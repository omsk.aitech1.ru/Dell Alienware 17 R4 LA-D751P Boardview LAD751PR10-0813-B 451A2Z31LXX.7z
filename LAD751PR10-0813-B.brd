# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB_OC0#: length 236.5
  TOP w0.114: UU1.13 20.3,45.33 19.76,45.88 18.49,45.88 v1(18.18,46.19) 17.98,46.39 v2(17.6,46.39)
  IN3 w0.127: v2(123.64,13.65) 122.53,14.76 115.73,14.76 111.28,10.32 104.95,10.32 103.96,11.31 55.66,11.31 53.73,13.24 46.27,13.24 43.47,16.03 42.74,16.03 42.33,16.45 42.33,17.23 38.55,21.01 38.55,22.83 36.78,24.61 36.27,24.61 35.19,25.69 35.19,26.13 34.84,26.47 34.84,35.7 33.47,37.08 33.47,40.04 29.47,44.04 27.95,44.04 26.42,45.56 23.25,45.56 22.68,46.13 17.85,46.13 v2(17.6,46.39)
  IN6 w0.081: v2(205.51,16.04) 204.88,16.67 204.1,16.67 202.89,17.88 202.89,20.73 201.71,21.92 201.71,25.03 201.15,25.59 191.81,25.59 191,26.4 184.85,26.4 183.66,25.22 183.66,23.22 180.52,20.08 159.95,20.08 156.98,17.11 129.21,17.11 125.74,13.65 v2(123.64,13.65)
  BOTTOM w0.114: RPH6.4 205.68,15.87 v2(205.51,16.04) 205.51,16.11 206.32,16.92 206.32,17.56 206.45,17.69 206.45,18.44 UH1.AD43
USB_OC1#: length 140.3
  TOP w0.102: CU17.1 319.39,24.3 319.2,24.11 v2(319.2,23.73) 319.26,23.66 UU3.3
  IN6 w0.102: v2(206.69,16.09) 208.79,16.09 208.92,16.21 212.24,16.21 212.86,15.59 213.84,15.59 214.43,16.19 219.18,16.19 220.24,15.13 226.93,15.13 227.34,15.55 230.5,15.55 230.91,15.14 234.08,15.14 234.65,15.71 239.99,15.71 242.2,13.49 251.91,13.49 253.56,15.15 255.55,15.15 256.11,15.7 258.59,15.7 259.19,15.11 271.32,15.11 271.41,15.02 291.66,15.02 293.5,13.18 299.92,13.18 300.17,12.92 302.21,12.92 302.72,13.44 315.05,13.44 317.37,11.12 v2(318.73,11.12)
  BOTTOM w0.089: v2(206.69,16.09) 206.7,16.1 206.7,17.33 207.03,17.66 207.03,18.44 206.27,19.2 UH1.AD42
  BOTTOM w0.102: RPH6.3 205.19,14.44 205.37,14.26 206.19,14.26 206.26,14.32 206.26,14.76 206.79,15.3 v1(206.79,15.51) 206.79,15.99 v2(206.69,16.09) ; v2(318.73,11.12) 318.31,11.53 318.31,12.32 319.2,13.2 v2(319.2,23.73)
USB_OC2#: length 8.4
  BOTTOM w0.102: UH1.AD39 205.38,19.56 205.38,18.35 205.42,18.3 205.42,18.05 205.16,17.78 205.13,17.78 204.19,16.84
  BOTTOM w0.107: 204.19,16.84 204.19,15.16
  BOTTOM w0.114: 204.19,15.16 RPH6.1 204.19,14.71 v4(202.94,13.47)
USB_OC3#: length 4.5
  BOTTOM w0.102: v1(204.54,16.41) 205.05,16.92 205.43,16.92 205.8,17.3 205.8,17.93 205.67,18.07 UH1.AC44
  BOTTOM w0.107: v1(204.54,16.41) 204.45,16.33 204.45,15.39 204.69,15.16 RPH6.2
USB_PWR_EN: length 23
  TOP w0.102: v2(314.26,24.74) 314.26,24.74 315.35,25.83 v1(315.77,25.83) RE645.2 318.63,25.04 CU16.1 318.46,23.87 318.26,23.66 UU3.4
  TOP w0.107: v2(305.92,17.81) UE5.117
  IN1 w0.102: v2(305.92,17.81) 307.6,17.81 308.05,18.26 312.47,18.26 312.85,18.64 312.85,22.93 313.51,23.59 313.51,23.99 v2(314.26,24.74)
USBC_PWR_EN: length 359.7
  TOP w0.102: v2(318.51,54.9) 318.26,55.15 UE10.5 ; RE649.2 20.07,51.85 v2(20.58,51.34)
  IN2 w0.102: v2(322.65,33.39) 322.36,33.69 321.53,33.69 316.45,28.61 310.31,28.61 306.89,25.19 305.23,25.19 304.54,24.51 294.5,24.51 290.61,28.4 284.04,28.4 279.6,32.85 276.18,32.85 266.88,42.15 240.74,42.15 239.23,43.66 233.45,43.66 231.18,41.38 225.25,41.38 221.66,44.98 216.7,44.98 216.18,45.49 212.95,45.49 211.46,46.98 210.46,46.98 209.52,47.92 209.52,48.83 206.61,51.73 202.78,51.73 200.75,49.7 192.64,49.7 190.8,47.87 187.63,47.87 180.32,40.57 176.79,40.57 176.21,41.15 176.21,45.49 175.36,46.34 174.49,46.34 174.02,46.8 172.59,46.8 172.49,46.91 124.29,46.91 123.79,47.4 107.58,47.4 107.05,46.87 96.5,46.87 96.22,47.15 95.07,47.15 94.94,47.27 89.99,47.27 89.35,46.64 67.79,46.64 66.7,47.72 58.45,47.72 57.97,48.2 45.99,48.2 45.72,48.47 45.01,48.47 44.83,48.29 35.76,48.29 34.71,49.35 26.98,49.35 24.99,51.34 v2(20.58,51.34)
  BOTTOM w0.102: v2(318.51,54.9) 318.91,54.5 v1(318.91,52.67) 318.91,52.13 319.21,51.82 319.21,51.08 320.32,49.97 320.32,41.73 321.64,40.42 321.64,39.44 321.8,39.27 321.8,38.14 321.48,37.82 321.48,36.53 322.34,35.68 322.34,33.7 v2(322.65,33.39) ; UU7.6 20.37,51.13 v2(20.58,51.34) 20.77,51.15 CU35.1
USBCHG_DET#: length 37
  TOP w0.102: v1(34.28,50.03) DU6.2
  TOP w0.508: CU27.2 32.06,45.6 32.65,46.18 RU4.2 32.83,47.12 CU28.1 33.28,47.14 v2(33.7,47.56) 34.28,48.13 DU6.2
  IN1 w0.508: v2(33.7,47.56) 33.7,47.21 31.57,45.08 31.57,37.85 31.2,37.48 29.74,37.48 29.41,37.81 26.78,37.81 24.34,35.38 16.15,35.38 15.25,34.47 14.58,34.47 13.78,33.68 JUSB1.10
USBCHG_DET_D: length 37.5
  TOP w0.102: v2(27.86,46.87) v1(27.86,47.47)
  TOP w0.254: PD100.3 59.33,44.59 v2(59.6,44.32)
  TOP w0.381: UU5.4 27.99,45.11 27.86,45.23 RU6.1 v2(27.86,46.87)
  IN3 w0.254: v2(59.6,44.32) 58.09,44.32 57.22,45.18 55.19,45.18 54.56,44.55 50.24,44.55 48.81,45.97 33.12,45.97 32.84,45.69 28.38,45.69 27.86,46.21 v2(27.86,46.87)
USBCHG_DET_EC#: length 305.1
  TOP w0.107: DU6.1 31.14,48.52 v1(30.36,47.75) 29.7,47.09 v2(29.7,46.96) CU29.1 RU6.2 ; UE5.75 297.14,9.1 296.96,9.28 296.96,12.94 296.83,13.07 296.83,17.87 295.17,19.52 295.17,22.39 v2(295.41,22.63)
  IN2 w0.102: v2(295.41,22.63) 295.09,22.63 290.23,27.49 283.64,27.49 279.81,31.31 276.42,31.31 266.68,41.05 244.69,41.05 243.99,40.35 241.23,40.35 239.86,41.73 238.89,41.73 237.88,42.74 235.7,42.74 234.87,41.9 232.99,41.9 231.56,40.47 230.51,40.47 229.89,39.85 224.61,39.85 220.59,43.87 215.31,43.87 214.9,44.28 213,44.28 212.77,44.05 212.63,43.9 211.47,43.9 211.24,44.13 202.96,44.13 202.67,44.42 198.94,44.42 198.26,43.73 190.9,43.73 190.28,43.12 185.91,43.12 181.13,38.33 134.07,38.33 133.27,39.14 112.95,39.14 107.08,45 98.95,45 98.78,45.17 96.85,45.17 96.29,45.73 64.72,45.73 64.02,46.43 57.91,46.43 57.43,46.9 53.17,46.9 52.45,46.19 49.09,46.19 48.7,46.58 33.47,46.58 32.93,46.04 30.62,46.04 v2(29.7,46.96)
VCIN0_PH1: length 301.3
  TOP w0.203: UE5.109 306.23,14.61 305.89,14.95 v2(305.89,15.08)
  TOP w0.254: PH1.1 153.72,110.42 v2(153.94,110.2) ; PR25.1 PR24.1 312.17,50.95 312.17,50.38 311.44,49.65 311.44,49.02 v1(309.31,46.89) 308.11,45.69 v2(307.79,45.69)
  IN2 w0.254: v2(163.27,34.26) 163.27,34.21 164.96,32.52 180.37,32.52 182.11,34.26 190.92,34.26 191.65,34.99 191.65,37.97 192.85,39.17 195.46,39.17 195.99,39.71 197.35,39.71 197.81,39.25 210.19,39.25 210.52,39.58 211.71,39.58 212.49,40.35 214.53,40.35 214.93,40.75 217.77,40.75 217.81,40.79 221.17,40.79 224.02,37.94 230.19,37.94 230.47,37.66 230.87,37.66 231.39,38.18 239.39,38.18 240.62,36.95 246.78,36.95 248.56,35.16 248.56,31.14 249.42,30.28 256.22,30.28 256.61,30.67 268.47,30.67 269.9,29.24 275.32,29.24 276.4,28.16 278.31,28.16 278.74,27.74 280.85,27.74 288.3,20.29 296.68,20.29 297.36,19.61 298.15,19.61 298.86,20.32 301.71,20.32 303.61,22.22 306.85,22.22 v2(307.3,22.67)
  IN3 w0.254: v2(153.94,110.2) 153.75,110.2 152.59,109.05 152.59,102.07 152.05,101.53 152.05,97.42 152.84,96.62 152.84,87.23 155.71,84.36 166,84.36 168.66,81.69 168.66,59.12 167.84,58.29 167.84,53.4 164.85,50.42 164.85,46.67 164.09,45.91 164.09,38.92 163.27,38.1 v2(163.27,34.26) ; v2(307.79,45.69) 307.61,45.69 307.13,45.21 306.42,45.21 305.68,44.46 305.68,41.89 305.01,41.22 305.01,38.77 304.11,37.88 304.11,32.61 304.62,32.1 304.62,28.92 305.95,27.59 305.95,26.45 306.82,25.58 306.82,24.51 307.3,24.02 v2(307.3,22.67)
  BOTTOM w0.254: v2(305.89,15.08) 307.3,16.5 v2(307.3,22.67)
VCIN1_AC_IN: length 428.8
  TOP w0.089: 219.18,16.89 217.75,15.46 217.75,15.16
  TOP w0.102: 219.18,16.89 220.8,18.51 220.8,19.35 221.36,19.91 221.36,21.21 222.13,21.98 222.13,22.52 222.82,23.21 222.82,24.43 222.32,24.92 222.32,26.89 v2(223.95,28.52) ; 217.75,15.16 v2(217.75,13.28) ; QE3.5 325.83,42.51 325.64,42.32 324.73,42.32 323.94,41.53 322.55,41.53 v2(322.14,41.94)
  TOP w0.107: UE5.110 308.09,15.01 308.4,14.7 v2(308.4,14.24) 308.4,14.03 308.64,13.79 CE40.2
  TOP w0.203: PR714.2 56.59,25.57 v2(56.59,25.5) 57.04,25.04 PU700.5
  TOP w0.254: v2(102.56,46.42) 102.56,46.49 v1(104.39,48.32) 108.78,52.71 108.78,58.01 115.4,64.62 115.4,74.78 117.53,76.92 PR731.1
  IN1 w0.102: v2(322.14,41.94) 322.14,38.29 321.6,37.74 318.78,37.74 318.59,37.94 313.12,37.94 312.81,38.26 303.16,38.26 302.25,37.34 291.67,37.34 287.86,33.53 278.02,33.53 277.28,34.27 272.99,34.27 265.32,41.94 251.51,41.94 249.89,40.33 249.89,38.16 245.67,33.94 244.56,33.94 243.7,33.08 243.7,32.41 241.59,30.31 239.47,30.31 239.18,30.02 239.18,26.92 236.04,23.78 236.04,23.02 235.63,22.61 228.79,22.61 227.11,24.29 227.11,28.06 226.56,28.61 224.04,28.61 v2(223.95,28.52)
  IN3 w0.102: v2(322.14,41.94) 322.14,38.11 321.68,37.65 321.68,35.71 315.31,29.34 315.31,19.68 315.01,19.39 315.01,18.7 311.08,14.76 310.08,14.76 309.56,14.24 v2(308.4,14.24)
  IN4 w0.254: v2(217.75,13.28) 213.33,13.28 211.34,15.27 205.32,15.27 205.05,15 200.81,15 198,17.81 194.76,17.81 193.72,16.77 183.39,16.77 180.54,13.93 175.82,13.93 173.28,16.47 109.75,16.47 105.88,20.34 105.88,24.33 103.99,26.21 103.99,29.59 102.56,31.02 v2(102.56,46.42) 100.06,48.93 97.75,48.93 95.73,46.91 93.39,46.91 91.61,45.13 87.59,45.13 69.31,26.85 57.95,26.85 v2(56.59,25.5)
  BOTTOM w0.107: DH1.1 223.78,28.35 v2(223.95,28.52)
  BOTTOM w0.254: v2(56.59,25.5) 56.71,25.5 57.24,24.97 PR715.1
VCIN1_ADP_PROCHOT: length 18.8
  TOP w0.107: v2(305.7,12.48) 306.36,11.81 UE5.102
  TOP w0.254: v2(295.09,6.93) v1(295.09,5.67) 294.83,5.4 PR26.2 PC13.2 PR23.1
  IN4 w0.102: v2(295.09,6.93) 296.41,6.93 297.56,8.07 301.29,8.07 v2(305.7,12.48)
VCIN_ BATT_TEMP: length 283.3
  TOP w0.203: UE5.63 289.76,10.21 CE35.2
  TOP w0.254: CE35.2 289.63,9.41 289.29,9.07 285.5,9.07 285.25,9.33 v2(285.25,10.95) ; PR727.1 54.66,17.74 v2(54.35,17.43) ; PD3.2 79.72,9.85 PR22.2 81.31,9.92 81.87,9.35 PR16.1 81.87,8.36 PC14.1 85.78,7.82 86.62,8.66 v1(86.62,14.55) v2(86.62,17.81)
  IN4 w0.254: v2(54.35,17.43) 54.35,14.65 56.97,12.03 80.84,12.03 v2(86.62,17.81)
  IN6 w0.254: v2(86.62,17.81) 92.4,12.04 104.01,12.04 107.32,8.73 111.33,8.73 111.83,8.22 122.82,8.22 123.9,9.3 128.15,9.3 131.33,12.48 163.24,12.48 166.04,15.27 169.64,15.27 173.26,11.65 181.35,11.65 186.9,6.11 206.9,6.11 208.02,7.24 223.41,7.24 224.6,6.05 250.31,6.05 252.1,7.84 252.1,11.15 253.34,12.39 265.18,12.39 266.04,13.24 268.36,13.24 269.21,12.39 279.05,12.39 280.48,10.95 v2(285.25,10.95)
VCOUT0_MAIN_PWR_ON#: length 288.8
  TOP w0.107: v2(308.4,12.61) UE5.104
  TOP w0.254: PR114.1 58.77,47.89 59.17,48.29 v2(59.17,48.47)
  IN2 w0.102: v2(59.17,48.47) 60.91,48.47 61.43,47.95 66.8,47.95 67.84,46.91 82.7,46.91 84.71,48.91 85.61,48.91 86.31,48.21 95.46,48.21 95.49,48.19 96.38,48.19 96.71,48.52 108.08,48.52 109.28,49.72 123.68,49.72 124.34,49.05 127.39,49.05 128.68,47.77 172.85,47.77 172.95,47.67 174.38,47.67 174.84,47.2 178.26,47.2 178.96,46.51 180.09,46.51 181.21,47.63 182.5,47.63 186.28,51.41 201.23,51.41 202.42,52.6 207.02,52.6 210.45,49.17 210.45,48.22 210.82,47.85 215.81,47.85 216.19,48.23 222.61,48.23 223.08,47.75 223.08,45.73 223.86,44.96 223.86,44 225.61,42.25 230.82,42.25 233.48,44.9 242.57,44.9 243.67,43.8 268.07,43.8 273.08,38.78 273.08,36.9 275.45,34.53 275.64,34.53 276.88,33.29 283.29,33.29 285.68,30.91 287.14,30.91 287.59,30.46 290.48,30.46 293.2,27.74 294.31,27.74 295.56,26.49 303.64,26.49 304.5,27.34 306.12,27.34 v2(306.52,26.94)
  BOTTOM w0.102: v2(306.52,26.94) v1(306.52,27.74)
  BOTTOM w0.107: v2(306.52,26.94) 306.52,24.54 307.71,23.36 307.71,13.3 v2(308.4,12.61)
VCOUT1_PROCHOT#: length 3
  TOP w0.107: UE5.103 308.3,12.21 308.5,12.01 RE84.2 RE85.2
VD33STB: length 3.1
  TOP w0.102: v2(36.86,29.43) 36.46,29.43 v1(36.05,29.03)
  TOP w0.107: RA25.2 37.29,28.79 36.86,29.22 v2(36.86,29.43)
  BOTTOM w0.107: UA1.10 36.44,29.51 36.51,29.43 v2(36.86,29.43)
VGA_EN: length 5.3
  BOTTOM w0.102: v1(123.5,158.48) 124.96,158.48 125.23,158.21 RM87.1 125.23,157.91 124.9,157.58 RM14.2
  BOTTOM w0.107: RM14.2 125.13,157.04 125.77,157.68 UM8.26
VGA_SMB_CK2: length 73
  IN1 w0.081: v2(203.3,148.61) 204.76,148.61 205.23,149.07 205.23,149.32 205.04,149.51 203.07,149.51 202.53,148.97 202.53,144.19 200.85,142.51 200.85,140.11 201,139.95 201,135.18 202.64,133.55 202.64,130.65 199.65,127.67 199.19,127.67 198.02,126.5 198.02,124.4 198.55,123.87 198.55,123.22 198.93,122.84 202.46,122.84 202.73,122.58 204.8,122.58 204.96,122.74 206.48,122.74 207.32,121.91 209.78,121.91 209.98,121.7 209.98,121.59 210.07,121.51 210.25,121.51 210.36,121.4 v2(210.36,121.24)
  IN6 w0.081: v2(223.57,114.65) 223.31,114.39 223.15,114.39 222.77,114.77 222.77,117.44 221.96,118.25 216.8,118.25 216.61,118.06 212.73,118.06 212.31,118.48 212.31,119.63 211.45,120.5 210.34,120.5 210.17,120.67 210.17,121.05 v2(210.36,121.24)
  BOTTOM w0.1: UG9.BJ8 v2(223.57,114.65)
  BOTTOM w0.114: v2(210.36,121.24) 210.16,121.04 210.16,120.82 209.91,120.57 208.97,120.57 208.3,121.24 208.3,122.1 208.19,122.21 208.05,122.21 RG17.1 ; v2(203.3,148.61) QG6.4
VGA_SMB_DA2: length 73.5
  IN1 w0.081: v2(207.03,150.86) 207.03,150.65 205.99,149.61 205.23,149.61 205.12,149.72 202.98,149.72 202.32,149.06 202.32,144.28 200.64,142.6 200.64,140.02 200.8,139.86 200.8,135.1 202.43,133.46 202.43,130.74 199.57,127.88 199.1,127.88 197.81,126.58 197.81,124.31 198.34,123.78 198.34,123.14 198.84,122.63 202.38,122.63 202.64,122.37 204.89,122.37 205.05,122.53 206.4,122.53 207.23,121.7 209.69,121.7 209.77,121.62 v2(209.77,121.24)
  IN6 w0.081: v2(209.77,121.24) 209.96,121.05 209.96,120.58 210.25,120.29 211.36,120.29 212.1,119.55 212.1,118.39 212.64,117.85 216.64,117.85 216.87,118.08 221.89,118.08 222.6,117.37 222.6,114.7 223.08,114.22 223.3,114.22 v2(223.57,113.95)
  BOTTOM w0.1: v2(223.57,113.95) UG9.BH8
  BOTTOM w0.114: v2(207.03,150.86) 207.03,150.65 207.15,150.54 207.15,150.15 206.9,149.91 QG6.1 ; v2(209.77,121.24) 209.92,121.09 209.92,120.92 209.81,120.81 209.07,120.81 208.54,121.34 208.54,122.2 208.29,122.45 208.05,122.45 RG18.1
VL: length 3
  BOTTOM w0.102: PC111.1 v1(52.69,42.32)
  BOTTOM w0.203: PC111.1 53.73,42.83 53.73,42.84 53.93,43.04 53.93,43.43 53.86,43.5 PU100.13
VR_HOT#: length 363
  TOP w0.114: RE78.1 v2(308.48,5.67)
  IN1 w0.081: v2(308.48,5.67) 305.54,8.61 300.27,8.61 299.1,9.78 299.1,11.46 298.22,12.34 296.77,12.34 295.67,13.44 293.34,13.44 291.29,15.48 273.08,15.48 271.65,14.06 267.67,14.06 266.08,12.47 255.76,12.47 254.98,13.25 241.72,13.25 239.78,11.32 229.33,11.32 229,11 212.54,11 212.22,10.67 207.05,10.67 206.57,10.2 206.56,10.2 206.4,10.04 202.87,10.04 202.1,9.27 193.35,9.27 191.96,10.65 186.12,10.65 174.84,21.94 131.36,21.94 v2(131.07,22.23)
  IN3 w0.127: v2(124.02,134.53) 124.02,134.47 124.6,133.89 126.44,133.89 127.71,132.62 127.71,115.2 128.17,114.74 128.95,114.74 129.72,113.97 129.72,104.78 128.52,103.59 128.52,102.56 125.33,99.37 125.33,98.75 119,92.42 119,73.07 109.9,63.97 109.9,61.45 105.48,57.03 105.48,40.91 107.39,38.99 107.39,32.16 102.82,27.59 102.82,26.77 101.04,24.99 101.04,23.66 99.06,21.69 v2(98.42,21.69)
  IN6 w0.081: v2(98.42,21.69) 98.83,21.27 98.83,17.88 98.91,17.8 111.31,17.8 114.37,20.86 129.71,20.86 v2(131.07,22.23)
  BOTTOM w0.114: PR504.1 124.06,134.57 v2(124.02,134.53) 124.06,134.49 PC501.1
VR_PWRGD: length 375.1
  TOP w0.102: v1(122.75,133.84) v2(123.44,134.53)
  TOP w0.107: v2(305.06,12.48) 306.12,11.41 UE5.101 ; v2(123.44,134.53) 123.45,134.54 PR520.1
  IN1 w0.097: 211.72,36.37 211.72,40.1 212.39,40.77 212.39,42.08
  IN1 w0.102: 211.72,36.37 211.72,35.16 213.12,33.76 214.89,33.76 215.27,33.37 218.77,33.37 219.34,32.8 219.34,28.76 223.71,24.4 223.71,18.93 v2(224.04,18.6) ; v2(206.13,54.9) 206.13,54.57 210.11,50.59 210.11,48.44 210.83,47.72 210.83,43.85 212.39,42.28 212.39,42.08
  IN2 w0.102: v2(305.06,12.48) 304.27,13.27 292.09,13.27 291.16,14.19 279.62,14.19 277.71,16.11 274.5,16.11 273.27,17.34 268.32,17.34 267.46,18.2 265.79,18.2 264.44,19.55 259.59,19.55 256.26,22.89 256.26,23.39 255.85,23.79 248.34,23.79 246.86,22.32 246.86,20.66 247.96,19.55 247.96,18.24 245.65,15.92 234.54,15.92 234.22,15.6 230.36,15.6 227.95,18.02 224.62,18.02 v2(224.04,18.6)
  IN3 w0.089: 129.44,105.21 129.44,105.97 129.49,106.02 129.49,113.61 129.44,113.65
  IN3 w0.102: 129.44,113.65 128.8,114.29 128.02,114.29 127.29,115.03 127.29,132.4 126.25,133.45 124.34,133.45 123.44,134.35 v2(123.44,134.53) ; 129.44,105.21 122.07,97.84 122.07,96.08 118.56,92.58 118.56,91.22 117.42,90.08 117.42,72.09 108.39,63.06 108.39,60.53 105.06,57.2 105.06,53.49 104.7,53.14 104.7,38.08 v2(106.08,36.7)
  IN6 w0.102: v2(106.08,36.7) 106.8,35.98 116.34,35.98 117.24,36.87 119.7,36.87 121.63,34.94 168.89,34.94 169.25,35.3 179.35,35.3 186.73,42.68 186.73,51.13 189.25,53.65 194.88,53.65 196.38,52.15 199.29,52.15 202.36,55.22 205.81,55.22 v2(206.13,54.9)
VR_SVID_ALERT#: length 16.6
  IN6 w0.081: v2(128.39,120.02) 128.39,129.79 126.72,131.47 v2(125.85,131.47)
  BOTTOM w0.114: v2(125.85,131.47) 125.84,131.49 PR509.2 ; v2(128.39,120.02) 128.14,119.77 RH152.2 126.73,120.68 RH153.1
VR_SVID_CLK: length 26.2
  IN6 w0.081: v2(124.95,131.47) 125.41,131.93 126.91,131.93 128.86,129.99 128.86,122.71 130.03,121.54 130.03,121.42 129.61,121 129.61,120.89 129.78,120.72 129.9,120.72 130.32,121.13 130.43,121.13 133.92,117.64 136.28,117.64 136.53,117.39 136.53,117.07 v2(136.92,116.68)
  BOTTOM w0.076: v2(136.92,116.68) 137.29,116.31 CPU1.BH32
  BOTTOM w0.114: v2(124.95,131.47) PR507.1
VR_SVID_DATA: length 27.4
  IN6 w0.081: v2(137.43,113.76) 135.01,113.76 131.59,117.18 129.97,117.18 v2(128.33,118.81) 127.93,119.21 127.93,129.6 v2(126.46,131.08)
  BOTTOM w0.076: v2(137.43,113.76) 137.44,113.76 CPU1.BH29
  BOTTOM w0.114: RH151.2 v2(128.33,118.81) ; PR511.2 126.73,131.34 v2(126.46,131.08)
VROM_SEL: length 130.1
  TOP w0.102: UG16.10 197.57,110.28 197.87,109.98 197.87,109.44 198.05,109.26 198.13,109.26 198.15,109.24 198.26,109.24 v2(198.64,108.86) 198.64,108.67 198.42,108.45 197.83,108.45 197.51,108.78 UG16.7 ; v2(192.91,108.85) 193.13,108.63 193.39,108.63 193.85,108.17 RH589.2 ; RH588.2 220.02,26.5 219.72,26.19 218.41,26.19 217.76,26.85 v1(217.43,26.85) 216.73,26.85 216.29,26.41 v2(214.77,26.41)
  IN1 w0.089: v2(214.77,26.41) 213.2,27.97 212.61,27.97 210.77,29.81 210.77,31.08 210.6,31.25 209.14,31.25 208.54,31.84 206.69,31.84 204.97,33.56 204.97,37.36 204.55,37.78 204.08,37.78 202.54,39.31 201.52,39.31 201.1,39.73 201.1,41.16 200.44,41.82 197.67,41.82 197.4,42.08
  IN1 w0.102: v2(192.81,63.41) 191.99,62.59 191.99,60.56 191.67,60.23 191.67,58.79 191.44,58.56 191.44,56.76 192.31,55.89 192.31,50.79 195.14,47.95 195.84,47.95 196.98,46.81 196.98,42.51 197.4,42.08 ; v2(192.91,108.85) 193.38,108.38 198.27,108.38 198.64,108.75 v2(198.64,108.86)
  IN2 w0.102: v2(192.81,63.41) 192.4,63 192.05,63 191.82,63.24 191.82,66.58 188.34,70.06 188.34,92.75 187.15,93.94 187.15,96.53 186.74,96.95 186.74,101.1 189.12,103.49 190.66,103.49 191.21,102.94 195.16,102.94 195.39,103.17 195.39,103.61 193.4,105.59 193.4,108.35 v2(192.91,108.85)
  BOTTOM w0.089: UH1.BC27 214.78,26.42 v2(214.77,26.41)
VSB_N_001: length 7
  TOP w0.127: 72.89,11.28 v1(72.89,12.35)
  TOP w0.508: PC10.2 72.34,9.89 PR12.2 72.89,11.28 72.83,11.35 PR13.2 71.7,11.72 71.45,11.97 70.94,11.97 70.44,11.47 PQ3.3
VSB_N_002: length 3.8
  TOP w0.127: v1(69.91,5.95) PQ4.2
  TOP w0.508: PQ4.2 69.91,7.68 69.4,8.19 PC12.1 68.86,8.21 PR17.1
VSB_N_003: length 1.8
  TOP w0.508: PR13.1 71.34,10.43 70.56,9.66 PQ4.1
VSENSEN_L: length 3.5
  TOP w0.203: UA4.27 31.85,13.97 31.7,14.13
  TOP w0.508: RA61.2 29.8,15.33 RA79.1 30.67,14.96 30.93,14.7 31.14,14.7 31.7,14.14 31.7,14.13
VSENSEN_R: length 2.8
  TOP w0.203: 29.47,12.1 29.56,12.01 UA4.30
  TOP w0.508: RA65.2 RA82.1 29.4,12.1 29.41,12.1 29.47,12.1
VTTREF_1.2V: length 1.7
  BOTTOM w0.203: PC210.1 93.09,46.95 PU201.4
WAKE#: length 8.1
  TOP w0.114: v1(219.72,34.13) v2(218.8,34.13) 218.41,33.74 RH4.2
  BOTTOM w0.089: v2(218.8,34.13) 218.64,33.98 218.64,33.75 218.27,33.38 216.2,33.38 216.07,33.5 215.76,33.5 215.5,33.76 UH1.BC13
  BOTTOM w0.114: v2(218.8,34.13) 218.89,34.03 218.89,33.35 219.16,33.09 219.16,32.44 RH453.1
WAKE_PCH#: length 5.4
  BOTTOM w0.089: UH1.BD11 216.12,34.12 216.31,34.12 216.71,33.73 217.98,33.73 218.07,33.82 218.07,34.11
  BOTTOM w0.107: RH545.1 219.59,34.35 219.24,34.7 218.18,34.7 218.07,34.59 v1(218.07,34.2) 218.07,34.11
WL_OFF#: length 158.7
  TOP w0.089: RH520.2 212.42,15.78 212.92,16.28 v2(213.27,16.28)
  TOP w0.102: RN15.2 311.86,38.83 312.24,38.45 v2(313.19,38.45)
  IN6 w0.102: v2(318.73,12.16) 318.72,12.16 317.29,12.16 314.31,15.15 309.83,15.15 309.07,15.9 306.97,15.9 306.68,16.19 300.27,16.19 299.2,15.12 298.73,15.12 298.42,15.43 292.72,15.43 292.12,16.03 272.01,16.03 270.97,17.07 268.46,17.07 267.27,18.26 261.58,18.26 255.47,24.37 248.57,24.37 246.41,22.22 246.41,18.17 244.63,16.39 234.36,16.39 233.8,15.82 231.2,15.82 230.79,16.23 227.06,16.23 226.64,15.82 220.52,15.82 219.47,16.87 213.76,16.87 213.27,16.38 v2(213.27,16.28)
  BOTTOM w0.089: v2(213.27,16.28) 212.64,16.91 212.64,17.94 212.49,18.1 UH1.AU44
  BOTTOM w0.107: v2(313.19,38.45) 313.63,38.01 315.56,38.01 316.68,36.88 316.68,36.2 317.17,35.72 318.92,35.72 319.73,36.53 320.15,36.53 321.37,35.32 v1(321.37,28.72) 319.64,26.99 319.64,13.07 v2(318.73,12.16)
WL_OFF#_R: length 6.7
  TOP w0.102: RN15.1 312.33,39.76 CN9.1 313.44,39.28 313.51,39.34 RN5.2 313.88,38.97 v2(314.14,38.7) 314.51,38.34 v1(315.25,38.34)
  BOTTOM w0.102: v2(314.14,38.7) 314.07,38.77 JWLAN.48
WOOFER_SEL: length 66.7
  TOP w0.102: UE10.7 319.48,56.16 v2(319.25,55.92)
  TOP w0.107: JIO.21 v2(326.78,19.85)
  IN3 w0.102: v2(319.25,55.92) 318.96,55.63 315.92,55.63 315.43,55.14 315.43,54.46 316.26,53.63 316.26,51.28 320.3,47.24 334.28,47.24 335.69,45.83 335.69,20.86 334.03,19.21 327.43,19.21 v2(326.78,19.85)
XCLK_BIASREF: length 2.9
  TOP w0.107: v2(196.15,40.16) 197.1,41.1 RH71.2
  BOTTOM w0.107: UH1.E1 196.61,39.7 v2(196.15,40.16)
XDP_BPM#0: length 4.8
  BOTTOM w0.076: CPU1.BR27 132.68,112.31 132.11,112.31 131.9,112.52 131.62,112.52 130.66,111.56 130.15,111.56
  BOTTOM w0.114: 130.15,111.56 129.28,111.56 T112.1
XDP_BPM#1: length 2.4
  BOTTOM w0.076: CPU1.BT27 132.31,112.69 131.55,112.69 130.77,111.91 T113.1
XDP_HOOK0: length 11.7
  TOP w0.107: RC355.1 126.65,158.78 124.93,160.5 122.87,160.5 122.2,161.17 118.68,161.17 117.9,160.39 v2(117.9,159.9) 117.9,159.38 118.28,159 JPCMC.27
XDP_ITP_PMODE: length 245
  TOP w0.107: JPCMC.26 117.49,159.26 117.49,160.32 118.58,161.41 122.3,161.41 122.89,160.81 124.95,160.81 126.18,159.58 v2(126.43,159.58) 126.53,159.58 126.84,159.89 127.3,159.89 128.41,158.78 RC353.2
  IN1 w0.102: v2(196.96,62.55) 197.97,63.56 198.64,63.56 199.31,62.89 202.41,62.89 208.09,57.21 208.09,53.91 213.29,48.71 213.29,45.77 213.49,45.57 213.49,41.35 213.65,41.18 214.26,41.18 214.64,41.56 v2(214.64,41.9)
  IN2 w0.102: v2(196.96,62.55) 196.53,62.55 195.11,61.13 195.11,59.17 192.78,56.85 192.04,56.85 191.54,57.35 186.62,57.35 184.45,59.52 184.45,60.9 174.35,71 174.35,82.61 176.62,84.88 176.62,92.26 178.31,93.95 178.31,103.32 180.41,105.42 180.41,119.69 188.05,127.33 188.05,146.69 184.6,150.14 174.22,150.14 170.79,153.58 163.53,153.58 162.1,152.15 154.99,152.15 153.09,154.04 142.09,154.04 138.67,150.63 125.84,150.63 124.51,151.96 124.51,156.82 126.43,158.74 v2(126.43,159.58)
  BOTTOM w0.089: v2(214.64,41.9) 214.64,41.84 213.27,40.47 212.66,40.47 212.16,39.97 212.16,39.28 212.29,39.14 UH1.AT2
XDP_PRDY#: length 287
  TOP w0.114: v2(121.37,160.05) 121.09,159.77 JPCMC.34
  IN1 w0.081: v2(213.94,41.65) 213.94,41.71 214.51,42.28 214.51,45.35 213.51,46.35 213.51,49.19 210.6,52.11 210.6,52.7 v2(209.53,53.76)
  IN3 w0.127: v2(133.33,113) 133.68,112.65 134.63,112.65 136.29,110.98 136.29,106.78 133.33,103.82 132.9,103.82 132.73,103.65 132.73,103.65 131.92,102.84 131.92,100.34 129.73,98.15 129.73,97.04 129.6,96.91 129.6,96.42 128.23,95.05 128.23,75.38 115.78,62.93 114.56,62.93 111.61,59.98 111.41,59.98 109.08,57.64 109.08,42.29 114,37.37 114.82,37.37 115.51,36.67 v2(115.6,36.67)
  IN6 w0.081: v2(115.6,36.67) 116.02,37.09 119.79,37.09 121.69,35.2 131.44,35.2 131.45,35.19 168.75,35.19 169.22,35.67 179.41,35.67 186.48,42.74 186.48,51.18 189.16,53.87 195.02,53.87 196.52,52.37 199.2,52.37 202.32,55.49 206.93,55.49 208.66,53.76 v2(209.53,53.76) ; v2(121.37,160.05) 121.69,160.37 123.08,160.37 125.03,158.42 125.03,153.6 120.31,148.88 120.31,147.7 120.39,147.62 120.39,145.07 118.99,143.67 118.99,133.11 126.35,125.74 126.35,118.87 125.66,118.17 125.66,116.01 125.97,115.7 126.92,115.7 127.58,116.36 128.42,116.36 130.05,114.73 131.92,114.73 133.33,113.32 v2(133.33,113)
  BOTTOM w0.076: v2(133.33,113) 133.66,112.67 CPU1.BP27
  BOTTOM w0.089: 211.97,40.08 211.97,39.21 212.02,39.17 212.02,38.34 211.91,38.23 UH1.AT4
  BOTTOM w0.102: 211.97,40.08 212.55,40.66 213.2,40.66 213.94,41.4 v2(213.94,41.65)
XDP_PREQ#: length 290.4
  TOP w0.114: v2(120.79,160.05) 120.72,159.98 120.72,159.44 JPCMC.33
  IN1 w0.081: v2(215.27,41.92) 215.27,41.95 214.98,42.24 214.98,45.51 213.72,46.77 213.72,49.47 210.8,52.39 210.8,53.05 209.64,54.21 v2(209.15,54.21)
  IN3 w0.091: 130.87,102.92 132.95,105 132.95,113.79 132.37,114.37 v2(131.75,114.37)
  IN3 w0.127: 130.87,102.92 130.87,101.83 130.4,101.35 130.4,100.42 129.36,99.38 129.36,96.54 127.98,95.16 127.98,75.49 115.67,63.18 114.46,63.18 111.51,60.23 111.3,60.23 108.8,57.72 108.8,42.21 114.23,36.78 v2(114.82,36.78)
  IN6 w0.081: v2(131.75,114.37) 131.6,114.52 129.8,114.52 129.56,114.76 128.1,114.76 127.54,115.32 125.95,115.32 125.45,115.83 125.45,118.26 126.15,118.96 126.15,125.66 118.78,133.02 118.78,143.76 120.18,145.16 120.18,147.53 120.1,147.62 120.1,148.97 124.82,153.69 124.82,158.34 123,160.16 122.05,160.16 121.53,159.65 121.18,159.65 v2(120.79,160.05) ; v2(114.82,36.78) 115.34,37.3 119.93,37.3 121.82,35.41 131.53,35.41 131.53,35.4 168.62,35.4 169.09,35.88 179.33,35.88 186.27,42.82 186.27,51.27 189.08,54.07 195.11,54.07 196.61,52.58 199.12,52.58 202.24,55.7 207.04,55.7 208.53,54.21 v2(209.15,54.21)
  BOTTOM w0.076: CPU1.BL30 135.23,114.5 131.88,114.5 v2(131.75,114.37) 131.47,114.65 130.09,114.65 RH156.2
  BOTTOM w0.089: v2(215.27,41.92) 215.27,41.75 213.25,39.73 213.11,39.73 212.53,39.14 212.53,38.71 212.29,38.48 UH1.AT3
XDP_SPI_IO2: length 14.9
  TOP w0.107: RC354.1 127.42,161.79 v1(125.73,161.79) 122.57,161.79 122.14,162.22 118.58,162.22 116.98,160.62 116.98,158.52 JPCMC.24
XDP_SPI_SI: length 262.9
  TOP w0.102: RC9.2 126.55,160.34 v2(126.36,160.16)
  TOP w0.107: JPCMC.25 117.66,158.48 117.23,158.91 117.23,160.5 118.55,161.81 122.22,161.81 122.9,161.13 126.3,161.13 RC9.2
  IN4 w0.089: 198.57,32.67 193.27,32.67
  IN4 w0.102: 193.27,32.67 190.4,32.67 186.93,36.14 186.93,50.43 181.59,55.76 181.59,58.31 180.06,59.85 180.06,69.23 180.24,69.41 180.24,71.51 179.24,72.51 178.06,72.51 175.6,74.97 175.6,92.81 178.72,95.93 178.72,117.2 187.69,126.16 187.69,144.77 183.5,148.95 167.01,148.95 164.42,151.54 155.59,151.54 152.1,155.04 143.09,155.04 140.66,152.6 137.92,152.6 137.51,153.01 128.15,153.01 127.3,153.86 127.3,158.45 127.42,158.57 127.42,159.66 126.92,160.16 v2(126.36,160.16) ; v2(225.29,28.11) 224.64,28.76 224.64,28.83 224.42,29.05 220.54,29.05 220.16,28.67 215.65,28.67 214.94,27.96 211.72,27.96 210.83,27.07 210.83,22.49 209.52,21.18 208.95,21.18 207.63,22.5 205.71,22.5 201.43,26.78 201.43,29.81 198.57,32.67
  BOTTOM w0.107: RH1.1 224.67,24.56 225.21,25.09 v1(225.21,25.7) 225.21,26.55 225.29,26.64 v2(225.29,28.11)
XDP_TCK: length 234.9
  TOP w0.102: v4(195.53,60.31) 195.53,60.81 v2(195.58,60.87)
  TOP w0.107: JPCMC.31 119.79,160.14 120.35,160.7 121.92,160.7 122.59,160.02 123.99,160.02 v2(124.28,159.73) 124.34,159.67 124.34,159.25 125.95,157.64 126.45,157.64 126.62,157.47 RC348.1
  IN2 w0.102: v2(124.28,159.73) 124.28,151.86 125.74,150.4 138.77,150.4 142.19,153.82 152.99,153.82 154.89,151.92 162.19,151.92 163.62,153.35 170.69,153.35 174.13,149.91 184.51,149.91 187.82,146.6 187.82,127.43 180.19,119.79 180.19,105.52 178.12,103.46 178.12,94.08 176.39,92.35 176.39,84.97 174.13,82.71 174.13,70.9 184.22,60.8 184.22,59.42 186.53,57.12 191.44,57.12 191.94,56.62 192.88,56.62 195.53,59.27 195.53,60.81 v2(195.58,60.87)
  IN3 w0.102: v2(211.34,41.56) 211.34,41.88 209.51,43.7 203.27,43.7 199.95,47.02 199.95,50.92 199.27,51.59 197.35,51.59 194.18,54.77 194.18,57.37 195.53,58.71 195.53,60.81 v2(195.58,60.87)
  BOTTOM w0.089: v2(211.34,41.56) 211.08,41.31 211.08,40.46 210.79,40.17 210.79,38.93 210.6,38.74 UH1.AN3
XDP_TDI: length 270.3
  TOP w0.102: v2(136.16,115.98) 134.78,114.6 133.82,114.6 132.15,112.94 131.14,112.94 130.82,113.25 v4(129.28,113.25) 126.88,113.25 v2(126.6,113.53) ; JPCMC.29 119,159.61 118.75,159.86 v2(118.75,160.05)
  IN2 w0.102: v2(116.85,40.57) 117.6,39.82 133.83,39.82 134,39.66 180.38,39.66 187.91,47.19 191.09,47.19 192.92,49.02 199.04,49.02 203.24,44.82 206.92,44.82 207.22,45.12 211.73,45.12 212.3,44.54 v2(212.37,44.54)
  IN3 w0.089: 130.99,83.85 130.99,90.47 133.56,93.04 133.56,98.26 132.98,98.83 132.98,100.18 133.75,100.95 133.75,102.25 134.72,103.22 135.64,103.22 136.47,104.05 137.36,104.05 138.06,104.74 138.06,113.95 136.16,115.85 v2(136.16,115.98)
  IN3 w0.102: 130.99,83.85 130.99,74.85 118.6,62.46 118.6,60.55 117.5,59.45 115.33,59.45 114.94,59.05 114.94,53.41 112.96,51.44 112.96,48.25 114.5,46.71 114.5,41.33 115.26,40.57 v2(116.85,40.57)
  IN6 w0.102: v2(118.75,160.05) 118.86,159.94 119.44,159.94 120.43,158.96 123.2,158.96 124.16,157.99 124.16,154.22 118.12,148.18 118.12,132.16 124.79,125.49 124.79,115.13 126.39,113.53 v2(126.6,113.53)
  BOTTOM w0.076: CPU1.BL32 135.83,116.31 v2(136.16,115.98)
  BOTTOM w0.089: UH1.AP2 211.16,39.05 211.4,39.28 211.4,40.27 212.62,41.5 212.62,42.07
  BOTTOM w0.102: RH495.2 126.81,113.33 v2(126.6,113.53)
  BOTTOM w0.107: 212.62,42.07 212.62,44.28 v2(212.37,44.54)
XDP_TDO: length 261.7
  TOP w0.089: v2(131.26,113.75) 131.4,113.88 v4(131.96,113.88)
  TOP w0.102: JPCMC.35 121.41,158.96 121.87,159.42 v2(122.18,159.42)
  IN2 w0.102: v2(107.77,46.2) 107.87,46.3 112.31,46.3 113.33,45.28 113.33,40.7 114.44,39.59 133.74,39.59 133.9,39.43 180.47,39.43 188,46.96 191.18,46.96 193.01,48.79 198.94,48.79 203.15,44.59 211.68,44.59 v2(211.72,44.55)
  IN3 w0.089: 129.44,101.38 130.28,102.22 130.28,103.16 132.38,105.26 132.38,112.67 132.1,112.95 131.56,112.95 131.26,113.25 v2(131.26,113.75)
  IN3 w0.102: v2(107.77,46.2) 108.05,46.48 108.05,58.03 110.99,60.98 111.2,60.98 123.96,73.74 123.96,74.14 127,77.18 127,97.12 128.42,98.53 128.42,100.35 129.44,101.38
  IN6 w0.102: v2(131.26,113.75) 130.92,114.1 129.63,114.1 129.39,114.33 127.93,114.33 127.36,114.9 125.78,114.9 125.02,115.65 125.02,126.18 118.35,132.85 118.35,148.09 124.39,154.13 124.39,158.09 123.07,159.42 v2(122.18,159.42)
  BOTTOM w0.076: RH496.2 130.72,113.92 130.72,113.92 131.09,113.92 v2(131.26,113.75) 132.03,113.75 CPU1.BT28
  BOTTOM w0.089: UH1.AP1 211.16,40.29 212.29,41.42 212.29,42.08
  BOTTOM w0.102: 212.29,42.08 212.29,43.97 v2(211.72,44.55)
XDP_TMS: length 286.7
  TOP w0.114: v2(119.35,160.35) JPCMC.30 ; v2(109.19,40.86) v4(109.81,40.86)
  IN3 w0.089: 129.44,101.04 130.46,102.05 130.46,103.09 132.56,105.19 132.56,112.75 131.99,113.32 v2(131.71,113.32)
  IN3 w0.127: v2(109.19,40.86) 108.29,41.76 108.29,57.93 111.09,60.74 111.3,60.74 114.25,63.69 115.46,63.69 127.47,75.7 127.47,97.24 128.66,98.43 128.66,100.25 129.44,101.04
  IN6 w0.081: v2(131.71,113.32) 131.71,113.89 131.28,114.31 129.72,114.31 129.48,114.55 128.02,114.55 127.46,115.12 125.87,115.12 125.24,115.74 125.24,118.35 125.94,119.05 125.94,125.57 118.57,132.94 118.57,143.84 119.98,145.25 119.98,147.45 119.89,147.53 119.89,149.05 124.61,153.77 124.61,158.25 122.91,159.95 122.13,159.95 121.62,159.44 120.25,159.44 v2(119.35,160.35) ; v2(109.19,40.86) 111.73,40.86 113.14,39.46 120.4,39.46 121.23,38.62 179.43,38.62 184.99,44.19 184.99,51.84 188.49,55.34 192.45,55.34 196.36,59.24 200.14,59.24 202.01,57.37 204.54,57.37 v2(204.69,57.52)
  BOTTOM w0.076: CPU1.BP28 133.32,113.76 132.91,113.76 132.73,113.57 132.73,113.19 132.61,113.08 131.94,113.08 v2(131.71,113.32)
  BOTTOM w0.089: v2(131.71,113.32) 131.48,113.09 130.67,113.09 130.49,112.91 RH494.2 ; UH1.AR2 211.79,39 211.79,40.16 213.18,41.55 213.18,42.08
  BOTTOM w0.114: v2(204.69,57.52) 205.15,57.52 207.27,55.39 207.27,54.44 211.05,50.66 211.05,50.27 213.94,47.38 213.94,44.76 213.18,44 213.18,42.08
XMP1: length 157.3
  TOP w0.102: v2(121.81,19.48) v1(121.81,18.96) ; PR212.1 102.73,50.54 v2(104.05,50.54)
  IN2 w0.089: 191.87,27.3 192.79,27.3 195.36,24.73 195.36,24.24 196.05,23.55 200.21,23.55 200.61,23.95 202.45,23.95 202.88,24.38 203.92,24.38 204.5,23.8 206.02,23.8 206.36,24.14 206.36,24.76 206.57,24.98 206.87,24.98 206.96,24.89 208.02,24.89 208.4,24.51 209.97,24.51 211.49,26.03 211.49,26.61 211.77,26.89 215.49,26.89 216.59,27.99 216.59,28.71 v2(216.94,29.06)
  IN2 w0.102: 191.87,27.3 190.86,27.3 190.48,27.68 186.61,27.68 185.77,28.52 130.54,28.52 122.59,20.57 122.59,20.25 v2(121.81,19.48)
  IN4 w0.102: v2(121.81,19.48) 121.37,19.03 107.62,19.03 106.18,20.47 106.18,24.45 104.59,26.04 104.59,29.42 103.25,30.77 103.25,49.74 v2(104.05,50.54)
  BOTTOM w0.089: UH1.BD22 216.17,29.01 216.89,29.01 v2(216.94,29.06)
XMP2: length 158.6
  TOP w0.102: v1(107.34,52) 106.89,51.56 v2(106.89,51.53) 106.74,51.38 PR214.1
  IN2 w0.089: v2(216.43,29.37) 216.3,29.24 216.3,27.96 215.42,27.07 214.11,27.07 213.36,27.82 211.66,27.82 211.24,27.41 211.24,26.05 209.89,24.69 208.47,24.69 208.09,25.07 207.03,25.07 206.95,25.15 206.5,25.15 206.19,24.84 206.19,24.21 205.95,23.98 204.58,23.98 203.64,24.92 200.71,24.92 200.29,24.49 196.83,24.49 196.44,24.89 196.44,24.95 195.98,25.41 195.61,25.41 194.71,26.31 194.71,27.58 194.23,28.06 191.87,28.06
  IN2 w0.102: v2(121.13,19.48) 121.13,19.71 130.16,28.75 185.86,28.75 186.55,28.06 191.87,28.06
  IN4 w0.102: v2(106.89,51.53) 106.89,51.19 107.3,50.78 107.3,49.96 103.49,46.15 103.49,31.11 104.82,29.77 104.82,27.11 106.41,25.52 106.41,20.56 107.49,19.48 v2(121.13,19.48)
  BOTTOM w0.089: v2(216.43,29.37) 216.38,29.41 UH1.BE21
XTAL24_IN: length 10.5
  BOTTOM w0.114: YH2.1 193.87,45.55 193.87,44.04 193.47,43.63 CH47.1 193.47,43.15 193.37,43.05 RH72.1 193.37,41.87 193.81,41.44 193.81,39.05 193.83,39.02 193.83,38.73 194.07,38.49 194.07,38.04 194.23,37.88 194.23,37.68 194.76,37.15 UH1.A6
XTAL24_OUT: length 8.1
  BOTTOM w0.114: YH2.3 194.48,44.06 194.48,43.63 CH48.1 194.35,43.12 194.34,43.11 194.34,42.66 RH72.2 194.28,41.84 194.01,41.57 194.01,39.13 194.03,39.11 194.03,38.82 194.28,38.58 194.28,38.13 194.44,37.97 194.44,37.76 194.64,37.56 UH1.A5
XTALIN: length 15.5
  BOTTOM w0.089: YG1.1 210.79,117.53 210.94,117.38 211.79,117.38 CG75.2 212.71,117.33 212.86,117.33 RG99.1 213.5,117.2 213.92,117.2 v1(214.41,117.68) 214.68,117.96 221.71,117.96 222.84,116.82 222.84,116.29 222.47,115.91 UG9.BL6
XTALOUT: length 15.6
  BOTTOM w0.089: UG9.BM6 222.47,116.91 221.62,117.76 216,117.76 v1(215.78,117.55) 214.75,117.55 214.21,117 213.45,117 RG99.2 212.33,116.67 CG76.2 211.96,116.57 211.53,117 209.43,117 209.09,116.66 YG1.3
XTALOUTBUFF_R: length 11.9
  BOTTOM w0.089: v1(215.95,113.48) 215.54,113.89 RG98.1
  BOTTOM w0.102: RG98.1 215.54,114.65 216.47,115.57 216.47,116.67 217.3,117.51 221.35,117.51 222.12,116.73 222.12,115.4 UG9.BK6
XTLI: length 8.6
  BOTTOM w0.114: UL1.8 275.49,160.64 275.66,160.47 276.35,160.47 CL8.2 277.38,161.51 v1(279.07,161.51) 281.14,163.58 YL1.1
XTLO: length 10.2
  BOTTOM w0.114: YL1.3 280.04,165.02 280.04,163.2 v1(279.87,163.02) 278.84,162 277.76,162 277.3,162.47 276.39,161.55 276.39,161.12 276.16,160.9 275.67,160.9 275.53,161.04 UL1.7
N3691692: length 0.9
  TOP w0.102: 248.46,20.62 v1(249.32,20.62)
N3691782: length 1.5
  BOTTOM w0.102: v1(256.37,16.49) 257.18,17.3 PC309.1
N4123408: length 1.2
  BOTTOM w0.102: PC105.2 v1(58.44,46.93)
N4123550: length 0.9
  TOP w0.102: 43.29,29.52 43.13,29.52 v1(42.6,29)
N4123582: length 1.7
  TOP w0.102: PR111.2 42.35,32.1 v1(42.35,30.77)
N4124695: length 1.3
  BOTTOM w0.102: PR109.2 48.61,44.53 v1(48.22,44.93)
N16758539: length 1.5
  TOP w0.102: PC6416.1 v1(301.94,48.46)
N16760382:
  vias: v1(300.82,56.04)
N16761462: length 4
  TOP w0.203: PR6417.1 304.97,57.36 PC6437.1 ; PC6437.1 303.23,57.36 PR6418.1 ; PC6437.1 v1(304.1,56.38) 304.1,56.16 303.84,55.9 PU6400.7
N16767833: length 7.9
  TOP w0.127: v1(62.04,48.84) 61.65,48.45 PC112.1
  TOP w0.254: PR115.2 PR113.2 62.15,45.51 PR116.1 61.65,46.64 PC112.1 61.22,47.28 60.9,46.97 PR112.2 PR100.2 59.65,46.97 PR114.2
N16767857: length 81.9
  TOP w0.508: PR115.1 v2(64.33,44.35)
  IN3 w0.508: v2(64.33,44.35) 66.54,42.15 67.92,42.15 76.18,33.88 76.18,29.88 76.81,29.25 78.33,29.25 80.74,26.84 80.74,23.97 82.85,21.86 82.85,19.3 82.75,19.2 82.75,17.56 78.52,13.33 56.45,13.33 54.35,15.42 v2(47.76,15.42)
  BOTTOM w0.254: PD101.1 v1(52.26,16.14) 51.55,15.42 v2(47.76,15.42)
N16768121: length 3.2
  TOP w0.127: PR113.1 v1(61.91,43.16)
  TOP w0.254: PR113.1 61.4,44.35 61.16,44.59 61.16,44.99 60.91,45.24 PD100.1
N16788038: length 28
  TOP w0.508: PC723.2 PR725.2 v2(68.17,32.61) ; PR705.1 57.07,28.61 PC701.2 57.13,28.99 57.64,29.5 58.85,29.5 60.46,31.1 v1(60.46,31.52) v2(60.46,32.42)
  IN3 w0.508: v2(67.13,39.61) 67.13,33.65 v2(68.17,32.61)
  BOTTOM w0.508: v2(60.46,32.42) 60.65,32.42 61.69,33.46 66.26,33.46 66.98,34.17 PQ702.4 67.62,34.17 68.17,33.62 v2(68.17,32.61) 67.09,31.53 PQ700.1
N16788064: length 4.6
  TOP w0.254: v2(62.88,32.74) 63.57,32.74 ; 63.57,32.74 PR701.1 ; 63.57,32.74 PR700.2
  BOTTOM w0.254: PQ700.2 63.59,30.88 63.36,31.11 v1(63.36,31.67) 63.36,32.27 v2(62.88,32.74)
N16857461: length 3
  TOP w0.102: v1(187.88,63.7) 188.09,63.91 DS1.1 188.54,65.31 188.54,65.74 188.54,65.74 QS3.1
N16910514: length 5.5
  TOP w0.254: PR6426.2 303.71,60.61 v1(304.62,60.61) 305.13,60.61 305.9,59.84 PC6439.1 305.91,59.12 PR6416.2 305.9,58.27 PR6417.2
N17186119: length 7.4
  TOP w0.203: PU6400.10 302.64,55.6 301.82,56.42 301.25,56.42 300.81,56.86 300.81,59.18 v1(300.04,59.94) 298.86,59.94 PR6421.2
N17230071: length 1.6
  TOP w0.508: PR6405.2 307.41,50.32 PC6423.2
N17235867:
  vias: v1(306.18,55.35)
N17244731: length 340.5
  TOP w0.102: PR6.2 v1(318.3,45.51)
  IN2 w0.102: v2(313.53,26.23) 313.27,26.5 309.17,26.5 308.19,25.52 308.19,24.69 307.95,24.45 307.45,24.45 307.27,24.28 305.61,24.28 304.92,23.59 296.95,23.59 295.58,22.22 294.99,22.22 289.95,27.26 283.54,27.26 279.73,31.07 276.34,31.07 266.59,40.82 244.78,40.82 244.09,40.13 241.14,40.13 239.77,41.5 238.8,41.5 237.78,42.51 235.8,42.51 234.96,41.68 233.09,41.68 231.65,40.24 230.61,40.24 229.98,39.62 224.51,39.62 220.49,43.64 215.22,43.64 214.81,44.05 213.1,44.05 212.72,43.68 211.37,43.68 211.14,43.9 202.86,43.9 202.57,44.19 199.06,44.19 198.36,43.49 190.98,43.49 190.38,42.89 186,42.89 179.1,35.99 135.32,35.99 132.4,38.91 112.85,38.91 106.99,44.77 98.85,44.77 98.69,44.94 96.43,44.94 96.25,44.76 94.17,44.76 93.43,45.5 64.63,45.5 63.92,46.2 58.39,46.2 57.48,45.29 54.88,45.29 54.23,44.63 53.32,44.63 53.06,44.9 50.06,44.9 48.61,46.35 35.88,46.35 30.77,41.24 v2(28.27,41.24)
  IN3 w0.102: v2(313.53,26.23) 313.51,26.26 313.51,32.35 311.98,33.88 311.98,36.17 311.11,37.04 311.11,45.31 312.63,46.83 v2(317.13,46.83)
  BOTTOM w0.254: v2(28.27,41.24) 28.27,41.05 28.83,40.49 PL2.1
N17244796: length 0.9
  TOP w0.254: PR6418.2 303.23,58.27 PR6423.1
N17249165: length 3.9
  TOP w0.102: v1(296.44,57.38) PR6415.1
  TOP w0.254: PR6422.2 297.86,58.35 PC6434.1 297.8,58.26 PR6415.1
N17249236: length 1.2
  TOP w0.254: PR6414.1 299.43,58.27 PC6434.2
N17431129: length 2
  TOP w0.102: v1(303.15,27.87) 303.04,27.76 CE36.1
  TOP w0.107: CE36.1 302.13,27.69 RE89.1
N17434554: length 2.3
  TOP w0.107: RE74.2 308.89,12.9 307.98,13.81 UE5.107
N18168284: length 4.7
  BOTTOM w0.102: v1(91.08,39.94) 91.94,40.8 PR204.2
  BOTTOM w0.203: PU201.12 93.09,42.01 93.61,41.5 PC207.2
  BOTTOM w0.254: PR204.2 PC207.2
N18249914: length 3.3
  TOP w0.089: v2(203.63,25.89) v1(204.04,26.29)
  TOP w0.508: CH3.1 204.15,24.91 RH6.2 204.16,25.11 203.63,25.64 v2(203.63,25.89)
  BOTTOM w0.127: UH1.V28 v2(203.63,25.89)
N18250394: length 5
  TOP w0.089: v2(213.95,33.15) 213.93,33.13 v1(213.93,32.54)
  TOP w0.381: RH7.2 212.67,33.69 212.98,33.69 212.99,33.69 213.41,33.69 213.41,33.69 213.42,33.69 v2(213.95,33.15) 213.95,33.29 214.33,33.67 215.15,33.67 CH4.1
  BOTTOM w0.203: UH1.BA15 214.41,32.7 v2(213.95,33.15)
N18456729: length 1.6
  TOP w0.203: PU700.20 58.24,19.3 58.37,19.17 PR722.1
N18456733: length 1.8
  TOP w0.203: PU700.19 57.84,19.53 57.9,19.47 57.9,19.01 PR723.1
N18456739: length 5.7
  TOP w0.102: PQ705.3 61.31,16.85 v1(61.06,16.61)
  TOP w0.203: PR709.1 59.23,18.59 58.83,18.98 58.83,19.2 58.64,19.39 PU700.21
  TOP w0.254: PQ705.3 60.62,18.11 PR711.1 PR709.1
N18456772: length 4.6
  BOTTOM w0.127: v1(61.26,24.42) 61.07,24.23 v2(60.46,24.23)
  BOTTOM w0.508: v2(60.46,24.23) 60.33,24.1 60.33,23.15 PC711.2 60.84,22.32 61.78,21.38 PR707.2
N18456789: length 3.8
  BOTTOM w0.127: PR707.1 63.1,18.71 v4(63.67,19.29)
  BOTTOM w0.508: PR707.1 60.57,18.71 PD700.1
N18456799: length 1.7
  TOP w0.203: PU700.10 54.74,22.63 54.68,22.57 54.15,22.57 PR724.2
N18456859: length 1.2
  TOP w0.102: PR708.1 v1(62.81,20.47)
N18456884: length 5.2
  TOP w0.102: PR717.1 53.88,26.42 v1(53.43,26.88)
  TOP w0.203: PR717.1 53.88,24.7 PC718.2 54.76,24.69 54.94,24.86 55.97,24.86 56.24,24.59 PU700.7
N18456888: length 1.7
  TOP w0.203: PC720.2 54.61,23.8 54.98,23.43 PU700.8
N18456944: length 2.3
  TOP w0.102: v1(64.82,17.74) 64.73,17.82 PR710.2
  TOP w0.254: PR710.2 63.21,18.25 PQ705.1
N18456952: length 1.7
  TOP w0.203: PR720.2 54.3,22.01 54.53,22.23 PU700.11
N18456954: length 3.1
  TOP w0.102: PR721.2 53.81,21.09 v1(53.81,19.91)
  TOP w0.203: PR721.2 54.04,21.12 54.75,21.83 PU700.12
N18468008: length 129.8
  IN4 w0.102: v2(205.89,57.54) 205.71,57.72 205.71,62.26 199.14,68.83 199.14,68.84 199.01,68.97 191.99,68.97 191.55,69.41 191.55,94.53 191.07,95.01 191.07,101.23 192.74,102.91 192.74,103.55 193.7,104.51 193.7,107.5 195.65,109.45 195.65,112.15 196.08,112.58 197.42,112.58 198.22,113.38 198.22,114.4 197.49,115.12 197.49,115.23 197.11,115.61 196.55,115.61 196.3,115.87 196.3,117.26 197.24,118.2 199.27,118.2 199.55,118.48 199.55,119.08 199.32,119.31 199.32,120.85 201.38,122.9 201.38,123.55 200.18,124.75 200.18,126.86 199.06,127.98 199.06,129.52 200.32,130.79 200.32,136.93 v2(199.93,137.32)
  BOTTOM w0.102: v2(205.89,57.54) v1(206.89,56.54) 207.51,55.92 207.51,54.53 211.28,50.76 211.28,50.37 217.46,44.19 217.46,42.04 219.66,39.84 RH9.1 217.57,37.67 217.42,37.67 216.53,36.79 216.12,36.79 UH1.BD7 ; RH656.2 v2(199.93,137.32) RH657.2
N18650921: length 4.6
  BOTTOM w0.102: UV21.59 203.56,130.58 204.43,129.71 v1(204.43,128.99) 204.43,128.86 204.62,128.67 204.62,127.94 204.96,127.59 RV634.2
N18651247: length 4
  BOTTOM w0.102: RV635.2 205.08,128.54 204.97,128.65 204.97,129.6 204.54,130.04 204.54,130.12 v1(204.3,130.36) 204.29,130.36 203.67,130.98 UV21.58
N18786622: length 1.9
  TOP w0.089: v2(131.84,93.76) 132.62,94.54 T44.1
  BOTTOM w0.076: v2(131.84,93.76) 132.24,94.16 CPU1.BT2
N18786625: length 2.4
  TOP w0.089: v2(131.52,93.02) 131.69,92.85 T43.1
  BOTTOM w0.076: v2(131.52,93.02) 131.67,93.17 132.2,93.17 132.61,93.59 CPU1.BR1
N18786626: length 1.8
  TOP w0.089: T41.1 170.49,94.78 v2(171.06,94.21)
  BOTTOM w0.089: v2(171.06,94.21) 170.51,94.76 CPU1.E3
N18786627: length 1.1
  TOP w0.089: T82.1 137.22,116.98 v2(136.92,117.28)
  BOTTOM w0.076: CPU1.BJ33 136.59,116.96 v2(136.92,117.28)
N18786629: length 4.6
  BOTTOM w0.127: CPU1.B2 172.79,93.78 172.79,92.2 T85.1
N18786630: length 4.3
  TOP w0.089: v2(131.15,92.56) 131.22,92.49 T88.1
  BOTTOM w0.076: v2(131.15,92.56) 132.21,92.56 132.75,93.1 133,93.1 133.29,93.39 133.29,94.06 CPU1.BR2
N18786631: length 1.1
  TOP w0.089: v2(136.92,117.93) 137.19,118.21 T81.1
  BOTTOM w0.076: CPU1.BJ34 136.59,117.61 v2(136.92,117.93)
N18786633: length 5.3
  BOTTOM w0.127: T89.1 173.83,90.39 172.35,91.88 172.35,92.95 CPU1.C1
N18786635: length 1.5
  TOP w0.089: T73.1 137.41,103.53 v2(137.36,103.48)
  BOTTOM w0.076: CPU1.BJ16 137.36,103.53 v2(137.36,103.48)
N18786636: length 1.2
  TOP w0.089: T74.1 135.72,104.56 v2(135.91,104.37)
  BOTTOM w0.076: CPU1.BK16 136.26,104.02 v2(135.91,104.37)
N18786637: length 1.1
  TOP w0.089: T75.1 135.83,109.82 v2(135.88,109.87)
  BOTTOM w0.076: CPU1.BK24 136.26,110.24 v2(135.88,109.87)
N18786638: length 1.3
  TOP w0.089: v2(137.44,110.01) 137.44,109.49 T76.1
  BOTTOM w0.076: v2(137.44,110.01) 137.18,110.27 CPU1.BJ24
N18786639: length 1.1
  TOP w0.089: v2(134.63,116.97) 135,116.6 T66.1
  BOTTOM w0.076: CPU1.BM33 134.96,116.64 v2(134.63,116.97)
N18786640: length 1.5
  TOP w0.089: v2(137.42,102.77) 137.08,103.11 T68.1
  BOTTOM w0.076: v2(137.42,102.77) 137.38,102.77 137.05,102.44 CPU1.BJ14
N18786641: length 2.6
  TOP w0.089: v2(137.99,102.82) 137.51,102.34 T69.1
  BOTTOM w0.076: CPU1.BJ13 136.86,101.92 137.36,102.41 137.58,102.41 v2(137.99,102.82)
N18786642: length 1.6
  TOP w0.089: T67.1 135.53,117.89 v2(136.13,117.28)
  BOTTOM w0.076: CPU1.BL33 135.81,116.96 v2(136.13,117.28)
N18786644: length 7.7
  TOP w0.089: RH192.2 v1(172.7,110.11) 171.62,110.11 171.21,109.7 169.13,109.7 v2(168.74,110.09)
  BOTTOM w0.076: CPU1.J23 168.11,110.09 v2(168.74,110.09)
N18786646: length 7.4
  TOP w0.089: RH167.2 174.38,108.55 v1(173.49,108.55) 171.52,108.55 171.14,108.93 169.14,108.93 v2(168.76,109.32)
  BOTTOM w0.076: v2(168.76,109.32) 168.38,109.69 CPU1.H23
N19499560: length 1.8
  TOP w0.102: CA51.2 v1(21.19,26.8)
  TOP w0.203: CA51.2 22.04,27.2 22.05,27.2 UA2.B3
N19499567: length 2.4
  TOP w0.127: v1(23.85,29.95) RA46.2
  TOP w0.203: UA2.A1 22.88,28.73 23.02,28.86 RA46.2
N19499569: length 1.9
  TOP w0.102: v1(23.55,26.8) RA47.2
  TOP w0.203: UA2.A3 22.55,27.34 22.68,27.21 RA47.2
N19500898: length 0.8
  TOP w0.254: UA3.A3 19.92,22.03 RA39.2
N19500900: length 4
  TOP w0.203: UA3.A1 20.21,23.2 20.74,22.68 20.74,21.63 v1(21.17,21.2) 21.65,20.72 RA38.2
N19500925: length 2.3
  TOP w0.254: CA44.2 17.79,23.2 v1(18.15,22.83) 18.78,22.2 UA3.B3
N19501351: length 1.2
  BOTTOM w0.107: CA18.1 36.73,24.48 36.65,24.4 RA10.2
N19501355: length 2.3
  TOP w0.107: CA11.1 38.5,27.1 v2(38.39,26.98)
  BOTTOM w0.102: v1(38.59,26.36) 38.39,26.56 v2(38.39,26.98)
  BOTTOM w0.107: v2(38.39,26.98) RA2.2
N19501476: length 5.1
  BOTTOM w0.102: CA21.1 29.42,23.9 28.38,22.85 v1(28.38,22.64)
  BOTTOM w0.203: UA1.27 30.02,26.55 29.44,25.98 29.44,25.93
  BOTTOM w0.254: CA21.1 29.42,24.39 29.33,24.48 29.33,25.82 29.44,25.93
N19501478: length 3.4
  BOTTOM w0.203: v1(28.51,25.51) 29.62,26.61 UA1.28
  BOTTOM w0.254: v1(28.51,25.51) CA21.2
N19501482: length 2.4
  BOTTOM w0.203: UA1.25 30.82,26.33 30.37,25.89 v1(30.37,25.83) 30.36,25.82 30.36,25.25 CA20.1
N19501484: length 2.3
  BOTTOM w0.203: 30.06,26.09 30.42,26.44 UA1.26
  BOTTOM w0.254: CA20.2 29.84,25.87 30.06,26.09
N19501519: length 4.1
  TOP w0.102: v2(33.96,26.02) v1(33.96,26.64)
  TOP w0.254: CA85.1 34.82,25 34.81,24.99 33.99,24.99 CA23.1 33.98,25.59 33.96,25.62 v2(33.96,26.02)
  BOTTOM w0.107: UA1.18 33.62,26.61 33.96,26.27 v2(33.96,26.02)
N19501610: length 3.7
  BOTTOM w0.114: RA18.2 37.07,25.36 36.09,26.35 35.29,26.35 35.23,26.29 34.74,26.29 34.42,26.61 UA1.16
N19501675: length 8.1
  BOTTOM w0.102: RA68.1 28.95,38.25 28.95,38.01 28.58,37.64 v1(26.72,37.64)
  BOTTOM w0.203: CA4.1 30.82,35.71 UA1.46
  BOTTOM w0.381: RA68.1 30.56,37.17 CA3.1 30.56,36.3 30.81,36.06 CA4.1
N19501723: length 4.9
  TOP w0.102: v1(32.25,34.3) 32.25,34.35 v2(32.76,34.87)
  TOP w0.508: RA69.1 CA7.1 33.12,36.55 CA8.1 33.12,35.22 v2(32.76,34.87)
  BOTTOM w0.203: UA1.51 32.82,34.82 v2(32.76,34.87)
N19501777: length 5.4
  BOTTOM w0.102: CA26.1 27.33,34.51 26.87,34.97 26.66,34.97 v1(26.11,35.52)
  BOTTOM w0.203: 28.85,34.51 29.49,34.51 29.62,34.38 UA1.43
  BOTTOM w0.254: 28.85,34.51 28.6,34.25 28.09,34.25 27.83,34.51 CA26.1 CA27.1
N19501783: length 1.9
  BOTTOM w0.203: UA1.41 28.17,32.71
  BOTTOM w0.254: CA33.1 27.33,32.89 28,32.89 28.17,32.71
N19501785: length 5.3
  TOP w0.102: CA30.1 31.01,24.93 30.07,25.88 v1(30.07,26.16)
  TOP w0.254: v2(32.6,25.55) 32.28,25.24 CA31.1 31.77,24.86 31.69,24.93 CA30.1
  BOTTOM w0.203: v2(32.6,25.55) 32.36,25.79 32.36,26.33 32.42,26.39 UA1.21
N19501806: length 4.5
  TOP w0.102: v1(30.21,35.4) CA32.1
  TOP w0.254: CA32.1 v2(28.34,34.76)
  BOTTOM w0.203: v2(28.34,34.76) 28.53,34.95 29.55,34.95 30.02,34.49 UA1.44
N19501856: length 4.3
  TOP w0.102: CA25.1 v1(29.76,27.93)
  TOP w0.254: CA25.1 28.03,26.65 27.8,26.88 v2(27.76,26.88)
  BOTTOM w0.203: UA1.29 28.41,27.91 28.29,27.78 28.29,27.15 28.02,26.88 v2(27.76,26.88)
N19501872: length 4.5
  TOP w0.102: v1(28.76,30.47) 28.58,30.3 CA24.1
  TOP w0.254: CA24.1 28.47,29.32 28.01,28.86 28.01,28.54 27.63,28.16 v2(27.44,28.16)
  BOTTOM w0.203: v2(27.44,28.16) 27.62,28.16 28.17,28.71 UA1.31
N19501885: length 9.1
  TOP w0.254: v2(31.56,25.62) v1(32.19,26.25) 32.75,26.81 33.18,26.81 33.36,26.63 CA19.2
  BOTTOM w0.203: UA1.23 31.62,26.34 31.55,26.27 31.55,25.63 v2(31.56,25.62)
N19501890: length 4.9
  TOP w0.102: v1(33.04,20.09) 32.44,20.69 CA19.1
  TOP w0.254: RA16.1 30.29,21.8 RA15.2 31.76,22.15 31.76,21.75 32.2,21.3 CA19.1
N19529476: length 3.2
  TOP w0.203: v2(33.32,14.25) 33.45,14.12 UA4.23
  BOTTOM w0.102: v1(32.29,14.87) 32.91,14.25 v2(33.32,14.25)
  BOTTOM w0.457: v2(33.32,14.25) 33.32,14.56 33.78,15.01 CA74.1
N19529515: length 1.8
  TOP w0.107: UA4.40 29.28,8.01 29.19,8.1 CA66.2
N19529521: length 2.9
  TOP w0.102: 36.76,8.37 36.72,8.41 v2(36.72,8.54)
  TOP w0.107: UA4.3 37.11,8.01 36.76,8.37
  BOTTOM w0.107: v2(36.72,8.54) 37.25,8.54 CA71.2 37.46,9.54 RA51.2
N19529522: length 4.1
  TOP w0.102: 36.78,9.7 36.71,9.76 v2(36.71,9.94)
  TOP w0.107: 36.78,9.7 37.26,9.21 UA4.6
  BOTTOM w0.102: RA52.1 36.71,11.3 v1(36.69,11.32)
  BOTTOM w0.107: v2(36.71,9.94) 37.3,10.53 RA51.1 37.6,10.6 RA52.1
N19529526:
  vias: v1(39.54,8.24) v2(39.7,8.8) v2(40.29,8.8)
N19529531: length 3.4
  TOP w0.107: UA4.5 37.08,8.81 v2(36.72,9.18)
  BOTTOM w0.107: RA62.2 36.77,7.84 v1(36.56,8.05) 36.31,8.31 36.31,8.71 36.72,9.12 v2(36.72,9.18)
N19616464: length 16.2
  TOP w0.089: v1(217.13,117.7) CG231.1
  TOP w0.305: CG231.1 218.8,117.86 CG232.1 221.32,117.86 LG4.2 224.06,115.12 224.06,111.96 224.8,111.22 224.8,110.09 CG230.1 226.88,109.76 v2(226.97,109.85)
  BOTTOM w0.25: UG9.BC12 v2(226.97,109.85)
N19616930: length 64.7
  TOP w0.254: CG237.1 226.93,97.39 v2(226.32,98)
  TOP w0.305: CG234.1 235.81,108.61 v2(235.32,109.1) 234.9,108.68 CG235.1 ; v2(247.32,91.7) 247.03,91.41 CG233.1
  IN1 w0.35: v2(235.32,109.1) 234.14,107.92 227.97,107.92 226.92,106.86 226.92,98.6 v2(226.32,98) 226.92,97.4 226.92,90.1 228.29,88.72 245.45,88.72 246.72,90 246.72,91.1 v2(247.32,91.7)
  IN3 w0.381: v2(227.02,110.59) 228.1,110.59 228.42,110.27 228.42,108.74 228.7,108.47 234.69,108.47 v2(235.32,109.1)
  BOTTOM w0.25: v2(227.02,110.59) 226.93,110.59 UG9.BD12 ; v2(235.32,109.1) 235.32,109.2 UG9.BB24
  BOTTOM w0.3: v2(247.32,91.7) 247.42,91.7 UG9.U42 ; v2(226.32,98) 226.22,98 UG9.AF11
  vias: v1(226.28,111.86)
