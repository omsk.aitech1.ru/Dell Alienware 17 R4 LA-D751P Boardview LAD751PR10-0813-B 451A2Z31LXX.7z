# Allegro board LAD751PR10-0813-B.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RH466  100_0402_1%  [R_0402]  153.73 123.34 270 bottom
RH469  100_0402_1%  [R_0402]  172.48 124.31 270 bottom
RH472  100_0402_1%  [R_0402]  152.84 123.34 270 bottom
RH484  2_0402_1%  [R_0402]  156.23 52.26 270 top
RH485  2_0402_1%  [R_0402]  152.66 38.53 0 top
RH489  1K_0402_5%  [R_0402]  224.37 22.45 180 bottom
RH493  2.2K_0402_5%  [R_0402]  223.6 20.57 90 bottom
RH494  51_0402_5%  [R_0402]  128.95 112.91 0 bottom
RH495  51_0402_5%  [R_0402]  127.72 112.87 180 bottom
RH496  51_0402_5%  [R_0402]  128.95 113.92 0 bottom
RH497  51_0402_5%  [R_0402]  129.43 156.94 180 top
RH501  499_0402_1%  [R_0402]  216.37 18.23 180 top
RH502  499_0402_1%  [R_0402]  216.37 19.69 180 top
RH506  1M_0402_5%  [R_0402]  220.04 29.36 0 top
RH512  10K_0402_5%  [R_0402]  204.87 15.21 180 top
RH515  8.2K_0402_5%  [R_0402]  219.59 32.96 0 bottom
RH516  10K_0402_5%  [R_0402]  205.49 20.92 45 top
RH517  8.2K_0402_5%  [R_0402]  215.16 14.57 180 bottom
RH518  10K_0402_5%~D  [R_0402]  208.44 32.38 90 top
RH519  0_0402_5%  [R_0402]  126.73 117.8 0 bottom
RH520  8.2K_0402_5%  [R_0402]  212.42 14.69 90 top
RH521  10K_0402_5%  [R_0402]  205.49 22.19 45 top
RH524  4.7K_0402_5%~D  [R_0402]  220.95 25.15 180 top
RH525  330K_0402_5%  [R_0402]  124.3 75.76 270 top
RH530  0_0402_5%  [R_0402]  160.75 101.1 90 top
RH531  1M_0402_5%  [R_0402]  216.84 34.9 180 top
RH533  8.2K_0402_5%  [R_0402]  221.37 30.5 90 bottom
RH537  10K_0201_5%  [R_0201]  207.78 15.06 270 bottom
RH545  10K_0402_5%  [R_0402]  219.59 33.92 0 bottom
RH558  10K_0201_5%  [R_0201]  215.23 30.31 90 top
RH571  8.2K_0402_5%  [R_0402]  215.83 43.02 0 bottom
RH580  1K_0402_5%  [R_0402]  206.62 36.21 90 top
RH581  1K_0402_5%  [R_0402]  207.16 42.62 90 bottom
RH584  10K_0402_5%  [R_0402]  200.88 14.37 270 bottom
RH585  10K_0402_5%  [R_0402]  199.99 13.46 90 bottom
RH588  10K_0402_5%  [R_0402]  220.94 27.02 180 top
RH589  10K_0402_5%  [R_0402]  193.06 108.17 0 top
RH656  0_0201_5%  [R_0201]  199.93 138.5 270 bottom
RH657  0_0201_5%  [R_0201]  199.93 136.14 90 bottom
RL1  4.7K_0402_5%~D  [R_0402]  277.53 164.23 180 bottom
RL2  30K_0402_5%  [R_0402]  277.53 163.34 180 bottom
RL3  2.37K_0402_1%~D  [R_0402]  275.19 157.79 90 top
RL4  5.1K_0402_1%~D  [R_0402]  274.33 163.68 90 top
RL5  10K_0402_5%  [R_0402]  266.96 168.32 270 bottom
RL8  330_0402_5%  [R_0402]  242.71 170.96 90 top
RL9  75_0402_1%~D  [R_0402]  257.18 163.91 90 top
RL10  75_0402_1%~D  [R_0402]  255.98 163.91 90 top
RL11  75_0402_1%~D  [R_0402]  249.63 163.91 90 top
RL12  75_0402_1%~D  [R_0402]  248.36 163.91 90 top
RL13  130_0402_1%~D  [R_0402]  263.47 156.64 270 top
RL14  1K_0402_1%~D  [R_0402]  266.96 155.98 90 top
RL15  130_0402_5%~D  [R_0402]  264.36 156.64 270 top
RM5  10K_0402_5%  [R_0402]  158.69 173.77 90 bottom
RM6  10K_0402_5%  [R_0402]  163.15 172.7 180 bottom
RM14  1K_0201_1%  [R_0201]  124.32 157.04 0 bottom
RM17  100K_0402_5%  [R_0402]  163.14 173.58 90 bottom
RM18  2.2_0402_1%  [R_0402]  173.31 158.53 180 bottom
RM20  1K_0402_1%  [R_0402]  169.35 151.44 90 bottom
RM21  1K_0402_1%  [R_0402]  171.26 151.44 90 bottom
RM23  1K_0201_1%  [R_0201]  138.92 160.12 180 bottom
RM25  475_0402_1%  [R_0402]  169.86 162.39 270 bottom
RM26  1K_0201_1%  [R_0201]  138.92 160.75 180 bottom
RM27  33_0402_1%  [R_0402]  167.45 162.26 270 bottom
RM28  33_0402_1%  [R_0402]  166.43 162.26 270 bottom
RM29  49.9_0402_1%  [R_0402]  164.19 161.68 0 bottom
RM31  100K_0402_5%  [R_0402]  309.83 43.71 90 top
RM38  49.9_0402_1%  [R_0402]  164.19 162.85 0 bottom
RM41  100K_0402_5%  [R_0402]  150.95 170.01 90 bottom
RM42  470K_0402_5%  [R_0402]  152.24 174.67 270 bottom
RM61  20K_0402_5%  [R_0402]  139.37 154.58 180 bottom
RM62  1K_0201_1%  [R_0201]  137.6 150.55 90 bottom
RM64  1K_0201_1%  [R_0201]  138.35 157.36 0 bottom
RM66  1K_0201_1%  [R_0201]  138.35 158.25 0 bottom
RM70  1K_0201_1%  [R_0201]  128.33 150.55 90 bottom
RM72  10K_0201_5%  [R_0201]  124.32 159.07 0 bottom
RM75  1K_0201_1%  [R_0201]  139.4 153.13 180 bottom
RM76  1K_0201_1%  [R_0201]  127.38 150.55 90 bottom
RM79  1K_0201_1%  [R_0201]  139.4 152.24 180 bottom
RM81  1K_0201_1%  [R_0201]  126.43 150.55 90 bottom
RM82  1K_0201_1%  [R_0201]  138.92 159.48 180 bottom
RM84  1K_0201_1%  [R_0201]  124.38 150.56 0 bottom
RM85  1K_0201_1%  [R_0201]  138.92 158.85 180 bottom
RM86  1K_0201_1%  [R_0201]  138.5 150.45 90 bottom
RM87  10K_0201_5%  [R_0201]  125.23 158.12 180 bottom
RM91  549_0402_1%  [R_0402]  148.36 163.23 180 bottom
RM92  100K_0402_5%~D  [R_0402]  148.36 164.69 180 bottom
RM93  100_0402_1%  [R_0402]  151.77 162.77 90 bottom
RM94  100K_0402_5%~D  [R_0402]  150.88 162.77 90 bottom
RM96  4.7K_0402_5%  [R_0402]  170.3 151.44 90 bottom
RN5  10K_0402_5%  [R_0402]  314.79 39.34 180 top
RN15  0_0201_5%  [R_0201]  311.86 39.76 270 top
RN16  10K_0402_5%  [R_0402]  317.59 37.89 180 top
RN17  0_0201_5%  [R_0201]  316.71 36.15 0 top
RP2  33_0804_8P4R_5%  [RP_0804_8P4R]  218.54 14.18 90 top
RP3  10K_0804_8P4R_5%  [RP_0804_8P4R]  221.13 27.95 180 bottom
RP5  10K_0804_8P4R_5%  [RP_0804_8P4R]  221.13 24.97 180 bottom
RPH5  15_0804_8P4R_5%  [RP_0804_8P4R]  221.13 22 180 bottom
RPH6  10K_8P4R_5%  [RP_0804_8P4R]  204.19 14.82 270 bottom
RPT1  2.2K_0804_8P4R_5%  [RP_0804_8P4R]  174 164.68 180 bottom
RS1  100K_0201_5%  [R_0201]  188.91 63.6 0 top
RS2  10K_0201_5%  [R_0201]  96.08 18.12 90 bottom
RS3  0_0201_5%  [R_0201]  234.86 17.81 0 bottom
RS8  0_0201_5%  [R0201_0OHM]  124.53 10.17 270 top
RT1  0_0201_5%  [R0201_0OHM]  176.06 165.39 0 bottom
RT2  0_0201_5%  [R_0201]  176.92 153.26 270 bottom
RT3  3.01K_0201_1%  [R_0201]  183.79 163.72 270 bottom
RT4  1M_0201_1%  [R_0201]  174.1 164.46 180 top
RT5  14K_0402_1%  [R_0402]  178.04 164.36 270 bottom
RT6  10K_0201_5%  [R_0201]  173.68 155.63 90 bottom
RT7  10K_0201_5%  [R_0201]  175.65 162.31 270 bottom
RT8  10K_0201_5%  [R_0201]  176.48 162.31 270 bottom
RT9  10K_0201_5%  [R_0201]  172.28 155.26 270 bottom
RT10  0_0201_5%  [R0201_0OHM]  172.31 160.91 90 top
RT11  1M_0201_1%  [R_0201]  172.95 159.26 180 top
RT12  0_0201_5%  [R_0201]  169.9 166.19 180 top
RT13  0_0201_5%  [R0201_0OHM]  169.31 162.31 0 top
RT14  0_0201_5%  [R_0201]  171.15 162.12 0 top
RT15  0_0201_5%  [R0201_0OHM]  172.96 165.64 180 bottom
RT16  0_0201_5%  [R_0201]  172.67 164.73 270 top
RT17  100_0201_5%  [R_0201]  171.75 166.4 180 top
RT18  100_0201_5%  [R_0201]  176.84 158.03 270 top
RT19  14K_0402_1%  [R_0402]  183.88 161.85 0 bottom
RT20  10K_0201_5%  [R_0201]  177.54 152.69 90 bottom
RT21  10K_0201_5%  [R_0201]  179.68 172.43 0 bottom
RT22  0_0201_5%  [R_0201]  201.56 158.67 270 bottom
RT23  0_0201_5%  [R_0201]  169.9 164.09 180 top
RT24  10K_0201_5%  [R_0201]  176.92 152.03 270 bottom
RT25  4.75K_0402_0.5%  [R_0402]  179.35 167.18 270 bottom
RT26  3.3K_0201_5%  [R_0201]  173.51 162.75 0 top
RT27  3.3K_0201_5%  [R_0201]  173.51 163.32 0 top
RT28  10K_0201_5%  [R_0201]  172.88 161.5 270 top
RT29  10K_0201_5%  [R_0201]  173.45 161.5 270 top
RT30  10K_0201_5%  [R_0201]  171.17 167.23 0 top
RT31  10K_0201_5%  [R_0201]  171.74 162.69 180 top
RT32  10K_0201_5%  [R_0201]  169.9 164.72 180 top
RT33  10K_0201_5%  [R_0201]  171.17 165.64 0 top
RT34  100K_0201_5%  [R_0201]  173.48 162.11 180 top
RT35  100K_0201_5%  [R_0201]  169.31 162.88 0 top
RT36  100K_0201_5%  [R_0201]  171.27 164.73 270 top
RT37  100K_0201_5%  [R_0201]  169.31 165.49 0 top
RT38  100K_0201_5%  [R_0201]  172.95 158.63 180 top
RT39  100K_0201_5%  [R_0201]  178.72 160.28 180 bottom
RT40  1M_0201_1%  [R_0201]  178.32 172.02 90 top
RT41  100K_0201_5%  [R_0201]  169.31 163.45 0 top
RT42  1M_0201_1%  [R_0201]  178.28 172.24 0 bottom
RT43  499_0201_1%  [R_0201]  185.39 166.4 0 bottom
RT44  499_0201_1%  [R_0201]  185.48 167.77 270 bottom
RT45  100K_0201_5%  [R_0201]  178.28 171.61 0 bottom
RT46  100K_0201_5%  [R_0201]  178.95 172.02 90 top
RT47  100K_0201_5%  [R_0201]  174.1 163.89 180 top
RT48  3.3K_0402_5%  [R_0402]  190 162.99 270 bottom
RT49  3.3K_0402_5%  [R_0402]  188.48 162.07 90 bottom
RT50  3.3K_0402_5%  [R_0402]  187.52 162.99 270 bottom
RT51  3.3K_0402_5%  [R_0402]  187.7 159.35 0 bottom
RT53  0_0402_5%  [R0402_0OHM]  194.69 164.56 0 top
RT57  10K_0201_5%  [R_0201]  205.81 154.67 270 bottom
RT58  10K_0201_5%  [R_0201]  204.61 154.67 270 bottom
RT59  0_0201_5%  [R_0201]  204.61 152.27 90 bottom
RT60  0_0201_5%  [R_0201]  205.81 152.27 90 bottom
RT61  0_0201_5%  [R_0201]  197.11 167.47 90 top
RT62  100K_0201_5%  [R_0201]  198.26 161.91 270 top
RT63  100K_0201_5%  [R_0201]  205.42 162.4 0 bottom
RT64  10K_0201_5%  [R_0201]  203.84 167.15 90 bottom
RT65  10K_0201_5%  [R_0201]  205.15 167.15 90 bottom
RT66  10K_0201_5%  [R_0201]  199.14 159.47 90 top
RT67  10K_0201_5%  [R_0201]  200.03 159.47 90 top
RT68  100K_0201_5%  [R_0201]  199.72 167.44 90 bottom
RT69  100K_0201_5%  [R_0201]  199.08 167.44 90 bottom
RT70  100K_0201_5%  [R_0201]  197.11 168.03 270 bottom
RT71  100K_0201_5%  [R_0201]  198.45 167.44 90 bottom
RT72  100K_0201_5%  [R_0201]  197.81 167.44 90 bottom
RT73  100K_0201_5%  [R_0201]  196.22 167.47 90 bottom
RT74  0_0201_5%  [R0201_0OHM]  208.2 163.23 180 bottom
RT75  15K_0402_1%  [R_0402]  195.6 163.67 180 bottom
RT76  100K_0201_5%  [R_0201]  178.19 153.26 270 bottom
RT77  100K_0201_5%  [R_0201]  182.57 153.26 270 bottom
RT78  100K_0201_5%  [R_0201]  179.97 153.26 270 bottom
RT79  100K_0201_5%  [R_0201]  180.79 153.26 270 bottom
RT80  100K_0201_5%  [R_0201]  176.73 167.66 270 bottom
RT83  0_0201_5%  [R_0201]  198.01 163.29 180 top
RT86  10K_0201_5%  [R_0201]  177.36 169.48 90 bottom
RT94  10K_0201_5%  [R_0201]  169.91 163.16 180 bottom
RT95  0_0805_5%  [R_0805]  176.41 172.66 90 bottom
RT97  0_0402_5%  [R0402_0OHM]  178.37 174.47 0 bottom
RT98  0_0201_5%  [R0201_0OHM]  196.03 156.01 90 bottom
RT99  0_0201_5%  [R0201_0OHM]  189.24 161.98 90 bottom
RT100  0_0201_5%  [R0201_0OHM]  188.48 160.85 270 bottom
RT101  0_0201_5%  [R0201_0OHM]  195.4 156.01 90 bottom
RT102  0_0201_5%  [R_0201]  205.42 163.29 0 bottom
RT107  10K_0201_5%  [R_0201]  204.57 155.48 0 bottom
RT108  0_0402_5%  [R_0402]  319.01 53.37 0 top
RT109  0_0402_5%  [R_0402]  319.92 54.26 180 top
RU1  10K_0402_5%  [R_0402]  24.32 41.66 180 top
RU2  19.1K_0402_1%  [R_0402]  19.41 45.29 270 top
RU3  19.1K_0402_1%  [R_0402]  19.41 42.6 90 top
RU4  100K_0402_5%  [R_0402]  32.83 45.27 90 top
RU5  220K_0402_5%  [R_0402]  32.83 44.41 270 top
RU6  1M_0402_5%  [R_0402]  27.86 46.23 0 top
RU7  10K_0402_5%  [R_0402]  26.16 45.66 180 top
RU12  0_0805_5%  [R_0805]  23.59 48.61 180 bottom
RU14  100K_0402_1%  [R_0402]  16.6 48.11 90 bottom
RU15  100K_0402_5%  [R_0402]  20.9 54.21 270 top
RU16  100K_0402_5%  [R_0402]  20.01 54.21 270 top
RU17  100K_0402_5%  [R_0402]  14.87 54.15 270 top
RU18  100K_0402_5%  [R_0402]  15.76 54.15 270 top
RU19  100K_0402_5%  [R_0402]  16.65 54.15 270 top
RU20  100K_0402_5%  [R_0402]  19.12 54.21 270 top
RU21  10K_0402_5%  [R_0402]  19.2 48.11 90 bottom
RU23  100K_0402_1%  [R_0402]  18.31 48.11 90 bottom
RU24  10K_0201_1%  [R_0201]  295.88 64.26 0 top
RU25  20K_0201_1%  [R_0201]  296.46 64.84 180 top
RU26  10K_0201_1%  [R_0201]  297.58 63.1 270 top
RV1  10K_0201_5%  [R_0201]  168.18 160.5 0 top
RV8  100K_0201_5%  [R_0201]  169.97 160.5 180 top
RV9  100K_0402_5%  [R_0402]  151.9 168.32 270 bottom
RV12  100K_0402_5%  [R_0402]  160.6 164.76 270 bottom
RV13  0_0402_5%  [R_0402]  164.21 163.74 0 top
RV15  100K_0201_5%  [R_0201]  236.1 166.68 90 bottom
RV16  100K_0201_5%  [R_0201]  236.99 166.68 90 bottom
RV17  1M_0201_1%  [R_0201]  228.91 157.75 270 bottom
RV18  5.1M_0402_5%  [R_0402]  233.22 166.68 90 bottom
RV19  100K_0402_5%  [R_0402]  190.93 135.15 0 bottom
RV20  100K_0402_5%  [R_0402]  191.84 136.1 180 bottom
RV21  4.7K_0402_1%  [R_0402]  205.03 131.53 0 bottom
RV22  4.7K_0402_1%  [R_0402]  207.32 132.18 0 bottom
RV23  1M_0402_5%  [R_0402]  202.24 137.07 270 bottom
RV24  4.99K_0402_1%  [R_0402]  195.54 136.24 180 bottom
RV25  10K_0402_5%  [R_0402]  204.04 136.16 180 bottom
RV26  499_0402_1%  [R_0402]  205.05 136.44 270 bottom
RV27  6.04 +-1% 0402  [R_0402]  213.58 168.75 90 bottom
RV28  6.04 +-1% 0402  [R_0402]  212.7 168.75 90 bottom
RV29  6.04 +-1% 0402  [R_0402]  215.95 168.8 90 bottom
RV30  6.04 +-1% 0402  [R_0402]  215.07 168.79 90 bottom
RV33  6.04 +-1% 0402  [R_0402]  211.29 168.76 90 bottom
RV34  6.04 +-1% 0402  [R_0402]  210.38 168.75 90 bottom
RV45  10K_0402_5%  [R_0402]  166.92 166.2 90 bottom
RV47  0_0402_5%  [R0402_0OHM]  160.24 163.81 180 top
RV81  0_0402_5%  [R0402_0OHM]  166.06 171.01 0 bottom
RV500  150_0402_1%  [R_0402]  217.5 167.9 0 bottom
RV501  150_0402_1%  [R_0402]  212.7 167.9 0 bottom
RV502  150_0402_1%  [R_0402]  215.05 167.9 0 bottom
RV503  150_0402_1%  [R_0402]  210.37 167.9 0 bottom
RV600  100K_0201_5%  [R_0201]  167.18 163.93 180 bottom
RV618  0_0402_5%  [R0402_0OHM]  225.08 158.66 270 bottom
RV619  0_0402_5%  [R0402_0OHM]  225.97 158.66 270 bottom
RV622  4.7K_0402_1%  [R_0402]  207.88 129.81 0 bottom
RV623  4.7K_0402_1%  [R_0402]  205.41 129.5 0 bottom
RV624  4.7K_0402_1%  [R_0402]  197.87 136.54 90 bottom
RV625  4.7K_0402_1%  [R_0402]  196.99 136.54 90 bottom
RV626  4.7K_0402_1%  [R_0402]  207.88 130.7 0 bottom
RV627  4.7K_0402_1%  [R_0402]  205.41 130.39 0 bottom
RV628  4.7K_0402_1%  [R_0402]  207.32 133.19 0 bottom
RV629  4.7K_0402_1%  [R_0402]  205.03 132.42 0 bottom
RV630  4.7K_0402_1%  [R_0402]  206.07 124.49 0 bottom
RV631  4.7K_0402_1%  [R_0402]  207.17 126.27 90 bottom
RV632  0_0402_5%  [R_0402]  205.88 134.4 180 bottom
RV633  0_0402_5%  [R_0402]  205.88 133.5 180 bottom
RV634  4.7K_0402_1%  [R_0402]  206.32 127.59 180 bottom
RV635  4.7K_0402_1%  [R_0402]  206.32 128.54 180 bottom
RV638  5.6_0402_1%  [R_0402]  210.33 165.82 90 bottom
RV639  5.6_0402_1%  [R_0402]  215.15 165.82 90 bottom
RV640  5.6_0402_1%  [R_0402]  217.53 165.82 90 bottom
RV641  5.6_0402_1%  [R_0402]  218.41 165.82 90 bottom
RV642  5.6_0402_1%  [R_0402]  216.02 165.82 90 bottom
RV643  5.6_0402_1%  [R_0402]  213.61 165.82 90 bottom
RV645  5.6_0402_1%  [R_0402]  211.21 165.82 90 bottom
RV646  5.6_0402_1%  [R_0402]  212.72 165.82 90 bottom
RV648  10K_0402_5%  [R_0402]  219.52 159.12 180 bottom
RV649  2K_0402_5%  [R_0402]  214.71 160.79 180 bottom
RV650  33_0402_1%  [R_0402]  219.18 160.46 180 bottom
RV651  33_0402_1%  [R_0402]  219.19 161.33 180 bottom
RV652  10K_0402_5%  [R_0402]  213.81 161.66 0 bottom
RV653  2K_0402_5%  [R_0402]  214.73 159.89 180 bottom
RV655  10K_0402_5%  [R_0402]  209.57 161.51 180 bottom
RV658  10K_0402_5%  [R_0402]  205.56 139.72 90 bottom
RV659  10K_0402_5%  [R_0402]  193.05 9.38 90 top
RV664  100K_0402_5%  [R_0402]  226.86 157.74 90 bottom
RV665  100K_0402_5%  [R_0402]  224.2 157.74 90 bottom
RV669  100K_0201_1%  [R_0201]  191.23 132.56 0 bottom
RV670  100K_0201_1%  [R_0201]  191.23 130.84 0 bottom
RV671  2.2K_0201_5%  [R_0201]  236.76 163.8 0 bottom
RV672  2.2K_0201_5%  [R_0201]  237.68 161.88 90 bottom
RV673  6.04 +-1% 0402  [R_0402]  218.4 168.76 90 bottom
RV674  6.04 +-1% 0402  [R_0402]  217.51 168.76 90 bottom
RX1  100K_0402_5%  [R_0402]  224.67 164.13 270 bottom
RX2  150K_0402_5%  [R_0402]  231.25 166.68 90 bottom
RX4  100K_0402_5%  [R_0402]  222.91 159.79 180 top
RX5  10K_0402_5%  [R_0402]  220.56 158.06 0 top
RX6  150K_0402_5%  [R_0402]  208.63 159.68 0 bottom
RX7  10K_0402_5%  [R_0402]  214.89 156.85 180 bottom
RX8  100K_0402_5%  [R_0402]  213.98 157.73 0 bottom
RX31  499_0201_1%  [R_0201]  214.27 162.47 270 top
RX32  499_0201_1%  [R_0201]  213.7 162.47 270 top
RX33  499_0201_1%  [R_0201]  218.83 162.47 270 top
RX34  499_0201_1%  [R_0201]  218.26 162.46 270 top
RX35  499_0201_1%  [R_0201]  216.56 162.49 270 top
RX36  499_0201_1%  [R_0201]  216 162.49 270 top
RX37  499_0201_1%  [R_0201]  211.25 162.49 270 top
RX38  499_0201_1%  [R_0201]  210.68 162.49 270 top
SW1  TST71A-N-220-S017 SPST H0.6 2P  [SW_TST71-N-220-T170-S017_2P]  315.1 5.49 180 top
T1  PAD~D  [TPC12]  175.6 116.82 180 bottom
T2  PAD~D  [TPC12]  174.38 161.86 90 top
T6  PAD~D  [TPC12]  224.52 112.15 0 top
T7  PAD~D  [TPC12]  171.87 160.09 45 top
T9  PAD~D  [TPC12]  174 160.15 45 top
T10  PAD~D  [TPC12]  234.73 118.27 180 bottom
T11  PAD~D  [TPC12]  231.89 119.01 180 bottom
T12  PAD~D  [TPC12]  231.71 120.28 180 bottom
T13  PAD~D  [TPC12]  233.23 118.76 180 bottom
T41  PAD~D  [TPC12]  170.49 94.87 0 top
T43  PAD~D  [TPC12]  132.24 92.85 0 top
T44  PAD~D  [TPC12]  132.62 94.63 0 top
T49  PAD~D  [TPC12]  200.21 41.48 0 top
T50  PAD~D  [TPC12]  200.68 40.28 0 top
T62  PAD~D  [TPC12]  200.96 162.91 0 top
T63  PAD~D  [TPC12]  199.68 163.4 0 top
T64  PAD~D  [TPC12]  196.86 159.29 180 bottom
T65  PAD~D  [TPC12]  195.46 159.77 180 bottom
T66  PAD~D  [TPC12]  135.03 116.6 0 top
T67  PAD~D  [TPC12]  135.33 117.89 0 top
T68  PAD~D  [TPC12]  136.72 103.11 0 top
T69  PAD~D  [TPC12]  137.51 102.06 0 top
T70  PAD~D  [TPC12]  201.18 161.58 0 top
T71  PAD~D  [TPC12]  200.81 164.76 0 top
T73  PAD~D  [TPC12]  137.41 104.27 0 top
T74  PAD~D  [TPC12]  135.34 104.56 0 top
T75  PAD~D  [TPC12]  135.33 109.82 0 top
T76  PAD~D  [TPC12]  137.38 109.43 0 top
T81  PAD~D  [TPC12]  137.19 118.38 0 top
T82  PAD~D  [TPC12]  137.32 116.98 0 top
T85  PAD~D  [TPC12]  174.43 90.56 180 bottom
T88  PAD~D  [TPC12]  131.22 91.84 0 top
T89  PAD~D  [TPC12]  173.83 89.19 180 bottom
T112  PAD~D  [TPC12]  128.96 111.88 180 bottom
T113  PAD~D  [TPC12]  130.29 111.91 180 bottom
T114  PAD~D  [TPC12]  204.05 162.3 0 top
T120  PAD~D  [TPC12]  203.45 163.62 0 top
T121  PAD~D  [TPC12]  204.59 162.59 180 bottom
T122  PAD~D  [TPC12]  205.06 164.14 180 bottom
TC24  PAD~D  [TPC12]  28.93 8.76 270 bottom
TL1  MHPC_NS692417  [MHPC_NS692417_24P]  259.81 155.42 180 bottom
U16  -  [AOZ1334DI-02_DFN8-7_3X3]  265.88 20.85 270 bottom
U17  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  63.49 15.1 0 bottom
U18  -  [SY6288C20AAC_SOT23-5]  227.34 42.19 90 top
U19  -  [AOZ1334DI-01_DFN8-7_3X3]  177.33 78.48 0 top
U20  -  [AOZ1334DI-01_DFN8-7_3X3]  181.65 78.48 0 top
U2407  -  [F75305M_MSOP10]  185.89 45.64 0 bottom
UA1  ALC3266-CG_QFN56_7X7  [ALC3266-CG_QFN56_7X7-S]  35.77 33.11 180 bottom
UA2  MAX9892ERT+T_UCSP6~D  [MAX9892ERTLFT_UCSP_6P]  22.55 28.73 270 top
UA3  MAX9892ERT+T_UCSP6~D  [MAX9892ERTLFT_UCSP_6P]  19.75 23.2 270 top
UA4  ALC1309-CG_QFN56_7X7  [ALC1309-CG_QFN56_7X7-S]  37.6 7.21 180 top
UC1  -  [74AUP1G07GW_TSSOP5]  125.58 79.24 180 top
UE1  C8051F383-GQ_LQFP32_7X7  [C8051F347-GQ_LQFP32_7X7]  313.8 9.2 0 top
UE2  EN25Q80A-100HIP_SO8  [EN25F80-75HCP_SO8]  103.63 16.64 180 bottom
UE3  TLC59116FIRHBR_VQFN32_5X5  [TLC59116FIRHBR_VQFN32_5X5-S]  227.51 156.06 0 top
UE4  TLC59116FIRHBR_VQFN32_5X5  [TLC59116FIRHBR_VQFN32_5X5-S]  185.3 21.69 270 top
UE5  -  [KB9022QD_LQFP128_14X14]  305.54 23.84 270 top
UE6  KC3810_QFN24_4X4  [KC3810_QFN24_4X4-S]  330.04 40.73 0 top
UE8  TLC59116FIRHBR_VQFN32_5X5  [TLC59116FIRHBR_VQFN32_5X5-S]  305.22 33.68 0 top
UE9  -  [SY6288C20AAC_SOT23-5]  102.71 28.23 180 bottom
UE10  KC3810_QFN24_4X4  [KC3810_QFN24_4X4-S]  316.26 55.71 0 top
UE12  -  [SY6288D20AAC_SOT23-5]  147.87 163.55 90 top
UG1  K4G80325FB-HC25 FBGA 170P  [H5GQ1H24AFR-T2L_BGA_170P]  282.95 87.16 90 bottom
UG2  K4G80325FB-HC25 FBGA 170P  [H5GQ1H24AFR-T2L_BGA_170P]  270.15 116.56 270 bottom
UG3  K4G80325FB-HC25 FBGA 170P  [H5GQ1H24AFR-T2L_BGA_170P]  250.39 52.51 0 bottom
UG4  K4G80325FB-HC25 FBGA 170P  [H5GQ1H24AFR-T2L_BGA_170P]  270.15 81.56 270 bottom
UG5  K4G80325FB-HC25 FBGA 170P  [H5GQ1H24AFR-T2L_BGA_170P]  215.39 52.51 0 bottom
UG6  K4G80325FB-HC25 FBGA 170P  [H5GQ1H24AFR-T2L_BGA_170P]  244.79 65.31 180 bottom
UG7  K4G80325FB-HC25 FBGA 170P  [H5GQ1H24AFR-T2L_BGA_170P]  192.63 100.05 270 bottom
UG8  K4G80325FB-HC25 FBGA 170P  [H5GQ1H24AFR-T2L_BGA_170P]  205.43 70.65 90 bottom
UG9  N17E-G1_BGA2152~D  [N17E-G1_BGA_2152P]  218.97 80.75 0 bottom
UG10  -  [NL17SZ08DFT2G_SC70-5]  200.11 121.75 0 bottom
UG11  INA3221AIRGVR_VQFN16_4X4  [INA3221AIRGVR_VQFN16_4X4-S]  190.21 118.58 0 bottom
UG12  AOZ1331_SON14_2X3  [TPS22966DPUR_SON14_2X3]  195.46 112.81 0 bottom
UG13  -  [W25Q80EWSSIG_SO8]  210.14 108.11 270 bottom
UG14  -  [TPS22961DNYR_WSON8]  195.29 104.31 180 bottom
UG15  -  [W25Q80EWSSIG_SO8]  210.14 114.14 270 bottom
UG16  -  [PI5A3158BZAEX_TDFN12_1X3]  195.45 111.28 270 top
UG22  -  [NL17SZ08DFT2G_SC70-5]  215.27 156.62 0 top
UG23  -  [BSS138DW_SC88-6]  309.81 60.77 180 top
UG24  -  [BSS138DW_SC88-6]  188.2 98.03 0 top
UG25  -  [74LVC1G32GW_TSSOP5]  277.25 146 0 top
UG26  -  [NL17SZ08DFT2G_SC70-5]  277.07 151.93 0 top
UG27  -  [74LVC1G32GW_TSSOP5]  311.36 60.58 270 top
UG28  -  [NL17SZ08DFT2G_SC70-5]  280.29 157.99 0 top
UG29  -  [NL17SZ08DFT2G_SC70-5]  278.52 143.49 270 top
UH1  SKL-H-PCH_BGA837  [SKY-S-PCH_BGA_837P-T]  194.76 39.41 90 bottom
UH3  -  [TC7SH08FU_SSOP5]  215.42 23.88 180 top
UH4  -  [W25Q128FVSIQ_SO8]  220.23 14.12 90 bottom
UL1  S IC E2400-BL3A-R QFN 40P E-LAN CTRL  [E2201-BL3A-R_QFN40_5X5-S]  274.89 163.44 270 bottom
UL2  -  [SY6288D20AAC_SOT23-5]  270.05 167.69 180 bottom
UM3  -  [TC7SH08FU_SSOP5]  161.12 172.58 180 bottom
UM4  PI6CEQ20200LIEX  [PI6CEQ20200LIEX_TSSOP20]  171.19 153.98 180 bottom
UM7  TC7SH08FU_SSOP5~D  [TC7SH08FU_SSOP5]  149.61 174.46 0 bottom
UM8  DS80PCI402SQNOPB_WQFN54_10X5P5  [DS80PCI402_WQFN54_10X5P5-S]  136.11 153.38 180 bottom
US1  KXCNL-1010_LGA16_3X3  [LNG3DMTR_LGA16_3X3]  184.24 64.15 0 top
UT1  ALPINE-RIDGE_BGA337  [ALPINE-RIDGE_BGA_337P]  175.92 169.84 0 top
UT2  -  [W25Q80DVSSIG_SO8]  190.18 159.63 0 bottom
UT4  TPS65982_BGA96  [TPS65982_BGA_96P]  198.16 160.07 0 bottom
UU1  TPS2546RTER_QFN16_3X3  [TPS2540RTER_QFN16_3X3-S]  21.58 43.11 0 top
UU3  -  [SY6288C20AAC_SOT23-5]  319.97 21.76 90 top
UU5  TC7SZ14FU_SSOP5~D  [TC7SZ14FU_SSOP5]  30.04 43.81 90 top
UU7  TPS25810RVCR_QFN20_4X3  [TPS25810RVCR_QFN20_4X3-S]  19.42 53.63 270 bottom
UV3  -  [SN74CBT3257CPWR_TSSOP16]  229.53 159.17 90 bottom
UV17  -  [SY6288C20AAC_SOT23-5]  163.65 166.59 0 bottom
UV21  PS8331BQFN60GTR-A2 QFN  [PS8331BQFN60GTR-A0_QFN60_5X9-S]  202.32 129.5 180 bottom
UV22  -  [SN74CBT3257CPWR_TSSOP16]  194.63 9.38 270 top
UX1  -  [NL17SZ08DFT2G_SC70-5]  222.87 160.88 90 top
UX2  -  [NL17SZ08DFT2G_SC70-5]  211.22 158.77 0 bottom
UZ21  -  [APE8937GN2_DFN8_2X2]  129.1 97.8 180 bottom
YG1  27MHZ 16PF +-30PPM 7M27070004F50Q5  [Y_5YEA27000163IF50Q5_4P]  210.79 118.29 270 bottom
YH1  32.768KHZ_X1A000141000300  [Y_CM31532768DZFT_2P]  221.31 38.02 270 bottom
YH2  24MHZ_12PF_7V24000020  [Y_X3G024000DC1H_4P]  192.97 46.45 0 bottom
YL1  25MHZ_12PF_7V25000012  [Y_FSX3M-25PM20FDO_4P]  281.14 164.52 180 bottom
YT1  25MHZ_12PF_7V25000012  [Y_7V25000012_4P]  194.14 167.98 180 top

## Library data of the parts
C2-C4 C6 C7 C10 C11 C29 C256 C258 C260 C263 C265 C266 C268 C270 C617 C618 C620-C625 C627-C630 C632-C640 C2498 C2500 C2502 C2504-C2511 C2516 C2518-C2525 CA1 CA2 CA4 CA6 CA8 CA10-CA13 CA15 CA16 CA18-CA21 CA23-CA28 CA30 CA34-CA41 CA45 CA46 CA53 CA54 CA56-CA60 CA62-CA66 CA71 CA74 CA77 CA78 CA80 CA81 CA83-CA85 CA87-CA92 CA254-CA257 CD1-CD4 CD12 CD16 CD18-CD22 CD29-CD32 CD34 CD69 CD74-CD83 CD91 CD92 CE1 CE3 CE4 CE6 CE7 CE9 CE13-CE20 CE24 CE25 CE27-CE36 CE38 CE40-CE46 CE51 CE55-CE65 CE79 CE81 CE82 CE84-CE87 CE168 CG2-CG4 CG13 CG17-CG19 CG23 CG40 CG42 CG43 CG47-CG49 CG51 CG53 CG54 CG56-CG61 CG64-CG66 CG75 CG76 CG78 CG79 CG83-CG91 CG100-CG106 CG113 CG114 CG118-CG126 CG135-CG141 CG148 CG149 CG153-CG161 CG170-CG176 CG192-CG215 CG230 CG233-CG238 CG240 CG241 CG256 CG265 CG272-CG277 CG284-CG287 CG291 CG292 CG295-CG300 CG308-CG310 CG312-CG318 CG320 CG322-CG408 CG410-CG475 CG481 CG482 CG487 CH3 CH4 CH45-CH49 CH70 CH80 CH82 CH100 CH101 CH105-CH110 CH173-CH176 CH179 CH180 CH183 CH185-CH195 CH197 CH200 CI38 CI39 CL1-CL9 CL11-CL13 CL16-CL21 CL23-CL25 CL27-CL29 CL31-CL39 CL41-CL44 CM9 CM10 CM13 CM15-CM18 CM20 CM21 CM23 CM30 CM32-CM36 CM70 CM98 CM99 CN9 CN23-CN25 CS5-CS7 CS16 CT37 CT38 CT50-CT53 CT81 CT82 CT88 CT94-CT97 CT101 CT103 CT104 CU7 CU12 CU13 CU16-CU21 CU26 CU28-CU31 CU34 CU35 CU38 CU39 CU45-CU48 CV9 CV15 CV17 CV19 CV20 CV34 CV372-CV375 CV436-CV439 CV484 CV1056 CX1 CX2 PC1-PC4 PC6-PC9 PC11-PC13 PC100 PC103 PC105 PC106 PC118 PC119 PC200 PC201 PC208 PC210 PC211 PC213 PC214 PC216-PC218 PC300-PC302 PC309-PC311 PC500-PC503 PC505-PC538 PC540 PC546 PC547 PC549 PC554 PC555 PC557 PC562 PC563 PC566 PC571-PC573 PC578 PC579 PC581 PC582 PC588-PC590 PC594 PC701-PC704 PC708 PC709 PC715-PC724 PC726 PC727 PC801-PC803 PC806 PC807 PC809 PC811 PC818 PC819 PC822 PC1019 PC1036-PC1041 PC1045-PC1096 PC1112-PC1122 PC1301 PC5002 PC5005-PC5011 PC5013-PC5026 PC6000-PC6012 PC6014-PC6017 PC6100 PC6104-PC6106 PC6117-PC6120 PC6200 PC6204-PC6206 PC6217-PC6220 PC6300-PC6358 PC6364-PC6369 PC6417-PC6420 PC6426 PC6429-PC6431 PC6434 PC6435 PC6437 PC6439 PC6441 PC8201 PC8202 PC8205 PC8210 PC8211 PC8215-PC8222 = C_0402
C257 C261 C262 C264 C267 C269 C2512-C2515 CA3 CA5 CA7 CA9 CA14 CA17 CA29 CA31-CA33 CA52 CA55 CA61 CA67-CA70 CA79 CA82 CD5-CD10 CD13-CD15 CD17 CD23-CD28 CD35 CD70-CD73 CD84-CD90 CE22 CF4 CG5 CG6 CG11 CG12 CG14 CG20 CG21 CG24 CG55 CG62 CG63 CG80-CG82 CG97-CG99 CG115-CG117 CG132-CG134 CG150-CG152 CG167-CG169 CG183-CG191 CG216-CG228 CG231 CG239 CG243 CG245 CG247 CG266-CG271 CG278-CG283 CG288-CG290 CG311 CH52 CH53 CH102-CH104 CH118-CH128 CL14 CL15 CL22 CM12 CM14 CM19 CM29 CM31 CS1 CS2 CT73-CT75 CT90-CT93 CT98-CT100 CT106 CU3 CU11 CU27 CU32 CU33 CU42 CU44 CV14 CV18 CV1068 PC10 PC14 PC101 PC109-PC112 PC204 PC207 PC212 PC305 PC308 PC504 PC541 PC548 PC550 PC556 PC558 PC564 PC567 PC570 PC574 PC580 PC586 PC587 PC591 PC593 PC596-PC599 PC707 PC710 PC711 PC725 PC804 PC805 PC808 PC812 PC813 PC815-PC817 PC820 PC821 PC823 PC824 PC1003 PC1004 PC1006 PC1011-PC1016 PC1020-PC1035 PC1300 PC1303-PC1307 PC5003 PC6101-PC6103 PC6114-PC6116 PC6201-PC6203 PC6214-PC6216 PC6361 PC6362 PC6374-PC6377 PC6379-PC6387 PC6392-PC6416 PC6423 PC6427 PC6442-PC6445 PC8200 PC8206 PC8213 = C_0603
C631 C641 CU6 CU40 = C_B15G
CA42-CA44 CA48 CA50 CA51 CC1-CC24 CG1 CG8-CG10 CG16 CG22 CG25-CG36 CG246 CG293 CG294 CG301-CG307 CG476 CG478-CG480 CG483 CH201-CH221 CM62-CM69 CT1-CT16 CT18 CT21 CT23-CT36 CT39-CT49 CT54-CT72 CT77-CT80 CT83-CT86 CT102 CT108-CT113 CV1-CV4 CV6-CV8 CV11-CV13 CV23-CV33 CV35 CV416-CV435 CV1057-CV1064 CV1069 PC1042-PC1044 PC1097-PC1111 PC1123-PC1238 = C_0201
CA47 CA49 = C_D2E
CD11 CD33 PC1000 PC1008-PC1010 = C_EEFSS0D221R
CE80 CF5 CG7 CG232 CH129-CH132 CH177 CH178 CH181 CH182 CH184 CL40 CM11 CU2 CU10 CU37 CV5 CV10 CV21 PC102 PC104 PC113 PC114 PC202 PC203 PC205 PC206 PC303 PC304 PC543-PC545 PC551-PC553 PC559-PC561 PC565 PC568 PC569 PC575-PC577 PC583-PC585 PC592 PC705 PC706 PC712-PC714 PC800 PC810 PC814 PC1005 PC1018 PC6107 PC6109-PC6111 PC6113 PC6121 PC6122 PC6125-PC6127 PC6208-PC6211 PC6213 PC6222-PC6225 PC6227 PC6359 PC6360 PC6370-PC6373 PC6378 PC6421 PC6422 PC6428 PC6432 PC6436 PC6440 PC8203 PC8204 PC8212 PC8214 = C_0805
CG242 CG244 = C_X
CL30 = C_1808
CLRP1 = SHORTPADS: User Part Number: PART#
CPU1 = SKL-H_BGA_1440P-T
DA1 = BAT54C-7-F_SOT23-3
DA2 DA3 = BAT54AW_SOT323-3
DA4-DA6 = AZ5125-02SPR7G_SOT23-3
DA7 DA8 = AZ5125-02SPR7G_SOT23-3-NPM
DE1 DF1 DF2 DU6 DU8 = SDMK0340L-7-F_SOD323-2
DE2-DE4 DH1 DV1 = RB751V-40_SOD323-2
DG1 = BAT54A-7-F_SOT23-3
DG2-DG4 DG6-DG9 = RB751S40T1G_SOD523-2
DS1 DT1 DV12 DV13 = SDM10U45-7_SOD523-2
DT2-DT9 DT11-DT14 = ESD108-B1-CSP0201_WLL-2-1-2
DT10 DU2 DU12 DU13 = TVWDF1004AD0_DFN9
DT15 = PESD24VS2UT_SOT23-3
DU1 DU11 = L30ESDL5V0C3-2_SOT23-3
DU20 DU21 DV4 DV14 = PSOT24C_SOT23-3
DV2 = PESD5V0U2BT_SOT23-3
FD1-FD6 = FIDUCIAL_C40M80
FV2 FV3 = F_SPR-P110
H1 H2 H4 H5 H7 = H_3P8
H3 H11 = H_3P6
H6 H8-H10 H12 H14-H22 = H_3P0
H13 = H_3P6X4P2
H23 = H_4P1X3P6
J4-J6 PJP801 PJP803 PJP1300 PJP1301 = JUMP_43X79
JACK1 JACK2 = YUQIU_PJ741-F07J1BE-C_6P-T
JCDRA = TE_2260531-1_46P-T
JDIMM1 = DEREN_40-42271-26001RHF_260P-T
JDIMM2 = DEREN_40-42261-26001RHF_260P-T
JDP = ACON_MAR2F-20K1800_20P
JEC = ACES_50521-0084N-P01_8P
JEDP = ACES_50473-0400M-P01_40P
JELC = AMPHE_G846A06201EU_6P-T
JFAN1 JFAN2 = ACES_50278-00401-001_4P
JHDD = STARC_111H30-000000-G4-R_30P
JHDMI = ACON_HMRA3-AK1L0C_19P
JIO = ACES_50473-0300M-P01_30P
JKB = ACES_50552-03001-P01_30P
JKB2 = ACES_50611-0100N-001_10P
JKB3 JPWR = ACES_87153-06411_6P
JKBBL = ACES_50552-02001-P01_20P
JLAN = SANTA_130456-512_13P
JLOGO = ACES_87212-1600L_16P
JP1 JP2 PJ800 PJP202 PJP203 PJP301 PJP504 PJP802 PJP8200 = JUMP_43X39
JP3 PJP100-PJP102 PJP104 PJP200 PJP201 PJP300 PJP302 PJP505 PJP8201 PJP8202 = JUMP_43X118
JPCMC = INTEL_CMC_PRIMARY_36P-T
JRTC1 = ACES_50271-00201-001_2P
JSPK = ACES_50278-00601-001_6P-T
JSSD1-JSSD3 = LCN_DAN05-67406-0103_75P-T
JTOBII = ACES_50450-0067N-P01_6P
JTP = ACES_51522-01601-P01_16P
JTRONL JTRONR = ACES_50450-0127N-001_12P
JUSB1 = SDAN_608015-010232_10P
JUSBC1 JUSBC2 = JAE_DX07S024JJ5_24P-T
JWDB = ACES_50207-00471-P01_4P-T
JWLAN = LCN_DAN05-67306-0102_67P
LA3-LA5 LL1 = MURAT_BLM15AG121SN1D_L0402_2P
LA6 = MURAT_BLM15BB221SN1D_2P
LA7 LA8 LA11 LA12 = MURAT_BLM15BD601SN1D_2P
LA9 LA10 = KC_FBMA-L10-160808-800LMT_2P
LA50-LA53 = MURAT_BLM15PX121SN1D_2P
LE1 LE2 = KC_FBMA-L11-160808-800LMT_2P
LE3 = INPAQ_MCM1012B900F06BP_4P-NPM
LG1-LG6 = CHILI_PBY160808T-300Y-N_2P
LM1 LT2 LT3 LU3-LU5 LU7-LU11 LV2 = INPAQ_MCM1012B900F06BP_4P
LT1 = MAG_MND-04ABIR60M-XGL_2P
LV3-LV6 = INPAQ_HCM1012GH900BP_4P-NPM
LX1-LX8 = CHILI_PBY100505T-300Y-N_2P
PBATT1 = ACES_50290-01201-P01_12P-T
PC108 PC115-PC117 PC209 PC215 PC306 PC307 PC1001 PC1002 PC1007 PC1017 PC8207 PC8208 = C_D2
PC539 PC542 = C_ECST250ADA101MF611
PC6108 PC6124 PC6207 PC6221 PC6363 PC6388-PC6391 PC6425 PC6438 = C_D1
PC6112 PC6123 PC6212 PC6226 PC6433 = C_EEFCX1E330R
PD1 = TP0610K-T1-E3_SOT23-3
PD2 PD3 = TVNST52302AB0_SOT523-3
PD5 PD100 = BAS40CW_SOT323-3
PD101 = LL4148_LL34-2
PD700 = BAT54CW_SOT323-3
PH1 PH500-PH504 PH6000 PR2-PR4 PR6 PR8 PR9 PR12-PR14 PR16 PR19 PR21-PR26 PR28 PR101-PR107 PR113 PR115 PR116 PR201 PR205-PR207 PR209 PR210 PR212-PR215 PR301 PR303 PR306-PR308 PR500-PR503 PR505 PR508 PR512-PR519 PR521 PR522 PR524 PR525 PR527-PR551 PR553 PR558-PR562 PR568-PR572 PR578-PR582 PR587-PR589 PR596-PR599 PR700 PR701 PR709-PR711 PR714-PR716 PR718 PR719 PR722-PR726 PR728-PR734 PR801 PR802 PR804 PR805 PR808 PR810-PR812 PR814 PR820 PR821 PR823 PR1300 PR1302 PR1304 PR1305 PR5004 PR5008 PR5011 PR5012 PR5014-PR5016 PR5019-PR5033 PR6000-PR6004 PR6006-PR6014 PR6017 PR6020 PR6022-PR6024 PR6026-PR6030 PR6032 PR6034 PR6036-PR6038 PR6040-PR6042 PR6045-PR6048 PR6050-PR6053 PR6055-PR6070 PR6102-PR6105 PR6109-PR6112 PR6200-PR6203 PR6207-PR6210 PR6212 PR6403 PR6404 PR6406 PR6408 PR6411 PR6413 PR6415-PR6420 PR6423 PR6425-PR6427 PR6430 PR6433-PR6436 PR8201-PR8203 PR8206 PR8208 PR8209 PR8211 PR8214 PR8215 PR8217 PR8218 PR8220 R144-R147 R150 R154 R174 R179-R182 R307 R325 R367 RA2 RA9 RA10 RA13 RA15 RA16 RA18 RA22 RA24 RA27 RA29-RA37 RA42 RA43 RA50 RA53 RA58 RA59 RA61-RA67 RA70 RA73-RA82 RC2 RC9 RC30 RC35 RC62 RC63 RC65 RC66 RC348 RC353-RC355 RD1-RD6 RD28-RD31 RD35 RD38-RD40 RE1 RE2 RE7-RE17 RE20 RE21 RE23 RE25-RE32 RE37 RE40 RE42-RE44 RE63 RE64 RE66 RE70 RE74-RE76 RE79 RE83-RE85 RE89 RE91 RE100-RE102 RE154-RE158 RE160-RE167 RE530 RE636 RE639 RE642-RE645 RE647-RE652 RF1-RF6 RG11 RG12 RG17-RG20 RG23 RG36-RG38 RG47-RG71 RG74-RG95 RG98 RG99 RG101-RG134 RG137 RG138 RG146-RG149 RG154-RG164 RG450-RG453 RG509-RG515 RG523-RG528 RG531 RG532 RG541-RG544 RG549 RG550 RG557 RG562 RH1 RH2 RH4 RH5 RH9 RH16 RH38 RH39 RH57-RH59 RH70-RH75 RH78 RH79 RH83-RH85 RH88-RH90 RH104 RH109 RH111 RH130 RH135 RH148-RH156 RH158 RH163-RH167 RH184-RH188 RH192 RH193 RH196 RH197 RH199 RH201 RH203 RH206 RH207 RH209-RH212 RH453 RH455 RH460-RH463 RH466 RH469 RH472 RH484 RH485 RH489 RH493-RH497 RH501 RH502 RH506 RH512 RH515-RH521 RH524 RH525 RH530 RH531 RH533 RH545 RH571 RH580 RH581 RH584 RH585 RH588 RH589 RL1-RL5 RL8-RL15 RM5 RM6 RM17 RM18 RM20 RM21 RM25 RM27-RM29 RM31 RM38 RM41 RM42 RM61 RM91-RM94 RM96 RN5 RN16 RT5 RT19 RT25 RT48-RT51 RT75 RT108 RT109 RU1-RU7 RU14-RU21 RU23 RV9 RV12 RV13 RV18-RV30 RV33 RV34 RV45 RV500-RV503 RV622-RV635 RV638-RV643 RV645 RV646 RV648-RV653 RV655 RV658 RV659 RV664 RV665 RV673 RV674 RX1 RX2 RX4-RX8 = R_0402
PJPDC1 = ACES_50290-01301-P01_13P-T
PL1 PL3-PL5 = CHENG_SMB3025500YA_2P
PL2 = MURAT_BLM15HG601SN1D_2P
PL100 PL701 = L_5X5X3_M_2P
PL101 PL102 PL700 = CYNTE_PCMB104T-2R2MS_2P
PL201 PL300 PL8200 PL8201 = L_7X7X3_M_2P
PL500 = KC_FBMA-L11-453215800LMA90T_2P
PL501-PL503 PL505 PL506 = CYNTE_PCME064T-R15MS0R667_2P
PL508 = CYNTE_PCMB053T-R47MS_2P
PL509 PL800 PL801 = CYNTE_PCMB042T-1R0MS_2P
PL6100 PL6101 PL6200 PL6201 = MAG_MMD12DZNR22MEX_4P
PL6400 PL6401 = MAG_MMD-10DZ-R22MES1L_2P
PQ2 = RHU002N06_SOT323-3
PQ3 QV1 = SI3457CDV-T1-GE3_TSOP6
PQ4 PQ8 PQ700 PQ705 Q2410 QS3 QV95 = SSM3K7002FU_SC70-3
PQ7 = FDV301N_NL_SOT23-3
PQ100 PQ102 = AON7518_DFN8-5
PQ101 PQ103 = AON7534_DFN3X3-8-5
PQ200 PQ300 = AON7408L_DFN8-5
PQ201 PQ301 = AON7506_DFN33-8-5
PQ202 PQ710 PQ8202 PQ8203 QG6 QG7 QG501-QG505 QG507 QG508 QV96 QV97 = 2N7002DW-7-F_SOT363-6
PQ701-PQ703 PQ707 PQ708 = MDU1512RH_POWERDFN56-8-5
PQ704 = AON6414AL_DFN8-5
PQ706 = MDV1525URH_PDFN33-8-5
PQ6400-PQ6403 = AON6992_DFN5X6D-8-7
PQ8200 PQ8201 = FDMS3660S_POWER56-8-7
PR17 PR100 PR112 PR114 PR208 PR211 PR300 PR504 PR506 PR507 PR509-PR511 PR520 PR523 PR526 PR552 PR556 PR563 PR566 PR573 PR576 PR585 PR590 PR591 PR594 PR703 PR704 PR717 PR720 PR721 PR727 PR807 PR813 PR815 PR1301 PR5001 PR5006 PR5007 PR5017 PR5018 PR5034 PR6005 PR6015 PR6016 PR6018 PR6019 PR6021 PR6025 PR6031 PR6039 PR6043 PR6044 PR6049 PR6054 PR6107 PR6114 PR6205 PR6410 PR6412 PR6421 PR6422 PR6428 PR6429 PR6431 PR6432 PR8216 PR8219 R184 R185 RA51 RA55 RA56 RE78 RT53 RT97 RV47 RV81 RV618 RV619 = R0402_0OHM
PR108 PR109 PR200 PR203 PR204 PR302 PR554 PR557 PR564 PR567 PR574 PR577 PR583 PR586 PR592 PR595 PR705 PR706 PR708 PR803 PR806 PR809 PR816 PR5003 PR5005 PR5010 PR6035 PR6106 PR6108 PR6113 PR6115 PR6204 PR6206 PR6211 PR6213 PR6400 PR6405 PR6407 PR6409 PR6414 PR6424 PR8200 PR8205 PR8207 RA5 RA69 RH6 RH7 = R_0603
PR110 PR111 PR202 PR305 PR555 PR565 PR575 PR584 PR593 PR707 PR713 PR5002 PR5009 PR8204 PR8210 = R_1206
PR702 = R_2512_4P
PR712 = R_1206_4P-D
PR6100 PR6101 PR6401 = RL-3264-9W-R005-FNH_2512_2512
PU100 = TPS51225CRUKR_QFN20_3X3-S
PU201 = RT8207PGQW_WQFN20_3X3-S
PU300 = TPS51212DSCR_SON10_3X3-S
PU500 = ISL95855HRTZ-T_TQFN48_6X6-S
PU502-PU504 PU507 PU510 PU6100 PU6101 PU6200 PU6201 = SIC632CDT1GE3_POWERPAK31_5X5
PU509 PU800 PU802 = SY8286RAC_QFN20_3X3
PU511 = SIC531CDT1GE3_POWERPAK22_4X3
PU700 = BQ24780RUYR_WQFN28_4X4-S
PU1300 = RT9059GSP_SO8
PU6000 = UP9511PQGJ_VQFN40_5X5
PU6400 = UP1666QQKF_WQFN20_3X3
PU8200 = RT8812AGQW_WQFN20_3X3-S
Q7-Q9 = DMN65D8LDW-7_SOT363-6
Q28 Q29 Q34 QE1 QE3 QE4 QE13 QE21 QE22 QE49-QE53 QE57 QG500 QH5 QM2 = DMN66D0LDW-7_SOT363-6
Q2407 Q2408 Q2411 QX2 QX3 = MMST3904-7-F_SOT323-3
Q2409 = SI3456DDV-T1-GE3_TSOP6
QE2 QE5 QG5 QU1 QV2 = 2N7002W-T-R7_SOT323-3
QE8 QM1 QM3 = SI2301CDS-T1-GE3_SOT23-3
QE29 QE39-QE48 = MMDT3904-7-F_SOT363-6
QE54-QE56 = BC857BS_SOT363-6
QG2-QG4 QG8 QG506 QG510 QG511 = MESS138W-G_SOT323-3
QL3 = 2N7002K_SOT23-3
QX1 = BSS138-G_SOT23-3
R2 RA1 RA3 RA4 RA6-RA8 RA11 RA68 RE24 = R0603_0OHM
R363-R366 RA12 RA17 RA21 RA26 RA28 RA40 RA41 RA44 RA45 RA52 RA85 RE300 RE396-RE401 RE449 RE451-RE529 RE630-RE635 RE637 RE638 RE640 RE641 RE646 RG1-RG4 RG6-RG9 RG13-RG16 RG21 RG22 RG24-RG26 RG150 RG151 RG500-RG504 RG506-RG508 RG516-RG519 RG522 RG529 RG530 RG533-RG537 RG540 RG545 RG551-RG556 RG561 RG563-RG565 RH21-RH30 RH537 RH558 RH656 RH657 RM14 RM23 RM26 RM62 RM64 RM66 RM70 RM72 RM75 RM76 RM79 RM81 RM82 RM84-RM87 RN15 RN17 RS1-RS3 RT2-RT4 RT6-RT9 RT11 RT12 RT14 RT16-RT18 RT20-RT24 RT26-RT47 RT57-RT73 RT76-RT80 RT83 RT86 RT94 RT102 RT107 RU24-RU26 RV1 RV8 RV15-RV17 RV600 RV669-RV672 RX31-RX38 = R_0201
RA19 RA25 RA38 RA39 RA46 RA47 RA84 RS8 RT1 RT10 RT13 RT15 RT74 RT98-RT101 = R0201_0OHM
RA57 RA60 RA83 RH12 RT95 RU12 = R_0805
RE90 RP2 RP3 RP5 RPH5 RPH6 RPT1 = RP_0804_8P4R
SW1 = SW_TST71-N-220-T170-S017_2P
T1 T2 T6 T7 T9-T13 T41 T43 T44 T49 T50 T62-T71 T73-T76 T81 T82 T85 T88 T89 T112-T114 T120-T122 TC24 = TPC12
TL1 = MHPC_NS692417_24P
U16 = AOZ1334DI-02_DFN8-7_3X3
U17 UG12 = TPS22966DPUR_SON14_2X3
U18 UE9 UU3 UV17 = SY6288C20AAC_SOT23-5
U19 U20 = AOZ1334DI-01_DFN8-7_3X3
U2407 = F75305M_MSOP10
UA1 = ALC3266-CG_QFN56_7X7-S
UA2 UA3 = MAX9892ERTLFT_UCSP_6P
UA4 = ALC1309-CG_QFN56_7X7-S
UC1 = 74AUP1G07GW_TSSOP5
UE1 = C8051F347-GQ_LQFP32_7X7
UE2 = EN25F80-75HCP_SO8
UE3 UE4 UE8 = TLC59116FIRHBR_VQFN32_5X5-S
UE5 = KB9022QD_LQFP128_14X14
UE6 UE10 = KC3810_QFN24_4X4-S
UE12 UL2 = SY6288D20AAC_SOT23-5
UG1-UG8 = H5GQ1H24AFR-T2L_BGA_170P
UG9 = N17E-G1_BGA_2152P
UG10 UG22 UG26 UG28 UG29 UX1 UX2 = NL17SZ08DFT2G_SC70-5
UG11 = INA3221AIRGVR_VQFN16_4X4-S
UG13 UG15 = W25Q80EWSSIG_SO8
UG14 = TPS22961DNYR_WSON8
UG16 = PI5A3158BZAEX_TDFN12_1X3
UG23 UG24 = BSS138DW_SC88-6
UG25 UG27 = 74LVC1G32GW_TSSOP5
UH1 = SKY-S-PCH_BGA_837P-T
UH3 UM3 UM7 = TC7SH08FU_SSOP5
UH4 = W25Q128FVSIQ_SO8
UL1 = E2201-BL3A-R_QFN40_5X5-S
UM4 = PI6CEQ20200LIEX_TSSOP20
UM8 = DS80PCI402_WQFN54_10X5P5-S
US1 = LNG3DMTR_LGA16_3X3
UT1 = ALPINE-RIDGE_BGA_337P
UT2 = W25Q80DVSSIG_SO8
UT4 = TPS65982_BGA_96P
UU1 = TPS2540RTER_QFN16_3X3-S
UU5 = TC7SZ14FU_SSOP5
UU7 = TPS25810RVCR_QFN20_4X3-S
UV3 UV22 = SN74CBT3257CPWR_TSSOP16
UV21 = PS8331BQFN60GTR-A0_QFN60_5X9-S
UZ21 = APE8937GN2_DFN8_2X2
YG1 = Y_5YEA27000163IF50Q5_4P
YH1 = Y_CM31532768DZFT_2P
YH2 = Y_X3G024000DC1H_4P
YL1 = Y_FSX3M-25PM20FDO_4P
YT1 = Y_7V25000012_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002DW-7-F_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
2N7002K_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
2N7002W-T-R7_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74LVC1G32GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50207-00471-P01_4P-T
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0)
  rect 1.194x1.702 smd: 5(-3.7,1.45) 6(1.3,1.45)
ACES_50271-00201-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(-2.55,-2.9) 4(3.8,-2.9)
ACES_50278-00401-001_4P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 1.295x3.353 smd: 5(-2.85,-4.925) 6(6.6,-4.925)
ACES_50278-00601-001_6P-T
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0)
  rect 1.295x3.353 smd: 7(-2.85,-4.925) 8(9.1,-4.925)
ACES_50290-01201-P01_12P-T
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0) 12(16.5,0)
ACES_50290-01301-P01_13P-T
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0) 12(16.5,0) 13(18,0)
ACES_50450-0067N-P01_6P
  oval 0.508x1.295 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0)
  rect 1.194x1.702 smd: 7(-1.3,1.3) 8(5.3,1.3)
ACES_50450-0127N-001_12P
  oval 0.508x1.295 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 9(6.4,0) 10(7.2,0) 11(8,0) 12(8.8,0)
  rect 1.194x1.702 smd: 13(-1.3,1.9) 14(10.1,1.9)
ACES_50473-0300M-P01_30P
  oval 0.254x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0)
  rect 0.559x1.092 smd: 31(-0.9,0) 32(15.4,0)
  rect 1.397x1.905 smd: 33(-3.1,-2.92) 34(17.6,-2.92)
ACES_50473-0400M-P01_40P
  oval 0.254x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 0.559x1.092 smd: 41(-0.9,0) 42(20.4,0)
  rect 1.397x1.905 smd: 43(-3.1,-2.92) 44(22.6,-2.92)
ACES_50521-0084N-P01_8P
  oval 0.305x1.092 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0)
  rect 0.406x0.787 smd: 9(1,-2.65) 10(-4.5,-2.65)
ACES_50552-02001-P01_20P
  oval 0.406x1.6 smd: 1(0,0) 2(0.5,-2.4) 3(1,0) 4(1.5,-2.4) 5(2,0) 6(2.5,-2.4) 7(3,0) 8(3.5,-2.4) 9(4,0) 10(4.5,-2.4) 11(5,0) 12(5.5,-2.4) 13(6,0) 14(6.5,-2.4) 15(7,0) 16(7.5,-2.4) 17(8,0) 18(8.5,-2.4) 19(9,0) 20(9.5,-2.4)
  rect 1.702x2.896 smd: 21(-1.65,-1.2) 22(11.15,-1.2)
ACES_50552-03001-P01_30P
  oval 0.406x1.6 smd: 1(0,0) 2(0.5,-2.4) 3(1,0) 4(1.5,-2.4) 5(2,0) 6(2.5,-2.4) 7(3,0) 8(3.5,-2.4) 9(4,0) 10(4.5,-2.4) 11(5,0) 12(5.5,-2.4) 13(6,0) 14(6.5,-2.4) 15(7,0) 16(7.5,-2.4) 17(8,0) 18(8.5,-2.4) 19(9,0) 20(9.5,-2.4) 21(10,0) 22(10.5,-2.4) 23(11,0) 24(11.5,-2.4) 25(12,0) 26(12.5,-2.4) 27(13,0) 28(13.5,-2.4) 29(14,0) 30(14.5,-2.4)
  rect 1.702x2.896 smd: 31(-1.65,-1.2) 32(16.15,-1.2)
ACES_50611-0100N-001_10P
  oval 0.61x1.651 smd: 1(0,0) 3(1,0) 5(2,0) 7(3,0) 9(4,0) 11(5,0) 13(6,0) 15(7,0) 17(8,0) 19(9,0)
  oval 0.61x1.854 smd: 2(0,3.75) 4(1,3.75) 6(2,3.75) 8(3,3.75) 10(4,3.75) 12(5,3.75) 14(6,3.75) 16(7,3.75) 18(8,3.75) 20(9,3.75)
ACES_51522-01601-P01_16P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0)
  rect 2.489x1.905 smd: 17(-2.15,-3.3) 18(9.65,-3.3)
ACES_87153-06411_6P
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3)
  rect 0.787x1.499 smd: 7(3.5,3) 8(3.5,0) 9(-1,0) 10(-1,3)
ACES_87212-1600L_16P
  oval 0.457x1.499 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0) 9(8,0) 10(9,0) 11(10,0) 12(11,0) 13(12,0) 14(13,0) 15(14,0) 16(15,0)
  rect 1.194x1.803 smd: 17(-1.3,2.55) 18(16.3,2.55)
ACON_HMRA3-AK1L0C_19P
  round 0.813 hole 0.559: 1(0,0) 2(0.5,1.55) 3(1,0) 4(1.5,1.55) 5(2,0) 6(2.5,1.55) 7(3,0) 8(3.5,1.55) 9(4,0) 10(4.5,1.55) 11(5,0) 12(5.5,1.55) 13(6,0) 14(6.5,1.55) 15(7,0) 16(7.5,1.55) 17(8,0) 18(8.5,1.55) 19(9,0)
  oval 1.499x2.21 hole 0.889x1.6: 20(-2.75,1.7) 21(-4.65,-6.5) 22(11.75,1.7) 23(13.65,-7.75)
ACON_MAR2F-20K1800_20P
  round 1.194 hole 1.194 unplated: (-6.95,-0.5) (1.55,-0.5)
  round 0.813 hole 0.508: 1(0,0) 3(-0.6,-1.2) 5(-1.1,0) 7(-1.7,-1.2) 9(-2.2,0) 11(-3.2,0) 13(-3.7,-1.2) 15(-4.3,0) 17(-4.8,-1.2) 19(-5.4,0)
  oval 0.406x1.88 smd: 2(0,-2.995) 4(-0.6,-2.995) 6(-1.2,-2.995) 8(-1.8,-2.995) 10(-2.4,-2.995) 12(-3,-2.995) 14(-3.6,-2.995) 16(-4.2,-2.995) 18(-4.8,-2.995) 20(-5.4,-2.995)
  oval 1.194x2.261 hole 0.711x1.753: 21(-8.2,2.96) 22(-8.2,-2.04) 23(2.8,2.96) 24(2.8,-2.04)
ALC1309-CG_QFN56_7X7-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7.1,-5.2) 30(7.1,-4.8) 31(7.1,-4.4) 32(7.1,-4) 33(7.1,-3.6) 34(7.1,-3.2) 35(7.1,-2.8) 36(7.1,-2.4) 37(7.1,-2) 38(7.1,-1.6) 39(7.1,-1.2) 40(7.1,-0.8) 41(7.1,-0.4) 42(7.1,0)
  oval 0.203x0.889 smd: 15(0.95,-6.15) 16(1.35,-6.15) 17(1.75,-6.15) 18(2.15,-6.15) 19(2.55,-6.15) 20(2.95,-6.15) 21(3.35,-6.15) 22(3.75,-6.15) 23(4.15,-6.15) 24(4.55,-6.15) 25(4.95,-6.15) 26(5.35,-6.15) 27(5.75,-6.15) 28(6.15,-6.15) 43(6.15,0.95) 44(5.75,0.95) 45(5.35,0.95) 46(4.95,0.95) 47(4.55,0.95) 48(4.15,0.95) 49(3.75,0.95) 50(3.35,0.95) 51(2.95,0.95) 52(2.55,0.95) 53(2.15,0.95) 54(1.75,0.95) 55(1.35,0.95) 56(0.95,0.95)
  rect 4.597x4.597 smd: 57(3.55,-2.6)
ALC3266-CG_QFN56_7X7-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 29(7.1,-5.2) 30(7.1,-4.8) 31(7.1,-4.4) 32(7.1,-4) 33(7.1,-3.6) 34(7.1,-3.2) 35(7.1,-2.8) 36(7.1,-2.4) 37(7.1,-2) 38(7.1,-1.6) 39(7.1,-1.2) 40(7.1,-0.8) 41(7.1,-0.4) 42(7.1,0)
  oval 0.203x0.889 smd: 15(0.95,-6.15) 16(1.35,-6.15) 17(1.75,-6.15) 18(2.15,-6.15) 19(2.55,-6.15) 20(2.95,-6.15) 21(3.35,-6.15) 22(3.75,-6.15) 23(4.15,-6.15) 24(4.55,-6.15) 25(4.95,-6.15) 26(5.35,-6.15) 27(5.75,-6.15) 28(6.15,-6.15) 43(6.15,0.95) 44(5.75,0.95) 45(5.35,0.95) 46(4.95,0.95) 47(4.55,0.95) 48(4.15,0.95) 49(3.75,0.95) 50(3.35,0.95) 51(2.95,0.95) 52(2.55,0.95) 53(2.15,0.95) 54(1.75,0.95) 55(1.35,0.95) 56(0.95,0.95)
  rect 4.597x4.597 smd: 57(3.55,-2.6)
ALPINE-RIDGE_BGA_337P
  round 0.254 smd: A1(0,0) A23(10.12,0) AA2(0.46,-9.2) AA22(9.66,-9.2) AB2(0.46,-9.66) AB3(0.92,-9.66) AB4(1.38,-9.66) AB5(1.84,-9.66) AB6(2.3,-9.66) AB7(2.76,-9.66) AB8(3.22,-9.66) AB9(3.68,-9.66) AB10(4.14,-9.66) AB11(4.6,-9.66) AB12(5.06,-9.66) AB13(5.52,-9.66) AB14(5.98,-9.66) AB15(6.44,-9.66) AB16(6.9,-9.66) AB17(7.36,-9.66) AB18(7.82,-9.66) AB19(8.28,-9.66) AB20(8.74,-9.66) AB21(9.2,-9.66) AB22(9.66,-9.66) AC1(0,-10.12) AC23(10.12,-10.12) B2(0.46,-0.46) B3(0.92,-0.46) B4(1.38,-0.46) B5(1.84,-0.46) B6(2.3,-0.46) B7(2.76,-0.46) B8(3.22,-0.46) B9(3.68,-0.46) B10(4.14,-0.46) B11(4.6,-0.46) B12(5.06,-0.46) B13(5.52,-0.46) B14(5.98,-0.46) B15(6.44,-0.46) B16(6.9,-0.46) B17(7.36,-0.46) B18(7.82,-0.46) B19(8.28,-0.46) B20(8.74,-0.46) B21(9.2,-0.46) B22(9.66,-0.46) C2(0.46,-0.92) C22(9.66,-0.92) D2(0.46,-1.38) D4(1.16,-1.16) D5(1.81,-1.16) D6(2.46,-1.16) D8(3.11,-1.16) D9(3.76,-1.16) D11(4.41,-1.16) D12(5.06,-1.16) D13(5.71,-1.16) D15(6.36,-1.16) D16(7.01,-1.16) D18(7.66,-1.16) D19(8.31,-1.16) D20(8.96,-1.16) D22(9.66,-1.38) E2(0.46,-1.84) E4(1.16,-1.81) E5(1.81,-1.81) E6(2.46,-1.81) E8(3.11,-1.81) E9(3.76,-1.81) E11(4.41,-1.81) E12(5.06,-1.81) E13(5.71,-1.81) E15(6.36,-1.81) E16(7.01,-1.81) E18(7.66,-1.81) E19(8.31,-1.81) E20(8.96,-1.81) E22(9.66,-1.84) F2(0.46,-2.3) F4(1.16,-2.46) F5(1.81,-2.46) F6(2.46,-2.46) F8(3.11,-2.46) F9(3.76,-2.46) F11(4.41,-2.46) F12(5.06,-2.46) F13(5.71,-2.46) F15(6.36,-2.46) F16(7.01,-2.46) F18(7.66,-2.46) F19(8.31,-2.46) F20(8.96,-2.46) F22(9.66,-2.3) G2(0.46,-2.76) G22(9.66,-2.76) H2(0.46,-3.22) H4(1.16,-3.11) H5(1.81,-3.11) H6(2.46,-3.11) H8(3.11,-3.11) H9(3.76,-3.11) H11(4.41,-3.11) H12(5.06,-3.11) H13(5.71,-3.11) H15(6.36,-3.11) H16(7.01,-3.11) H18(7.66,-3.11) H19(8.31,-3.11) H20(8.96,-3.11) H22(9.66,-3.22) J2(0.46,-3.68) J4(1.16,-3.76) J5(1.81,-3.76) J6(2.46,-3.76) J8(3.11,-3.76) J9(3.76,-3.76) J11(4.41,-3.76) J12(5.06,-3.76) J13(5.71,-3.76) J15(6.36,-3.76) J16(7.01,-3.76) J18(7.66,-3.76) J19(8.31,-3.76) J20(8.96,-3.76) J22(9.66,-3.68) K2(0.46,-4.14) K22(9.66,-4.14) L2(0.46,-4.6) L4(1.16,-4.41) L5(1.81,-4.41) L6(2.46,-4.41) L8(3.11,-4.41) L9(3.76,-4.41) L11(4.41,-4.41) L12(5.06,-4.41) L13(5.71,-4.41) L15(6.36,-4.41) L16(7.01,-4.41) L18(7.66,-4.41) L19(8.31,-4.41) L20(8.96,-4.41) L22(9.66,-4.6) M2(0.46,-5.06) M4(1.16,-5.06) M5(1.81,-5.06) M6(2.46,-5.06) M8(3.11,-5.06) M9(3.76,-5.06) M11(4.41,-5.06) M12(5.06,-5.06) M13(5.71,-5.06) M15(6.36,-5.06) M16(7.01,-5.06) M18(7.66,-5.06) M19(8.31,-5.06) M20(8.96,-5.06) M22(9.66,-5.06) N2(0.46,-5.52) N4(1.16,-5.71) N5(1.81,-5.71) N6(2.46,-5.71) N8(3.11,-5.71) N9(3.76,-5.71) N11(4.41,-5.71) N12(5.06,-5.71) N13(5.71,-5.71) N15(6.36,-5.71) N16(7.01,-5.71) N18(7.66,-5.71) N19(8.31,-5.71) N20(8.96,-5.71) N22(9.66,-5.52) P2(0.46,-5.98) P22(9.66,-5.98) R2(0.46,-6.44) R4(1.16,-6.36) R5(1.81,-6.36) R6(2.46,-6.36) R8(3.11,-6.36) R9(3.76,-6.36) R11(4.41,-6.36) R12(5.06,-6.36) R13(5.71,-6.36) R15(6.36,-6.36) R16(7.01,-6.36) R18(7.66,-6.36) R19(8.31,-6.36) R20(8.96,-6.36) R22(9.66,-6.44) T2(0.46,-6.9) T4(1.16,-7.01) T5(1.81,-7.01) T6(2.46,-7.01) T8(3.11,-7.01) T9(3.76,-7.01) T11(4.41,-7.01) T12(5.06,-7.01) T13(5.71,-7.01) T15(6.36,-7.01) T16(7.01,-7.01) T18(7.66,-7.01) T19(8.31,-7.01) T20(8.96,-7.01) T22(9.66,-6.9) U2(0.46,-7.36) U22(9.66,-7.36) V2(0.46,-7.82) V4(1.16,-7.66) V5(1.81,-7.66) V6(2.46,-7.66) V8(3.11,-7.66) V9(3.76,-7.66) V11(4.41,-7.66) V12(5.06,-7.66) V13(5.71,-7.66) V15(6.36,-7.66) V16(7.01,-7.66) V18(7.66,-7.66) V19(8.31,-7.66) V20(8.96,-7.66) V22(9.66,-7.82) W2(0.46,-8.28) W4(1.16,-8.31) W5(1.81,-8.31) W6(2.46,-8.31) W8(3.11,-8.31) W9(3.76,-8.31) W11(4.41,-8.31) W12(5.06,-8.31) W13(5.71,-8.31) W15(6.36,-8.31) W16(7.01,-8.31) W18(7.66,-8.31) W19(8.31,-8.31) W20(8.96,-8.31) W22(9.66,-8.28) Y2(0.46,-8.74) Y4(1.16,-8.96) Y5(1.81,-8.96) Y6(2.46,-8.96) Y8(3.11,-8.96) Y9(3.76,-8.96) Y11(4.41,-8.96) Y12(5.06,-8.96) Y13(5.71,-8.96) Y15(6.36,-8.96) Y16(7.01,-8.96) Y18(7.66,-8.96) Y19(8.31,-8.96) Y20(8.96,-8.96) Y22(9.66,-8.74)
  oval 0.178x0.33 smd: A2(0.46,0) A3(0.92,0) A4(1.38,0) A5(1.84,0) A6(2.3,0) A7(2.76,0) A8(3.22,0) A9(3.68,0) A10(4.14,0) A11(4.6,0) A12(5.06,0) A13(5.52,0) A14(5.98,0) A15(6.44,0) A16(6.9,0) A17(7.36,0) A18(7.82,0) A19(8.28,0) A20(8.74,0) A21(9.2,0) A22(9.66,0) AC2(0.46,-10.12) AC3(0.92,-10.12) AC4(1.38,-10.12) AC5(1.84,-10.12) AC6(2.3,-10.12) AC7(2.76,-10.12) AC8(3.22,-10.12) AC9(3.68,-10.12) AC10(4.14,-10.12) AC11(4.6,-10.12) AC12(5.06,-10.12) AC13(5.52,-10.12) AC14(5.98,-10.12) AC15(6.44,-10.12) AC16(6.9,-10.12) AC17(7.36,-10.12) AC18(7.82,-10.12) AC19(8.28,-10.12) AC20(8.74,-10.12) AC21(9.2,-10.12) AC22(9.66,-10.12)
  oval 0.33x0.178 smd: AA1(0,-9.2) AA23(10.12,-9.2) AB1(0,-9.66) AB23(10.12,-9.66) B1(0,-0.46) B23(10.12,-0.46) C1(0,-0.92) C23(10.12,-0.92) D1(0,-1.38) D23(10.12,-1.38) E1(0,-1.84) E23(10.12,-1.84) F1(0,-2.3) F23(10.12,-2.3) G1(0,-2.76) G23(10.12,-2.76) H1(0,-3.22) H23(10.12,-3.22) J1(0,-3.68) J23(10.12,-3.68) K1(0,-4.14) K23(10.12,-4.14) L1(0,-4.6) L23(10.12,-4.6) M1(0,-5.06) M23(10.12,-5.06) N1(0,-5.52) N23(10.12,-5.52) P1(0,-5.98) P23(10.12,-5.98) R1(0,-6.44) R23(10.12,-6.44) T1(0,-6.9) T23(10.12,-6.9) U1(0,-7.36) U23(10.12,-7.36) V1(0,-7.82) V23(10.12,-7.82) W1(0,-8.28) W23(10.12,-8.28) Y1(0,-8.74) Y23(10.12,-8.74)
AMPHE_G846A06201EU_6P-T
  oval 0.508x0.991 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0)
  rect 1.194x1.702 smd: 7(-1.3,1.45) 8(5.3,1.45)
AON6414AL_DFN8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
AON6992_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.62)
AON7408L_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7506_DFN33-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7518_DFN8-5
  oval 0.356x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.57x0.57 smd: 5(0.975,1.4)
