# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PD_EE_CLK: length 6.1
  BOTTOM w0.107: UT4.A3 199.1,160.01 199.1,159.19
  BOTTOM w0.114: 199.1,159.19 198.99,159.08 v1(198.99,158.42) 198.65,158.08 198.65,158.08 197.69,157.13 195.93,157.13 RT101.2
PD_EE_CS_N: length 13.2
  IN1 w0.081: v2(189.24,160.37) 195.33,160.37 197.3,158.4 v2(198.38,158.4)
  BOTTOM w0.076: 198.91,159.65 198.91,160.32 UT4.B3
  BOTTOM w0.107: 198.38,158.85 198.38,158.97 198.91,159.5 198.91,159.65
  BOTTOM w0.114: RT100.2 189.01,160.27 189.11,160.37 v2(189.24,160.37) ; 198.38,158.85 v2(198.38,158.4)
PD_EE_DI: length 6.7
  BOTTOM w0.076: 199.53,159.04 199.41,159.15 199.41,160.32 199.65,160.57 UT4.B4
  BOTTOM w0.107: 199.59,158.85 199.59,158.97 199.53,159.04
  BOTTOM w0.114: 199.59,158.85 199.59,158.27 197.91,156.6 v1(197.38,156.6) RT98.2
PD_EE_DO: length 17
  IN1 w0.081: v2(189.11,163.11) 189.11,162.66 191.19,160.58 195.41,160.58 197.2,158.8 198.55,158.8 198.83,158.52 198.83,157.77 v2(199.27,157.32)
  BOTTOM w0.114: v2(199.27,157.32) 199.3,157.32 199.91,157.93 199.91,159.1 199.66,159.35 UT4.A4 ; RT99.2 189.24,162.99 v2(189.11,163.11)
PD_IRQ#: length 250.3
  TOP w0.107: UE5.89 302.74,9.6 299.54,12.8 v2(299.54,14.13)
  IN4 w0.102: v2(205.04,156.12) 204.62,156.12 202.85,154.34 202.85,150.57 201.42,149.14 201.42,147.31 202.18,146.55 202.18,142.51 205.18,139.52 205.18,135.03 202.94,132.79 202.94,130.35 202.13,129.53 202.13,128.31 203.13,127.31 203.13,125.72 203.7,125.14 203.7,113.71 206.85,110.56 206.85,102.34 207.44,101.76 207.44,66.97 206.99,66.52 206.99,62.26 207.4,61.86 207.4,53.99 210.13,51.26 210.13,50.23 212.97,47.4 214.15,47.4 216.16,45.39 224.15,45.39 224.97,44.57 225.52,44.57 226.27,43.82 226.76,43.82 227.71,42.87 228.41,42.87 228.55,43.01 232.56,43.01 233.99,44.44 239.01,44.44 239.6,43.86 240.45,43.86 241.04,44.44 247.75,44.44 247.98,44.67 259.95,44.67 260.56,44.06 268.63,44.06 273.79,38.9 278.34,38.9 279.62,40.18 290.76,40.18 291.57,39.36 294.88,39.36 v2(295.79,38.45)
  BOTTOM w0.076: 200.55,159.62 200.41,159.77 200.41,160.32 UT4.B6
  BOTTOM w0.089: 200.55,159.62 200.93,159.25
  BOTTOM w0.102: v2(295.79,38.45) 297.95,36.29 297.95,31.85 297.54,31.43 297.54,16.13 v2(299.54,14.13) ; v2(205.04,156.12) 205.15,156 RT107.2
  BOTTOM w0.107: 200.93,159.25 201.05,159.12 v1(201.05,156.92) 201.05,156.8 201.74,156.12 v2(205.04,156.12)
PD_RESET: length 3.4
  TOP w0.102: UE10.8 320,56.94 320.2,56.74 320.2,55.09 v2(320.02,54.91) 319.92,54.81 RT109.1
PD_UART: length 3.2
  TOP w0.102: v1(197.19,162.15) 197.47,162.43 v2(197.62,162.43)
  TOP w0.107: v2(197.62,162.43) 197.97,162.43 198.26,162.13 RT62.1
  BOTTOM w0.076: UT4.E2 198.53,162.07 198.28,162.32 197.73,162.32 v2(197.62,162.43)
  BOTTOM w0.127: UT4.F2 UT4.E2
PECI_KB9012: length 2.1
  TOP w0.114: UE5.118 308.7,18.21 RE76.1
PEG_CRX_C_GTX_N8: length 2.5
  BOTTOM w0.099: UM8.4 134.61,153.08
  BOTTOM w0.107: 134.61,153.08 134.76,152.94 134.81,152.89 134.81,152.16 135.01,151.95 135.01,151.47 CM69.2
PEG_CRX_C_GTX_N9: length 2.5
  BOTTOM w0.107: UM8.8 132.61,152.86 132.71,152.77 132.71,152.61 132.4,152.3 v3(132.4,152.04) 132.4,151.46 CM66.2
PEG_CRX_C_GTX_N10: length 4.5
  BOTTOM w0.099: UM8.6 133.61,152.79 133.75,152.65
  BOTTOM w0.107: CM62.2 133.6,149.61 133.6,149.86 133.79,150.05 v3(133.79,150.59) 133.79,151.62 133.76,151.65 133.76,152.26 133.79,152.29 133.79,152.61 133.75,152.65
PEG_CRX_C_GTX_N11: length 4.6
  BOTTOM w0.107: UM8.2 135.61,152.95 135.77,152.79 135.77,152.51 v3(136.13,152.15) 136.33,151.95 136.33,151.12 136.31,151.09 136.31,150.52 136.33,150.49 136.33,149.55 CM65.2
PEG_CRX_C_GTX_P8: length 2.5
  BOTTOM w0.099: UM8.3 135.11,153.05
  BOTTOM w0.107: 135.11,153.05 135.01,152.95 135.01,152.24 135.21,152.04 135.21,151.49 CM67.2
PEG_CRX_C_GTX_P9: length 2.6
  BOTTOM w0.107: CM63.2 132.63,151.47 132.63,152.25 132.91,152.53 132.91,152.75 133.11,152.95 UM8.7
PEG_CRX_C_GTX_P10: length 4.4
  BOTTOM w0.099: UM8.5 134.11,152.79
  BOTTOM w0.107: 134.11,152.79 133.99,152.67 v3(133.99,151.97) 133.99,150.9 134.02,150.88 134.02,150.31 133.99,150.28 133.99,149.97 133.8,149.78 133.8,149.54 CM68.2
PEG_CRX_C_GTX_P11: length 4.6
  BOTTOM w0.107: UM8.1 136.11,152.94 135.98,152.8 135.98,152.62 136.08,152.51 136.1,152.51 136.54,152.07 v3(136.54,150.81) 136.54,149.6 CM64.2
PEG_CRX_GTX_N0: length 59.6
  TOP w0.107: CG9.1 206.07,132.87 205.69,132.49 v3(205.69,131.02) 205.69,130.14 204.54,129 203.66,129 203.35,128.69 203.35,128.45 v2(203.2,128.3)
  IN3 w0.089: v2(170.05,99.89) 170.05,99.61 170.32,99.34 170.64,99.34 171.08,98.9 172.44,98.9 172.57,98.77 178.76,98.77 179.35,99.37 179.44,99.37
  IN3 w0.127: v2(203.2,128.3) 203.35,128.14 203.35,127.96 203.16,127.77 202.78,127.77 202.45,128.1 199.84,128.1 198.32,126.58 198.32,123.99 192.5,118.18 192.5,117.27 190.46,115.23 190.46,113.13 188.27,110.94 187.82,110.94 185.62,108.74 185.62,107.89 182.88,105.16 182.88,104.25 180.93,102.3 180.93,100.86 179.44,99.37
  BOTTOM w0.076: v2(170.05,99.89) 170.05,99.81 CPU1.E10
PEG_CRX_GTX_N0_C: length 41.4
  TOP w0.107: v2(236.07,113.9) 236.07,114.14 236.2,114.27 236.44,114.27 236.55,114.38 236.55,119.36 236.04,119.86 236.04,120.39 234.42,122.02 v3(223.49,122.02) 220.45,122.02 209.96,132.51 209.34,132.51 209.31,132.53 208.74,132.53 208.71,132.51 208.28,132.51 208.16,132.62 208.16,132.77 208.06,132.87 CG9.2
  BOTTOM w0.117: UG9.BH26 236.47,113.78 236.35,113.9 v2(236.07,113.9)
PEG_CRX_GTX_N1: length 58.7
  TOP w0.107: v2(202.96,129.42) 202.96,130.34 203.29,130.66 204.2,130.66 204.52,130.98 v3(204.52,132.11) 204.52,133.37 204.97,133.81 205.64,133.81 CG16.1
  IN3 w0.089: v2(170.71,99.87) 170.71,99.87 171.28,99.29 172.42,99.29 173.06,99.93 178.59,99.93 178.96,100.3 179.53,100.3
  IN3 w0.127: v2(202.96,129.42) 202.96,129.42 203.15,129.6 203.15,129.89 203.02,130.02 202.19,130.02 201.91,129.73 199.56,129.73 196.63,126.81 196.63,125.35 195.17,123.89 195.17,122.75 193.09,120.66 193.09,120.2 191.01,118.12 191.01,117.15 190.94,117.09 190.94,117.09 189.77,115.92 189.77,114.17 186.89,111.28 186.89,110.73 184.91,108.75 184.91,107.9 182.37,105.37 182.37,104.46 180.43,102.51 180.43,101.07 179.65,100.3 179.53,100.3
  BOTTOM w0.076: CPU1.E11 170.38,100.2 v2(170.71,99.87)
PEG_CRX_GTX_N1_C: length 46.5
  TOP w0.107: v2(236.17,111.25) 236.33,111.41 236.46,111.41 236.78,111.74 236.78,113.8 236.98,114 236.98,116 237.05,116.08 237.05,119.41 236.78,119.68 v3(236.78,120.22) 236.78,120.64 234.69,122.73 220.72,122.73 209.81,133.63 207.53,133.63 207.27,133.89 CG16.2
  BOTTOM w0.107: v2(236.17,111.25) 236.17,111.44 236.28,111.55 UG9.BE26
PEG_CRX_GTX_N2: length 62.8
  TOP w0.107: v2(203.49,134.59) 203.37,134.59 203.03,134.26 203.03,134.06 203.14,133.95 204.13,133.95 204.76,134.58 206.67,134.58 206.8,134.72 206.85,134.72 CG25.1
  IN3 w0.089: 179.49,101.7 179.43,101.7 178.2,100.47 172.77,100.47 172.62,100.32 170.99,100.32 170.42,100.89 170.29,100.89 v2(170.06,100.66)
  IN3 w0.127: v2(203.49,134.59) 203.27,134.37 203.27,134.02 203.02,133.76 197.2,133.76 196.73,133.29 196.73,129.04 195.69,127.99 194.76,127.99 194.24,127.47 194.24,122.86 188.85,117.48 188.85,115.35 186.06,112.57 186.06,110.94 184.18,109.05 184.18,108.2 181.65,105.67 181.65,104.76 179.7,102.81 179.7,101.91 179.49,101.7
  BOTTOM w0.089: CPU1.E12 170.06,100.73 v2(170.06,100.66)
PEG_CRX_GTX_N2_C: length 44.5
  TOP w0.107: v2(237.6,113.36) 237.59,113.36 237.45,113.23 237.29,113.23 237.18,113.33 237.18,113.63 237.38,113.83 237.38,115.83 237.47,115.92 237.47,121.01 234.94,123.54 220.93,123.54 209.93,134.54 v3(209.04,134.54) 208.02,134.54 207.93,134.63 207.78,134.63 CG25.2
  BOTTOM w0.107: UG9.BG27 237.48,113.26 237.48,113.26 237.59,113.36 v2(237.6,113.36)
PEG_CRX_GTX_N3: length 61.3
  TOP w0.107: v2(203.78,135.1) 203.91,135.22 203.91,135.57 204.14,135.8 205.08,135.8 205.2,135.69 205.33,135.69 205.35,135.67 CG27.1
  IN3 w0.089: v2(170.71,101.45) 171.31,100.84 172.32,100.84 172.98,101.51 178.36,101.51 179.13,102.27 179.13,102.55 179.17,102.58
  IN3 w0.127: 179.17,102.58 179.17,103.31 180.88,105.03 180.88,106.04 183.46,108.61 183.46,109.35 185.23,111.13 185.23,112.76 188.12,115.66 188.12,117.78 193.22,122.88 193.22,128.04 194.82,129.64 194.82,133.43 195.88,134.49 200.75,134.49 202.44,136.18 203.6,136.18 203.97,135.81 203.97,135.28 v2(203.78,135.1)
  BOTTOM w0.076: v2(170.71,101.45) 170.56,101.45 170.38,101.63 CPU1.E13
PEG_CRX_GTX_N3_C: length 46.5
  TOP w0.107: CG27.2 206.57,135.45 206.63,135.45 206.67,135.41 210.11,135.41 221.28,124.24 235.47,124.24 238.16,121.54 v3(238.16,117.79) 238.16,115.8 238.58,115.39 238.58,114.46 238.45,114.33 238.17,114.33 238.04,114.21 238.04,114.05 v2(238.19,113.9)
  BOTTOM w0.107: v2(238.19,113.9) 238.46,113.9 238.57,113.79 UG9.BH29
PEG_CRX_GTX_N4: length 64.7
  TOP w0.107: CG29.1 206.77,136.34 206.25,136.34 206.21,136.38 205.88,136.38 205.88,136.38 205.48,136.38 205.37,136.49 v3(203.54,136.49) 202.8,136.49 202.25,137.04 202.25,137.34 202.63,137.72 v2(202.73,137.72)
  IN3 w0.089: 178.23,103.03 178.23,102.44 178,102.21 174.48,102.21 174.47,102.21 170.94,102.21 170.32,102.84 170.26,102.84 v2(170.05,103.05)
  IN3 w0.127: 178.23,103.03 178.23,103.76 179.78,105.31 179.78,106.27 182.51,109.01 182.51,109.75 184.29,111.52 184.29,113.15 187.18,116.05 187.18,118.17 192.28,123.27 192.28,128.43 193.87,130.03 193.87,134.25 195.9,136.27 199.63,136.27 200.51,137.16 200.51,137.73 201.19,138.4 202.13,138.4 202.35,138.18 202.35,138.09 202.72,137.72 v2(202.73,137.72)
  BOTTOM w0.076: CPU1.E14 170.05,102.96 v2(170.05,103.05)
PEG_CRX_GTX_N4_C: length 49.3
  TOP w0.107: CG29.2 207.86,136.56 207.97,136.45 207.97,136.3 208.08,136.19 v3(209.06,136.19) 210.34,136.19 221.52,125.01 235.71,125.01 239.1,121.62 239.1,116.63 238.97,116.51 238.97,114.06 238.78,113.87 238.78,112.64 238.97,112.45 238.97,111.65 238.8,111.47 238.49,111.47 v2(238.27,111.25)
  BOTTOM w0.117: UG9.BE29 v2(238.27,111.25)
PEG_CRX_GTX_N5: length 62.9
  TOP w0.107: CG31.1 205.56,137.23 205.51,137.23 205.46,137.18 203.69,137.18 203.53,137.34 203.53,137.5 203.93,137.9 v2(203.97,137.9)
  IN3 w0.089: 176.72,103.33 176.72,103.33 176.72,103.3 176.59,103.18 173.03,103.18 172.41,103.79 170.89,103.79 170.67,103.58 v2(170.67,103)
  IN3 w0.127: v2(203.97,137.9) 203.83,138.04 203.83,138.54 203.24,139.12 200.7,139.12 199.17,137.6 196.13,137.6 192.89,134.36 192.89,132.84 192.39,132.33 192.39,131.5 193.02,130.87 193.02,130.2 191.55,128.73 191.55,123.66 186.35,118.46 186.35,116.82 183.48,113.95 183.48,111.75 181.78,110.05 181.78,109.31 178.73,106.26 178.73,105.34 176.72,103.33
  BOTTOM w0.107: CPU1.E15 170.38,103.29 v2(170.67,103)
PEG_CRX_GTX_N5_C: length 50
  TOP w0.107: CG31.2 206.56,137.25 210.27,137.25 221.81,125.71 236.03,125.71 239.85,121.89 v3(239.85,119.59) 239.85,116.23 239.37,115.76 239.37,113.82 239.18,113.63 239.18,113.26 239.3,113.13 239.45,113.13 v2(239.65,113.33)
  BOTTOM w0.117: v2(239.65,113.33) UG9.BG30
PEG_CRX_GTX_N6: length 65.1
  TOP w0.107: v2(202.53,140.36) 202.46,140.36 202.05,139.95 202.05,139.56 202.38,139.22 203.07,139.22 203.57,138.73 204.63,138.73 204.83,138.53 205.75,138.53 206.22,138.06 206.77,138.06 CG33.1
  IN3 w0.089: v2(170.06,103.81) 170.65,103.81 170.82,103.98 172.85,103.98 173.28,103.55 176.07,103.55 177.39,104.88 177.42,104.88 177.46,104.92 177.47,104.91 177.48,104.91 177.49,104.92
  IN3 w0.127: 177.49,104.92 178.13,105.56 178.13,106.37 181.28,109.52 181.28,110.26 182.97,111.96 182.97,114.16 185.05,116.24 185.05,117.95 191.04,123.95 191.04,130.36 191.65,130.97 191.65,135.24 196.37,139.96 200.13,139.96 200.45,139.63 202.06,139.63 202.31,139.88 202.31,140.13 v2(202.53,140.36)
  BOTTOM w0.089: CPU1.E16 170.06,103.88 v2(170.06,103.81)
PEG_CRX_GTX_N6_C: length 49.2
  TOP w0.107: v2(240.29,113.9) 240.15,114.04 240.15,114.23 240.32,114.4 240.61,114.4 240.8,114.59 240.8,118.33 240.57,118.57 240.57,122.25 236.34,126.47 222.11,126.47 210.64,137.94 209.82,137.94 209.79,137.97 209.22,137.97 209.19,137.94 207.95,137.94 207.83,138.06 207.78,138.06 CG33.2
  BOTTOM w0.117: UG9.BH32 240.67,113.76 240.53,113.9 v2(240.29,113.9)
PEG_CRX_GTX_N7: length 63.9
  TOP w0.107: v2(203.89,140.18) 203.65,140.18 203.45,139.98 203.45,139.83 203.72,139.55 205.1,139.55 205.16,139.49 205.54,139.49 205.85,139.8 CG36.1
  IN3 w0.127: v2(203.89,140.18) 203.83,140.24 203.83,140.85 202.19,142.49 197.57,142.49 190.64,135.56 190.64,131.34 190.1,130.81 190.1,124.34 184.07,118.31 184.07,116.6 182.03,114.55 182.03,112.35 180.24,110.56 180.24,109.82 177.21,106.79 177.21,105.98 176.66,105.43 170.92,105.43 170.66,105.17 170.66,104.62 v2(170.64,104.6)
  BOTTOM w0.076: CPU1.E17 170.65,104.67 v2(170.64,104.6)
PEG_CRX_GTX_N7_C: length 54.5
  TOP w0.107: v2(240.37,111.25) 241.01,111.25 241.26,111.5 241.26,122.57 236.49,127.34 222.24,127.34 210.14,139.44 209.17,139.44 209.15,139.47 208.57,139.47 208.55,139.44 207.02,139.44 206.89,139.57 206.89,139.69 206.79,139.8 CG36.2
  BOTTOM w0.117: UG9.BE32 v2(240.37,111.25)
PEG_CRX_GTX_N8: length 87.9
  IN3 w0.091: 172.6,105.82 172.41,105.63 170.3,105.63 v2(170.06,105.39)
  IN3 w0.127: 172.6,105.82 173.36,106.59 173.86,106.59 174.71,107.44 174.71,110.62 175.75,111.67 175.75,122.25 174.62,123.38 174.31,123.69 170.94,123.69 166.46,128.18 156.72,128.18 154.12,130.78 137.87,130.78 134.67,133.98 134.67,144.65 136.56,146.55 136.56,149.79 135.86,150.49 135.63,150.49 135.01,150.49 134.75,150.23 v2(134.75,149.57)
  BOTTOM w0.076: CPU1.F18 169.73,105.71 170.06,105.39 v2(170.06,105.39)
  BOTTOM w0.107: v2(134.75,149.57) 135.01,149.83 135.01,150.22 CM69.1
PEG_CRX_GTX_N9: length 84.8
  IN3 w0.127: v2(171.36,106.17) 171.36,106.41 171.74,106.79 172.26,106.79 173.42,107.94 173.42,111.53 173.09,111.86 173.09,112.56 173.63,113.11 173.63,113.71 174.84,114.92 174.84,116.07 174.58,116.33 174.58,120.03 172.12,122.49 170.99,122.49 167.05,126.42 155.1,126.42 151.51,130.02 137.36,130.02 133.6,133.77 133.6,144.61 135.84,146.85 135.84,147.93 135.12,148.65 134.34,148.65 133.06,149.93 131.96,149.93 v2(131.9,149.99)
  BOTTOM w0.076: CPU1.D19 171.03,106.5 v2(171.36,106.17)
  BOTTOM w0.107: v2(131.9,149.99) 132.09,149.8 132.31,149.8 132.52,150.01 132.52,150.44 132.41,150.55 CM66.1
PEG_CRX_GTX_N10: length 72.8
  IN3 w0.127: v2(170.07,106.96) 169.8,107.22 169.78,107.22 169.69,107.22 167.99,108.92 167.99,113.18 166.77,114.4 166.17,114.4 165.43,115.13 165.43,122.79 163.53,124.68 153.94,124.68 150.35,128.27 136.74,128.27 131.93,133.08 131.93,145.64 132.92,146.63 v2(132.92,147.45)
  BOTTOM w0.076: CPU1.F20 169.73,107.3 v2(170.07,106.96)
  BOTTOM w0.107: v2(132.92,147.45) 133.18,147.71 133.18,147.84 133.52,148.18 133.52,148.34 CM62.1
PEG_CRX_GTX_N11: length 80
  IN3 w0.127: v2(171.36,107.75) 171.33,107.77 171.33,108.13 171.46,108.26 171.88,108.26 172.63,109.01 172.63,111.13 171.59,112.17 171.59,112.63 172.63,113.67 172.63,114.12 172.88,114.37 172.88,118.3 171.23,119.95 169.96,119.95 169.33,120.58 169.33,123.12 168.88,123.57 166.6,123.57 164.5,125.66 154.59,125.66 151,129.25 137.09,129.25 132.88,133.47 132.88,144.91 135.11,147.15 135.11,147.63 134.86,147.89 v2(134.27,147.89)
  BOTTOM w0.076: v2(171.36,107.75) 171.03,108.07 CPU1.D21
  BOTTOM w0.107: CM65.1 136.36,148.65 136.47,148.54 136.47,148.11 136.07,147.71 134.44,147.71 v2(134.27,147.89)
PEG_CRX_GTX_P0: length 59.6
  TOP w0.107: CG8.1 206.77,132.52 206.71,132.52 206.58,132.65 206.13,132.65 205.89,132.41 205.89,131.33 205.92,131.31 205.92,130.73 205.89,130.71 205.89,130.06 204.63,128.8 203.75,128.8 203.59,128.64 203.59,128.41 203.7,128.3 v2(203.88,128.3)
  IN3 w0.089: 179.53,99.15 179.39,99.15 178.84,98.59 172.49,98.59 172.36,98.72 171,98.72 170.57,99.16 170.13,99.16 v2(170.06,99.09)
  IN3 w0.127: 179.53,99.15 179.59,99.21 181.15,100.77 181.15,102.21 183.1,104.16 183.1,105.07 185.84,107.8 185.84,108.65 187.91,110.72 188.36,110.72 190.68,113.04 190.68,115.13 192.72,117.18 192.72,118.09 198.54,123.9 198.54,126.49 199.93,127.89 202.36,127.89 202.69,127.56 203.25,127.56 203.57,127.87 203.57,127.98 v2(203.88,128.3)
  BOTTOM w0.076: v2(170.06,99.09) 169.73,99.41 CPU1.F10
PEG_CRX_GTX_P0_C: length 41.4
  TOP w0.107: v2(236.06,113.35) 235.7,113.71 235.7,114.05 236.34,114.7 236.34,119.27 235.84,119.78 235.84,120.31 234.34,121.81 223.8,121.81 223.78,121.78 223.21,121.78 223.18,121.81 220.37,121.81 209.88,132.3 v3(209.03,132.3) CG8.2
  BOTTOM w0.117: v2(236.06,113.35) 236.07,113.35 UG9.BG26
PEG_CRX_GTX_P1: length 58.6
  TOP w0.107: CG10.1 205.41,133.32 205.3,133.43 205.3,133.51 205.2,133.61 205.05,133.61 204.73,133.29 204.73,132.43 204.76,132.4 204.76,131.83 204.73,131.8 204.73,130.9 204.29,130.46 203.37,130.46 203.17,130.26 203.17,129.8 v2(203.55,129.42)
  IN3 w0.089: 179.53,100.52 179.51,100.52 179.51,100.51 178.92,100.51 178.51,100.11 172.98,100.11 172.35,99.47 171.36,99.47 171.22,99.61 171.22,99.74 v2(171.36,99.87)
  IN3 w0.127: v2(203.55,129.42) 203.36,129.6 203.36,129.99 203.12,130.23 202.1,130.23 201.82,129.95 199.47,129.95 196.41,126.9 196.41,125.44 194.95,123.98 194.95,122.84 192.87,120.75 192.87,120.29 190.79,118.21 190.79,117.24 189.56,116.01 189.56,114.26 186.67,111.37 186.67,110.82 184.69,108.84 184.69,107.99 182.15,105.46 182.15,104.55 180.21,102.6 180.21,101.16 179.56,100.52 179.53,100.52
  BOTTOM w0.076: CPU1.D11 171.03,100.2 v2(171.36,99.87)
PEG_CRX_GTX_P1_C: length 46.5
  TOP w0.107: v2(236,112.02) 236,111.77 236.15,111.62 236.38,111.62 236.58,111.82 236.58,113.88 236.78,114.08 236.78,116.09 236.85,116.16 236.85,119.33 236.58,119.6 236.58,120.55 234.61,122.52 220.63,122.52 209.73,133.43 207.45,133.43 207.19,133.69 206.76,133.69 206.7,133.62 206.7,133.45 206.62,133.36 206.34,133.36 CG10.2
  BOTTOM w0.107: v2(236,112.02) 236.23,112.25 UG9.BF26
PEG_CRX_GTX_P2: length 62.8
  TOP w0.107: v2(202.83,134.63) 202.83,133.98 203.05,133.75 204.21,133.75 204.84,134.38 206.87,134.38 CG22.1
  IN3 w0.089: v2(170.04,101.48) 170.04,101.21 170.17,101.07 170.49,101.07 171.07,100.5 172.55,100.5 172.7,100.65 178.13,100.65 179.48,102
  IN3 w0.127: 179.48,102 179.48,102.9 181.43,104.85 181.43,105.76 183.96,108.29 183.96,109.14 185.85,111.03 185.85,112.66 188.63,115.45 188.63,117.57 194.02,122.95 194.02,127.56 194.67,128.21 195.6,128.21 196.51,129.13 196.51,133.38 197.11,133.98 202.9,133.98 203.03,134.11 203.03,134.43 v2(202.83,134.63)
  BOTTOM w0.089: v2(170.04,101.48) 170.04,101.36 CPU1.F12
PEG_CRX_GTX_P2_C: length 44.6
  TOP w0.107: v2(237.47,112.55) 236.98,113.04 236.98,113.72 237.18,113.92 237.18,115.91 237.27,116.01 237.27,120.92 234.86,123.34 220.84,123.34 209.85,134.33 209.35,134.33 209.32,134.31 208.75,134.31 208.72,134.33 207.63,134.33 CG22.2
  BOTTOM w0.107: v2(237.47,112.55) 237.46,112.56 237.29,112.56 237.17,112.44 UG9.BF27
PEG_CRX_GTX_P3: length 61.3
  TOP w0.107: CG26.1 205.46,135.1 205.37,135.19 205.37,135.38 205.26,135.49 205.11,135.49 205,135.6 204.22,135.6 204.11,135.49 204.11,135.34 204.36,135.1 v2(204.36,135.1)
  IN3 w0.089: v2(171.36,101.45) 171.22,101.31 171.22,101.19 171.39,101.02 172.25,101.02 172.91,101.69 178.29,101.69 178.95,102.35 178.95,102.58
  IN3 w0.127: 178.95,102.58 178.95,103.4 180.67,105.12 180.67,106.13 183.24,108.7 183.24,109.45 185.01,111.22 185.01,112.85 187.91,115.75 187.91,117.87 193.01,122.97 193.01,128.13 194.6,129.73 194.6,133.52 195.79,134.71 200.66,134.71 202.35,136.39 203.69,136.39 204.19,135.9 204.19,135.28 v2(204.36,135.1)
  BOTTOM w0.076: CPU1.D13 171.03,101.59 171.18,101.45 v2(171.36,101.45)
PEG_CRX_GTX_P3_C: length 46.5
  TOP w0.107: v2(238.17,113.35) 237.82,113.7 237.82,114.28 238.32,114.78 238.32,115.35 237.96,115.72 v3(237.96,119.35) 237.96,121.46 235.38,124.03 221.19,124.03 210.02,135.2 206.47,135.2 CG26.2
  BOTTOM w0.107: UG9.BG29 v2(238.17,113.35)
PEG_CRX_GTX_P4: length 64.8
  TOP w0.107: CG28.1 206.83,136.14 206.17,136.14 206.13,136.18 205.4,136.18 205.28,136.29 203.85,136.29 203.82,136.26 203.25,136.26 203.23,136.29 202.71,136.29 202.05,136.95 v2(202.05,137.72)
  IN3 w0.089: 178.44,103.03 178.41,102.99 178.41,102.37 178.07,102.03 174.48,102.03 174.47,102.03 170.87,102.03 170.26,102.64 169.94,102.64 169.85,102.55 169.85,102.42 170.06,102.22 v2(170.07,102.22)
  IN3 w0.127: v2(202.05,137.72) 202.13,137.8 202.13,138.05 202,138.18 201.28,138.18 200.73,137.64 200.73,137.07 199.72,136.05 195.99,136.05 194.09,134.16 194.09,129.94 192.5,128.34 192.5,123.18 187.4,118.08 187.4,115.96 184.5,113.06 184.5,111.43 182.73,109.66 182.73,108.92 180,106.18 180,105.22 178.44,103.67 178.44,103.03
  BOTTOM w0.076: CPU1.F14 170.06,102.31 170.06,102.24 v2(170.07,102.22)
PEG_CRX_GTX_P4_C: length 49.3
  TOP w0.107: v2(238.18,112.1) 237.98,112.1 237.88,111.99 237.88,111.78 237.98,111.68 238.66,111.68 238.77,111.78 238.77,112.36 238.58,112.55 238.58,113.95 238.77,114.14 238.77,116.59 238.9,116.72 v3(238.9,120.56) 238.9,121.54 235.62,124.81 221.43,124.81 210.26,135.99 209.38,135.99 209.35,135.96 208.78,135.96 208.75,135.99 CG28.2
  BOTTOM w0.117: v2(238.18,112.1) 238.18,112.1 238.42,112.1 UG9.BF29
PEG_CRX_GTX_P5: length 62.9
  TOP w0.107: CG30.1 205.67,136.98 203.6,136.98 203.3,137.29 v2(203.3,137.84)
  IN3 w0.089: v2(171.43,103.02) 171.33,102.93 171.21,102.93 171.01,103.12 171.01,103.17 170.85,103.33 170.85,103.5 170.96,103.61 172.34,103.61 172.95,102.99 176.67,102.99 176.84,103.17 176.87,103.17 176.88,103.18
  IN3 w0.127: 176.88,103.18 178.95,105.25 178.95,106.17 182,109.22 182,109.96 183.7,111.65 183.7,113.86 186.57,116.73 186.57,118.37 191.77,123.57 191.77,128.64 193.24,130.11 193.24,130.96 192.6,131.6 192.6,132.24 193.11,132.75 193.11,134.27 196.22,137.38 199.26,137.38 200.79,138.91 203.15,138.91 203.61,138.45 203.61,138.11 203.34,137.84 v2(203.3,137.84)
  BOTTOM w0.076: CPU1.D15 v2(171.43,103.02)
PEG_CRX_GTX_P5_C: length 50
  TOP w0.107: v2(239.57,112.55) 238.98,113.14 238.98,113.71 239.17,113.91 239.17,115.84 239.65,116.32 239.65,121.8 235.94,125.51 221.73,125.51 210.19,137.04 206.53,137.04 CG30.2
  BOTTOM w0.117: UG9.BF30 239.27,112.43 239.39,112.55 v2(239.57,112.55)
PEG_CRX_GTX_P6: length 65.1
  TOP w0.107: v2(201.85,140.32) 201.85,139.47 202.3,139.02 202.99,139.02 203.49,138.53 204.54,138.53 204.75,138.32 205.66,138.32 206.13,137.85 206.83,137.85 CG32.1
  IN3 w0.089: 177.34,105.08 175.99,103.73 173.36,103.73 172.93,104.16 170.75,104.16 170.58,103.99 170.43,103.99 170.06,104.37 v2(170.06,104.6)
  IN3 w0.127: v2(201.85,140.32) 202.09,140.08 202.09,139.98 201.96,139.85 200.54,139.85 200.22,140.18 196.28,140.18 191.43,135.33 191.43,131.06 190.83,130.45 190.83,124.04 184.83,118.04 184.83,116.33 182.75,114.25 182.75,112.05 181.06,110.35 181.06,109.61 177.91,106.46 177.91,105.65 177.34,105.08
  BOTTOM w0.089: CPU1.F16 170.06,104.53 v2(170.06,104.6)
PEG_CRX_GTX_P6_C: length 49.2
  TOP w0.107: v2(240.3,113.32) 239.92,113.7 239.92,114.29 240.6,114.96 240.6,118.25 240.36,118.48 240.36,122.17 236.26,126.27 222.02,126.27 210.56,137.74 v3(209.51,137.74) 207.6,137.74 CG32.2
  BOTTOM w0.117: UG9.BG32 v2(240.3,113.32)
PEG_CRX_GTX_P7: length 63.9
  TOP w0.107: CG35.1 205.84,139.29 205.08,139.29 205.02,139.35 203.64,139.35 203.24,139.74 203.24,140.16 v2(203.15,140.26)
  IN3 w0.127: v2(171.42,104.6) 171.42,104.6 171.39,104.57 171.12,104.57 171.02,104.67 171.02,104.76 170.88,104.9 170.88,105.08 171.01,105.21 176.75,105.21 177.43,105.89 177.43,106.7 180.46,109.73 180.46,110.47 182.25,112.26 182.25,114.46 184.29,116.51 184.29,118.22 190.32,124.25 190.32,130.72 190.86,131.25 190.86,135.47 197.66,142.27 202.1,142.27 203.61,140.76 203.61,140.49 203.38,140.26 v2(203.15,140.26)
  BOTTOM w0.076: CPU1.D17 171.03,104.99 171.42,104.6 v2(171.42,104.6)
PEG_CRX_GTX_P7_C: length 54.5
  TOP w0.107: CG35.2 206.5,139.24 v3(208.86,139.24) 210.05,139.24 222.15,127.14 236.41,127.14 241.05,122.49 241.05,111.58 240.93,111.45 240.76,111.45 240.55,111.67 240.15,111.67 240.05,111.77 240.05,111.92 v2(240.23,112.11)
  BOTTOM w0.117: UG9.BF32 240.53,112.11 v2(240.23,112.11)
PEG_CRX_GTX_P8: length 87.9
  IN3 w0.091: 172.45,105.98 172.45,105.93 172.33,105.81 169.86,105.81 169.77,105.9 169.77,106.07 169.93,106.22 v2(170.06,106.22)
  IN3 w0.127: 172.45,105.98 173.27,106.8 173.77,106.8 174.49,107.53 174.49,110.71 175.53,111.76 175.53,122.16 174.21,123.48 170.85,123.48 166.37,127.96 156.63,127.96 154.03,130.56 137.78,130.56 134.45,133.89 134.45,144.74 136.35,146.64 136.35,149.7 135.77,150.27 135.48,150.27 135.39,150.27 135.11,150.27 134.98,150.14 134.98,149.93 135.34,149.57 v2(135.45,149.57)
  BOTTOM w0.089: v2(170.06,106.22) 170.06,106.17 170.38,105.85 CPU1.E18
  BOTTOM w0.107: v2(135.45,149.57) 135.21,149.82 135.21,150.2 CM67.1
PEG_CRX_GTX_P9: length 84.8
  IN3 w0.127: v2(131.9,149.41) 131.91,149.41 132.21,149.71 132.97,149.71 134.25,148.43 135.03,148.43 135.62,147.84 135.62,146.94 133.39,144.7 133.39,133.68 137.27,129.8 151.42,129.8 155.01,126.21 166.96,126.21 170.9,122.27 172.03,122.27 174.36,119.94 174.36,116.24 174.62,115.98 174.62,115.01 173.41,113.8 173.41,113.2 172.87,112.65 172.87,111.77 173.2,111.44 173.2,108.04 172.17,107.01 171.65,107.01 171.17,106.53 171.06,106.53 v2(170.71,106.17)
  BOTTOM w0.076: CPU1.E19 170.38,106.5 v2(170.71,106.17)
  BOTTOM w0.107: CM63.1 132.72,150.31 132.72,149.92 132.4,149.6 132.09,149.6 v2(131.9,149.41)
PEG_CRX_GTX_P10: length 72.8
  IN3 w0.127: v2(133.51,147.45) 133.51,147.44 133.14,147.08 133.14,146.54 132.15,145.55 132.15,133.17 136.83,128.49 150.44,128.49 154.03,124.9 163.62,124.9 165.64,122.88 165.64,115.23 166.26,114.61 166.86,114.61 168.21,113.27 168.21,109.01 169.78,107.44 169.93,107.44 170.05,107.57 170.05,107.79 v2(170.05,107.79)
  BOTTOM w0.076: CPU1.E20 170.05,107.69 v2(170.05,107.79)
  BOTTOM w0.107: v2(133.51,147.45) 133.39,147.57 133.39,147.75 133.73,148.09 133.73,148.26 CM68.1
PEG_CRX_GTX_P11: length 80
  IN3 w0.127: v2(170.71,107.75) 170.73,107.75 171.11,108.13 171.11,108.23 171.37,108.48 171.79,108.48 172.41,109.1 172.41,111.04 171.37,112.08 171.37,112.72 172.41,113.76 172.41,114.21 172.66,114.46 172.66,118.21 171.14,119.73 169.87,119.73 169.11,120.49 169.11,123.03 168.79,123.35 166.51,123.35 164.41,125.44 154.5,125.44 150.91,129.04 137,129.04 132.66,133.38 132.66,145.01 134.89,147.24 134.89,147.54 134.77,147.67 134.64,147.67 134.28,147.3 v2(134.27,147.3)
  BOTTOM w0.076: v2(170.71,107.75) 170.38,108.07 CPU1.E21
  BOTTOM w0.107: v2(134.27,147.3) 134.41,147.45 134.47,147.5 136.16,147.5 136.67,148.02 136.67,148.42 CM64.1
PEG_CRX_TTX_N12: length 95.1
  TOP w0.107: CT16.1 189.34,160.89 189.69,160.55 191.39,160.55 192.11,161.27 192.11,161.84 192.73,162.46 192.73,163.1 192.7,163.13 192.7,163.96 v2(192.79,164.05)
  IN6 w0.089: v2(170.05,108.53) 170.47,108.11 173.95,108.11 175.26,106.8 177.18,106.8 178.39,108.01 183.47,108.01 187.51,112.05 187.97,112.05 189.4,113.48 189.4,115.41 190.99,116.99 190.99,117.31 193.14,119.46 194.22,119.46 195.44,120.68 197.06,120.68 199.09,122.71 199.27,122.71 199.69,123.13 199.69,124.2 200.07,124.58 200.07,127.15 200.8,127.88 200.8,128.81 202.61,130.63 202.61,130.89 202.61,133.7 201.79,134.53 201.79,136.26 200.61,137.45 200.61,142.15 201.24,142.78 201.24,148.11 202.85,149.73 202.85,153.97 199.98,156.85 199.18,156.85 194.67,161.35 194.67,162.11 193.52,163.27 193.02,163.27 192.73,163.55 192.73,163.99 v2(192.79,164.05)
  BOTTOM w0.089: CPU1.F22 169.73,108.84 v2(170.05,108.53)
PEG_CRX_TTX_N12_C: length 2.6
  TOP w0.089: CT16.2 187.56,161.1 187.27,161.1 186.57,161.79 185.81,161.79 UT1.V22
PEG_CRX_TTX_N13: length 87.4
  TOP w0.107: CT2.1 188.52,163.35 188.73,163.35 188.92,163.54 189.26,163.54 189.91,162.9 190.46,162.9 v2(190.73,162.62)
  IN6 w0.089: v2(171.42,109.32) 171.24,109.49 171.09,109.49 171,109.4 171,109.01 171.17,108.84 172.23,108.84 172.92,109.53 174.8,109.53 175.44,108.89 176.65,108.89 176.72,108.82 182.98,108.82 187.01,112.85 187.58,112.85 188.46,113.72 188.46,115.6 189.27,116.41 189.27,117.28 191.15,119.15 191.7,119.15 194.03,121.48 196.72,121.48 198.36,123.12 198.36,126.58 200,128.21 200,129.58 200.68,130.26 200.68,135.41 199.08,137 199.08,142.39 200.37,143.68 200.37,146.01 195.55,150.83 195.55,159.28 193.71,161.13 193.71,161.87 193.11,162.47 192.69,162.47 192.17,162.98 191.39,162.98 191.21,163.16 191.08,163.16 190.78,162.86 190.78,162.67 v2(190.73,162.62)
  BOTTOM w0.089: CPU1.D23 171.03,109.7 v2(171.42,109.32)
PEG_CRX_TTX_N13_C: length 2.5
  TOP w0.089: UT1.P22 185.65,163.86 185.87,163.64 186.25,163.64 186.3,163.69 186.67,163.69 187.05,163.31 187.63,163.31 CT2.2
PEG_CRX_TTX_N14: length 78.1
  TOP w0.107: v2(188.89,166.04) 188.89,165.99 188.74,165.84 188.54,165.84 CT108.1
  IN6 w0.089: v2(170.06,110.9) 170.06,110.84 170.34,110.56 170.45,110.56 170.93,110.08 175.35,110.08 176.12,110.84 176.12,112.71 177.78,114.37 182.82,114.37 184.95,116.5 184.95,116.64 186.1,117.79 186.1,118.98 191.87,124.75 191.87,125.48 194.8,128.41 194.8,129.7 195.87,130.78 195.87,134.06 195.04,134.88 195.04,146.85 191.84,150.05 191.84,150.68 190.8,151.73 190.8,157.82 188.03,160.59 188.03,165.49 188.28,165.74 188.59,165.74 v2(188.89,166.04)
  BOTTOM w0.107: CPU1.F24 170.06,110.83 v2(170.06,110.9)
PEG_CRX_TTX_N14_C: length 2.4
  TOP w0.089: CT108.2 187.74,166.04 187.59,165.89 187.14,165.89 187.05,165.8 186.71,165.8 186.58,165.93 185.84,165.93 UT1.K22
PEG_CRX_TTX_N15: length 79.4
  TOP w0.107: CT110.1 188.35,167.75 188.52,167.92 189.56,167.92 189.73,167.75 189.73,167.58 189.44,167.29 v2(189.11,167.29)
  IN6 w0.089: v2(189.11,167.29) 189.15,167.33 189.44,167.33 189.53,167.24 189.53,166.86 189.27,166.6 188.24,166.6 187.36,165.72 187.36,159.01 190.16,156.21 190.16,151.47 191.21,150.42 191.21,149.78 194.15,146.84 194.15,137.27 194.05,137.17 194.05,136.3 194.16,136.19 194.16,128.67 191.23,125.75 191.23,125.01 184.03,117.81 184.03,116.48 182.56,115.01 177.93,115.01 175.5,112.58 175.5,111.58 175.08,111.16 172.96,111.16 172.26,110.46 171.17,110.46 171.04,110.59 171.04,110.79 171.13,110.88 v2(171.32,110.88)
  BOTTOM w0.089: v2(171.32,110.88) 171.03,111.16 CPU1.D25
PEG_CRX_TTX_N15_C: length 2.5
  TOP w0.089: CT110.2 187.06,167.75 186.61,167.31 185.81,167.31 UT1.F22
PEG_CRX_TTX_P12: length 95.1
  TOP w0.107: CT14.1 188.42,161.47 188.79,161.1 189.43,161.1 189.77,160.75 191.3,160.75 191.91,161.36 191.91,161.93 192.5,162.52 v3(192.5,162.78) 192.5,163.59 192.04,164.04 v2(191.98,164.04)
  IN6 w0.089: v2(191.98,164.04) 191.98,164.22 192.07,164.31 192.31,164.31 192.39,164.22 192.39,163.82 192.57,163.65 192.57,163.48 192.95,163.1 193.45,163.1 194.51,162.04 194.51,161.28 199.11,156.68 199.91,156.68 202.69,153.91 202.69,149.8 201.08,148.18 201.08,142.85 200.44,142.21 200.44,137.38 201.62,136.2 201.62,134.46 202.45,133.64 202.45,130.82 202.45,130.7 200.63,128.88 200.63,127.95 199.91,127.22 199.91,124.65 199.53,124.27 199.53,123.2 199.2,122.88 199.02,122.88 196.99,120.85 195.37,120.85 194.15,119.63 193.07,119.63 190.83,117.38 190.83,117.06 189.24,115.48 189.24,113.55 187.9,112.21 187.44,112.21 183.4,108.17 178.32,108.17 177.11,106.97 175.33,106.97 174.02,108.28 170.77,108.28 170.68,108.36 v2(170.68,108.53)
  BOTTOM w0.089: v2(170.68,108.53) 170.38,108.83 CPU1.E22
PEG_CRX_TTX_P12_C: length 2.6
  TOP w0.089: UT1.V23 185.94,162.12 185.94,162.21 185.98,162.25 186.31,162.25 186.36,162.2 186.36,162.02 186.39,161.99 186.66,161.99 187.35,161.3 187.59,161.3 CT14.2
PEG_CRX_TTX_P13: length 87.4
  TOP w0.107: CT12.1 188.54,163.55 188.64,163.55 188.84,163.75 189.34,163.75 189.99,163.1 190.46,163.1 v2(190.72,163.36)
  IN6 w0.089: v2(190.72,163.36) 191.24,163.36 191.46,163.14 192.24,163.14 192.76,162.63 193.18,162.63 193.87,161.94 193.87,161.2 195.72,159.35 195.72,150.9 200.54,146.08 200.54,143.61 199.25,142.32 199.25,137.07 200.84,135.47 200.84,130.19 200.16,129.51 200.16,128.14 198.53,126.51 198.53,123.05 196.79,121.32 194.1,121.32 191.77,118.99 191.21,118.99 189.44,117.21 189.44,116.34 188.62,115.53 188.62,113.65 187.65,112.68 187.08,112.68 183.05,108.65 176.65,108.65 176.58,108.72 175.37,108.72 174.73,109.37 172.99,109.37 172.3,108.68 171.24,108.68 171.1,108.68 170.84,108.94 170.84,109.12 v2(170.64,109.32)
  BOTTOM w0.089: CPU1.E23 170.49,109.71 170.64,109.56 v2(170.64,109.32)
PEG_CRX_TTX_P13_C: length 2.5
  TOP w0.089: UT1.P23 185.94,163.96 185.94,164.05 185.98,164.09 186.31,164.09 186.36,164.04 186.36,163.94 186.43,163.88 186.75,163.88 187.13,163.5 187.31,163.5 187.4,163.59 187.4,163.66 187.49,163.75 CT12.2
PEG_CRX_TTX_P14: length 78.1
  TOP w0.107: CT109.1 188.49,165.61 188.64,165.61 v2(188.91,165.34)
  IN6 w0.089: v2(188.91,165.34) 188.67,165.58 188.35,165.58 188.2,165.42 188.2,160.65 190.96,157.89 190.96,151.8 192.01,150.75 192.01,150.12 195.2,146.92 195.2,134.95 196.03,134.12 196.03,130.71 194.96,129.64 194.96,128.34 192.03,125.41 192.03,124.68 186.26,118.91 186.26,117.72 185.11,116.57 185.11,116.43 182.89,114.21 177.84,114.21 176.28,112.64 176.28,110.78 175.42,109.91 170.86,109.91 170.38,110.4 170.25,110.4 170.06,110.2 v2(170.06,110.1)
  BOTTOM w0.107: CPU1.E24 170.06,110.18 v2(170.06,110.1)
PEG_CRX_TTX_P14_C: length 2.4
  TOP w0.089: CT109.2 187.52,165.7 187.21,165.7 187.12,165.61 186.62,165.61 186.52,165.71 186.42,165.71 186.36,165.64 186.36,165.54 186.28,165.47 186.05,165.47 185.92,165.6 185.92,165.7 UT1.K23
PEG_CRX_TTX_P15: length 79.4
  TOP w0.107: v2(189.93,167.2) 189.93,167.87 189.67,168.13 188.54,168.13 CT111.1
  IN6 w0.089: v2(189.93,167.2) 189.7,166.97 189.7,166.8 189.34,166.44 188.31,166.44 187.52,165.65 187.52,159.08 190.33,156.28 190.33,151.53 191.37,150.49 191.37,149.85 194.32,146.91 194.32,137.21 194.22,137.1 194.22,136.37 194.33,136.26 194.33,128.6 191.4,125.68 191.4,124.94 184.2,117.74 184.2,116.41 182.62,114.84 177.99,114.84 175.67,112.51 175.67,111.51 175.15,110.99 173.03,110.99 172.33,110.29 171.1,110.29 170.87,110.52 170.87,110.69 v2(170.68,110.88)
  BOTTOM w0.089: CPU1.E25 170.38,111.24 170.68,110.94 v2(170.68,110.88)
PEG_CRX_TTX_P15_C: length 2.5
  TOP w0.089: 187.46,168.24 187.44,168.22 187.44,168.02 187.35,167.93 186.98,167.93 186.57,167.52 186.47,167.52 186.38,167.61 186.38,167.66 186.29,167.75 186.13,167.75 186.04,167.66 UT1.F23
  TOP w0.099: CT111.2 187.54,168.32 187.46,168.24
PEG_CTX_C_GRX_N0: length 26.9
  BOTTOM w0.089: 236.27,121.7 236.27,121.63 v3(236.82,121.08) 237.56,120.34 237.56,119.46 237.59,119.44 237.59,118.88 237.56,118.85 237.56,117.05 237.74,116.88 237.74,116.3 237.5,116.06 237.5,115.48 237.17,115.15 UG9.BK27
  BOTTOM w0.107: 236.27,121.7 235.98,121.99 235.97,121.99 235.8,122.16 220.4,122.16 220.08,121.84 220.05,121.84 218.89,120.68 CC1.2
PEG_CTX_C_GRX_N1: length 29
  BOTTOM w0.089: UG9.BL29 238.59,115.75 238.69,115.85 238.69,116.02 238.6,116.11 238.34,116.11 238.25,116.2
  BOTTOM w0.107: 238.25,116.2 v3(238.25,120.38) 238.25,120.89 237.59,121.56 237.59,121.58 237.53,121.63 237.53,121.64 237.26,121.91 237.23,121.91 236.3,122.85 219.9,122.85 219.62,122.56 219.55,122.56 219.1,122.1 219.1,122.06 218.25,121.22 217.06,121.22 216.71,121.57 CC2.2
PEG_CTX_C_GRX_N2: length 27.5
  BOTTOM w0.089: 238.45,121.7 239.09,121.06 239.09,116.63 UG9.BM30
  BOTTOM w0.107: CC3.2 v3(218.47,123.6) 219.33,123.6 219.4,123.54 236.61,123.54 238.45,121.7
PEG_CTX_C_GRX_N3: length 32.2
  BOTTOM w0.089: UG9.BK30 239.27,115.23 239.63,115.59 239.63,116.06 239.85,116.28 239.85,119.22 239.87,119.25 239.87,119.81 239.85,119.83 v3(239.85,120.81) 239.85,121.32 239.47,121.7
  BOTTOM w0.107: 239.47,121.7 236.94,124.23 219.66,124.23 219.25,124.64 215.59,124.64 CC4.2
PEG_CTX_C_GRX_N4: length 32.4
  BOTTOM w0.089: UG9.BL32 240.78,115.64 240.78,115.51 240.69,115.42 240.55,115.42 240.5,115.36 240.37,115.36 240.28,115.45 240.28,116.12 240.16,116.24 v3(240.16,118.31) 240.16,118.78 240.31,118.93 240.31,121.56 240.16,121.7
  BOTTOM w0.107: CC5.2 217.14,125.13 217.24,125.23 217.24,125.34 217.37,125.47 217.99,125.47 218.01,125.5 219.09,125.5 219.87,124.72 237.15,124.72 240.16,121.7
PEG_CTX_C_GRX_N5: length 33.2
  BOTTOM w0.089: 241.18,121.7 241.37,121.5 v3(241.37,120.34) UG9.BM33
  BOTTOM w0.107: CC6.2 215.74,126.42 218.66,126.42 218.68,126.45 219.4,126.45 220.2,125.64 237.63,125.64 241.18,122.1 241.18,121.7
PEG_CTX_C_GRX_N6: length 34.8
  BOTTOM w0.089: UG9.BK33 241.65,115.33 241.65,115.46 241.68,115.49 241.68,115.8 242.02,116.14 242.02,121.6 241.93,121.69 241.93,121.7
  BOTTOM w0.107: CC7.2 v3(218.12,127.58) 219.24,127.58 220.49,126.33 237.92,126.33 241.93,122.32 241.93,121.7
PEG_CTX_C_GRX_N7: length 37.1
  BOTTOM w0.089: 242.62,121.7 242.62,118.18 242.46,118.02 242.46,116.18 242.52,116.12 242.83,116.12 242.96,115.98 242.96,115.86 242.85,115.75 UG9.BL35
  BOTTOM w0.107: 242.62,121.7 242.62,122.67 v3(239.85,125.44) 238.27,127.03 221.86,127.03 221.83,127.05 221.14,127.05 221.12,127.03 220.77,127.03 219.53,128.27 215.9,128.27 215.62,128.56 CC8.2
PEG_CTX_C_GRX_N8: length 5.5
  BOTTOM w0.107: JCDRA.4 153.82,176.77 153.74,176.69 153.74,175.47 153.56,175.29 153.56,174.22 153.59,174.19 153.59,173.62 153.56,173.59 153.56,172.81 CC9.2
PEG_CTX_C_GRX_N9: length 3.6
  BOTTOM w0.099: JCDRA.7 155.02,176.57
  BOTTOM w0.107: CC10.2 154.77,174.72 154.77,175.05 154.79,175.08 154.79,175.68 154.92,175.8 154.92,176.47 155.02,176.57
PEG_CTX_C_GRX_N10: length 5.5
  BOTTOM w0.099: JCDRA.10 156.22,176.63
  BOTTOM w0.107: 156.22,176.63 156.1,176.51 156.1,175.73 155.98,175.61 v3(155.98,175.13) 155.98,172.82 CC11.2
PEG_CTX_C_GRX_N11: length 3.6
  BOTTOM w0.099: JCDRA.13 157.42,176.81
  BOTTOM w0.107: 157.42,176.81 157.31,176.7 157.31,176.2 157.44,176.08 v3(157.44,175.36) 157.44,174.69 CC12.2
PEG_CTX_C_GRX_P0: length 26.8
  BOTTOM w0.089: 235.96,121.7 236.47,121.19 236.47,121.14 236.88,120.73 236.92,120.73 237.38,120.27 v3(237.38,119.17) 237.38,116.98 237.56,116.8 237.56,116.37 237.31,116.11 237.09,116.11 236.86,115.88 236.86,115.63 236.95,115.54 237.08,115.54 237.17,115.63 UG9.BL27
  BOTTOM w0.107: CC13.2 218.02,120.11 218.13,120.22 218.13,120.3 218.24,120.41 218.94,120.41 220.48,121.95 235.72,121.95 235.83,121.84 235.83,121.83 235.96,121.7
PEG_CTX_C_GRX_P1: length 29
  BOTTOM w0.089: UG9.BK29 238.26,115.36 238.26,115.86 238.03,116.08 238.03,116.23
  BOTTOM w0.107: 238.03,116.23 238.03,120.8 237.37,121.47 237.37,121.49 237.32,121.55 237.32,121.57 237.17,121.71 237.15,121.71 236.22,122.64 219.98,122.64 v3(219.52,122.18) 218.34,121 216.46,121 CC14.2
PEG_CTX_C_GRX_P2: length 27.6
  BOTTOM w0.089: UG9.BM29 238.89,116.77 v3(238.89,118.35) 238.89,120.97 238.16,121.7
  BOTTOM w0.107: 238.16,121.7 236.53,123.33 219.32,123.33 219.25,123.4 218.82,123.4 218.78,123.36 218.19,123.36 218.16,123.4 217.81,123.4 217.69,123.27 217.69,123.1 217.62,123.03 CC15.2
PEG_CTX_C_GRX_P3: length 32.2
  BOTTOM w0.089: 239.19,121.7 239.67,121.21 239.67,121.1 239.65,121.08 239.65,120.54 239.67,120.52 v3(239.67,119.54) 239.67,116.35 239.45,116.13 239.1,116.13 238.96,115.98 238.96,115.68 239.05,115.59 239.17,115.59 239.27,115.69 UG9.BL30
  BOTTOM w0.107: CC16.2 215.63,124.11 215.91,124.11 215.97,124.17 215.97,124.35 216.06,124.44 219.17,124.44 219.58,124.02 236.86,124.02 239.19,121.7
PEG_CTX_C_GRX_P4: length 32.5
  BOTTOM w0.089: 240.44,121.7 240.51,121.64 240.51,118.85 240.36,118.7 240.36,116.32 240.58,116.1 240.76,116.1 240.98,115.88 240.98,115.36 UG9.BK32
  BOTTOM w0.107: CC17.2 v3(217.7,125.7) 219.17,125.7 219.95,124.92 237.23,124.92 240.32,121.83 240.32,121.83 240.44,121.7 240.44,121.7
PEG_CTX_C_GRX_P5: length 33.2
  BOTTOM w0.089: 240.97,121.7 240.97,121.62 241.17,121.42 241.17,116.8 240.82,116.45 UG9.BM32
  BOTTOM w0.107: CC18.2 215.57,126.02 215.76,126.21 v3(218.97,126.21) 219.34,126.21 220.12,125.44 237.54,125.44 240.97,122.01 240.97,121.7
PEG_CTX_C_GRX_P6: length 34.8
  BOTTOM w0.089: 241.73,121.7 241.73,121.68 241.73,121.68 241.73,121.6 241.82,121.52 v3(241.82,118.82) 241.82,116.22 241.65,116.05 241.46,116.05 241.37,116.14 241.25,116.14 241.16,116.05 241.16,115.75 241.25,115.66 241.28,115.66 UG9.BL33
  BOTTOM w0.107: CC19.2 217.1,126.91 217.21,127.01 217.21,127.27 217.31,127.37 217.81,127.37 217.83,127.35 218.4,127.35 218.43,127.37 219.16,127.37 220.4,126.13 237.83,126.13 241.73,122.24 241.73,121.7
PEG_CTX_C_GRX_P7: length 37.1
  BOTTOM w0.089: UG9.BK35 242.77,115.21 242.43,115.56 242.43,115.93 242.26,116.1 242.26,118.1 242.42,118.27 242.42,121.68 242.42,121.68 242.42,121.7
  BOTTOM w0.107: CC20.2 215.58,128.07 219.45,128.07 220.69,126.82 v3(221.43,126.82) 238.18,126.82 239.49,125.52 239.49,125.48 239.89,125.07 239.93,125.07 242.42,122.59 242.42,121.7
PEG_CTX_C_GRX_P8: length 5.5
  BOTTOM w0.107: JCDRA.3 153.42,176.78 153.54,176.66 153.54,175.55 153.36,175.38 v3(153.36,173.91) 153.36,172.73 153.08,172.45 CC21.2
PEG_CTX_C_GRX_P9: length 3.6
  BOTTOM w0.107: JCDRA.6 154.62,176.64 154.72,176.54 154.72,175.89 154.56,175.74 v3(154.56,175.37) 154.56,174.67 CC22.2
PEG_CTX_C_GRX_P10: length 5.5
  BOTTOM w0.099: JCDRA.9 155.82,176.59
  BOTTOM w0.107: 155.82,176.59 155.9,176.5 155.9,175.82 155.77,175.69 155.77,175.44 155.75,175.41 155.75,174.84 155.77,174.81 155.77,172.78 CC23.2
PEG_CTX_C_GRX_P11: length 3.6
  BOTTOM w0.099: JCDRA.12 157.02,176.78
  BOTTOM w0.107: CC24.2 157.11,174.6 157.11,174.71 157.23,174.83 157.23,175.03 157.21,175.06 157.21,175.65 157.23,175.68 157.23,176 157.11,176.12 157.11,176.69 157.02,176.78
PEG_CTX_GRX_N0: length 63.3
  IN6 w0.089: v2(175.87,99.17) 175.87,98.36 176.47,97.76 178.25,97.76 182.91,102.42 186.72,102.42 187.86,103.56 188.2,103.56 191.26,106.62 194.56,106.62 196.28,108.35 198.78,108.35 199.84,109.41 199.84,110.98 200.66,111.8 200.66,112.63 205.06,117.03 205.06,120.49 208.21,123.64 211.65,123.64 212.23,123.07 212.23,122.57 212.54,122.26 212.77,122.26 212.97,122.05 212.99,122.05 213.28,121.76 213.28,121.76 v2(213.58,121.47)
  BOTTOM w0.076: v2(175.87,99.17) 175.44,99.6 174.76,99.6 174.25,99.09 173.35,99.09 173.26,99.18 172.35,99.18 172.27,99.25 172.27,99.42 CPU1.B10
  BOTTOM w0.107: v2(213.58,121.47) 213.52,121.47 213.36,121.31 213.36,121.17 213.46,121.07 215.02,121.07 215.77,120.33 216.7,120.33 216.73,120.36 216.73,120.62 216.8,120.68 CC1.1
PEG_CTX_GRX_N1: length 61.9
  IN6 w0.089: v2(214.34,121.44) 214.51,121.61 214.51,122.04 214.17,122.37 213.42,122.37 212.76,123.04 212.76,123.2 211.84,124.12 208.79,124.12 208.41,124.5 207.94,124.5 204.58,121.15 204.58,117.22 200.19,112.83 200.19,112.01 199.59,111.41 198.4,111.41 195.72,108.72 195.72,108.45 194.75,107.48 190.99,107.48 187.01,103.5 183.21,103.5 178.32,98.61 177.53,98.61 177.3,98.84 177.3,98.91 v2(177.03,99.18)
  BOTTOM w0.076: 175.37,99.85 173.37,99.85 173.3,99.78 172.75,99.78 172.54,99.99 172.54,100.19 172.46,100.27 CPU1.B11
  BOTTOM w0.089: v2(214.34,121.44) 214.5,121.6 214.5,122.13 214.6,122.22 ; CC2.1 215.62,121.57 215.53,121.66 215.53,122.01 215.32,122.22 ; v2(177.03,99.18) 177.29,99.43 177.29,99.64 177.08,99.85 175.37,99.85
  BOTTOM w0.107: 214.6,122.22 214.7,122.32 215.22,122.32 215.32,122.22
PEG_CTX_GRX_N2: length 62.5
  IN6 w0.089: v2(215.08,123.01) 215.46,123.39 215.46,123.48 215.38,123.56 214.7,123.56 212.45,125.82 212.25,125.82 211.86,126.2 207.2,126.2 206.26,125.26 206.26,124.62 203.31,121.68 203.31,119.89 202.13,118.71 202.13,118.35 201.27,117.49 201.27,116.84 198.85,114.42 198.85,113.96 197.16,112.27 196.34,112.27 195.14,111.07 194.85,111.07 193.79,110 193.64,110 193.21,109.57 192.63,109.57 191.81,108.75 190.46,108.75 188.96,107.25 187.67,107.25 185.19,104.77 182.22,104.77 177.87,100.43 176.98,100.43 176.82,100.59 176.82,100.88 v2(176.58,101.12)
  BOTTOM w0.076: v2(176.58,101.12) 176.66,101.12 176.99,100.79 176.99,100.62 176.92,100.55 173.44,100.55 173.23,100.75 172.02,100.75 171.95,100.83 171.95,100.97 172.08,101.1 172.29,101.1 CPU1.B12
  BOTTOM w0.107: v2(215.08,123.01) 215.08,123.16 215.52,123.6 CC3.1
PEG_CTX_GRX_N3: length 60.1
  IN6 w0.089: v2(174.88,101.12) 175.08,100.92 175.08,100.68 176.01,99.74 178.12,99.74 182.51,104.13 185.45,104.13 187.93,106.61 189.22,106.61 190.72,108.12 194.21,108.12 198.07,111.98 198.07,112.29 199.48,113.7 199.48,114.14 203.95,118.61 203.95,121.41 208.1,125.57 211.6,125.57 212.05,125.11 212.25,125.11 213.89,123.47 213.89,123.24 v2(213.66,123.01)
  BOTTOM w0.076: CPU1.B13 172.52,101.84 172.59,101.76 172.59,101.53 172.79,101.34 173.21,101.34 173.44,101.57 174.89,101.57 175.01,101.44 175.01,101.26 v2(174.88,101.12)
  BOTTOM w0.107: CC4.1 214.2,124.62 213.73,124.15 213.73,123.08 v2(213.66,123.01)
PEG_CTX_GRX_N4: length 62.4
  IN6 w0.089: v2(174.78,102.63) 175.03,102.38 175.03,102.03 175.21,101.85 178.19,101.85 181.75,105.4 184.93,105.4 187.41,107.88 188.53,107.88 192.57,111.92 194.83,111.92 195.89,112.97 196.64,112.97 197.13,113.46 197.13,114.22 197.54,114.64 197.54,115.25 197.93,115.63 198.91,115.63 200.35,117.06 200.35,118.75 202.68,121.08 202.68,121.94 204.44,123.7 204.44,125.46 204.68,125.7 205.47,125.7 207.12,127.35 212.12,127.35 212.42,127.06 212.42,126.85 v2(212.21,126.65)
  BOTTOM w0.076: CPU1.B14 172.28,102.69 172.17,102.69 172.16,102.67 172.02,102.67 171.96,102.62 171.96,102.51 171.96,102.51 171.96,102.41 172.04,102.33 173.16,102.33 173.27,102.21 175,102.21 175.13,102.35 175.13,102.41 175.06,102.49 175.06,102.54 174.96,102.63 v2(174.78,102.63)
  BOTTOM w0.107: v2(212.21,126.65) 212.21,125.8 212.99,125.03 213.9,125.03 214.07,125.19 216.19,125.19 CC5.1
PEG_CTX_GRX_N5: length 60.9
  IN6 w0.089: v2(176.6,102.58) 176.6,103.37 177.06,103.83 177.65,103.83 180.02,106.2 184.59,106.2 187.07,108.69 188.2,108.69 191.69,112.17 191.69,113.71 193.25,115.27 194.79,115.27 195.94,116.43 198.56,116.43 199.54,117.42 199.54,120.36 202.61,123.42 202.61,123.88 203.2,124.47 203.2,126.55 203.91,127.26 204.66,127.26 205.55,128.15 213.39,128.15 214.13,127.41 v2(214.13,126.65)
  BOTTOM w0.076: CPU1.B15 172.49,103.42 172.57,103.34 172.57,103.13 172.75,102.95 173.26,102.95 173.31,103 176.72,103 176.8,102.93 176.8,102.79 v2(176.6,102.58)
  BOTTOM w0.107: CC6.1 214.77,126.59 214.64,126.46 214.64,126.39 214.46,126.22 213.95,126.22 213.84,126.33 213.84,126.5 213.98,126.65 v2(214.13,126.65)
PEG_CTX_GRX_N6: length 63.1
  IN6 w0.089: v2(174.22,104.09) 174.22,104.72 174.41,104.91 175.5,104.91 175.73,104.68 177.51,104.68 179.71,106.88 184.12,106.88 187.8,110.56 188.85,110.56 190.69,112.4 190.69,113.76 192.5,115.58 192.5,115.98 193.26,116.74 193.26,117.35 193.87,117.96 194.77,117.96 195.28,118.47 195.28,118.96 195.9,119.58 197.51,119.58 199.51,121.57 199.86,121.57 201.24,122.95 201.24,123.57 202.26,124.59 202.26,126.82 203.33,127.9 204.28,127.9 205.25,128.86 207.66,128.86 208.31,129.51 208.99,129.51 209.24,129.25 v2(209.24,128.61)
  BOTTOM w0.076: CPU1.B16 172.27,104.27 172.15,104.27 171.98,104.11 171.98,103.99 172.11,103.87 173.17,103.87 173.46,103.58 174.56,103.58 174.65,103.67 174.65,103.81 174.54,103.92 174.4,103.92 v2(174.22,104.09)
  BOTTOM w0.107: CC7.1 215.85,127.58 215.73,127.47 215.73,127.41 215.6,127.28 214.65,127.28 214.51,127.41 209.7,127.41 209.68,127.43 209.32,127.43 208.76,127.99 208.76,128.23 208.94,128.41 209.05,128.41 v2(209.24,128.61)
PEG_CTX_GRX_N7: length 61.8
  IN6 w0.089: v2(176.35,105.86) 176.11,105.62 176.11,105.5 176.25,105.35 177.28,105.35 179.43,107.51 183.73,107.51 187.43,111.21 188.51,111.21 190.03,112.72 190.03,114.77 192.45,117.19 192.45,118.11 193.34,118.99 194.41,118.99 195.63,120.21 197.25,120.21 199.28,122.24 199.63,122.24 200.61,123.22 200.61,127.02 202.03,128.44 202.03,129.32 202.69,129.98 204.81,129.98 205.06,129.74 207.64,129.74 208.11,130.21 209.62,130.21 210.3,129.53 210.3,128.75 v2(210.44,128.61)
  BOTTOM w0.076: CPU1.B17 172.44,104.88 172.44,104.74 172.65,104.53 173.35,104.53 173.45,104.63 175.94,104.63 176.35,105.04 v2(176.35,105.86)
  BOTTOM w0.107: CC8.1 214.64,128.56 214.54,128.46 214.54,128.29 214.44,128.19 213.06,128.19 212.98,128.1 210.31,128.1 210.21,128.21 210.21,128.4 210.41,128.61 v2(210.44,128.61)
PEG_CTX_GRX_N8: length 103.5
  IN3 w0.127: v2(152.49,169.23) 152.36,169.1 152.36,168.46 155.96,164.86 155.96,162.54 159.41,159.1 161.58,159.1 163.86,156.81 163.86,154.61 165.93,152.54 165.93,152.44 168.02,150.36 172.96,150.36 173.15,150.17 184.43,150.17 188.87,145.74 188.87,125.14 180.79,117.07 180.79,112.86 178.67,110.74 178.67,108.73 176.66,106.71 174.89,106.71 174.44,106.27 174.44,106.12 v2(174.61,105.95)
  BOTTOM w0.076: CPU1.C18 171.8,105.66 171.8,105.51 172.04,105.28 174.44,105.28 174.61,105.45 v2(174.61,105.95)
  BOTTOM w0.107: v2(152.49,169.23) 152.3,169.42 152.3,169.74 152.69,170.13 152.72,170.13 153.12,170.54 153.12,170.58 153.59,171.04 153.59,171.52 CC9.1
PEG_CTX_GRX_N9: length 106.3
  IN3 w0.127: v2(154.98,171.41) 154.96,171.41 154.78,171.59 154.78,171.88 154.9,172 155.95,172 157.71,170.24 157.71,166.76 157.57,166.61 157.57,161.71 159.62,159.66 161.76,159.66 164.38,157.04 166.47,157.04 167.9,155.61 167.9,153.33 169.91,151.32 172.71,151.32 173.36,150.68 184.69,150.68 189.37,146 189.37,124.82 181.3,116.75 181.3,112.65 179.5,110.85 179.5,110.21 179.14,109.85 v2(179.14,109.38)
  BOTTOM w0.076: 177.72,106.56 174.13,106.56 174.06,106.5 173.39,106.5 173.28,106.38 173.27,106.38 173.17,106.28 172.82,106.28 172.63,106.48 172.63,106.58 172.72,106.68 172.87,106.68 CPU1.A19
  BOTTOM w0.107: v2(179.14,109.38) 179.14,109.53 179.25,109.63 179.44,109.63 179.58,109.5 179.58,108.26 177.88,106.56 177.72,106.56 ; v2(154.98,171.41) 154.82,171.57 154.82,173.46 CC10.1
PEG_CTX_GRX_N10: length 107.2
  IN3 w0.127: v2(156.19,171.04) 155.99,170.85 155.99,170.58 155.66,170.25 152.33,170.25 151.48,169.4 151.48,168.31 154.69,165.1 154.69,163.98 155.17,163.5 155.17,161.22 156.93,159.46 156.93,154.26 158.83,152.36 164.16,152.36 166.89,149.64 172.66,149.64 172.85,149.44 184.13,149.44 188.14,145.43 188.14,125.62 180.03,117.52 180.03,113.13 177.91,111 177.91,108.84 176.52,107.46 176.52,107.43 176.45,107.37 v2(176.39,107.37)
  BOTTOM w0.076: v2(176.39,107.37) 176.21,107.54 175.84,107.54 175.4,107.09 174.29,107.09 173.95,106.75 173.35,106.75 173.26,106.84 172.14,106.84 171.92,107.07 171.92,107.12 CPU1.C20
  BOTTOM w0.107: v2(156.19,171.04) 155.96,171.27 155.96,171.49 CC11.1
PEG_CTX_GRX_N11: length 109.9
  IN3 w0.127: v2(175.21,108.24) 175.69,108.72 175.69,110.77 177.06,112.14 177.77,112.14 178.99,113.35 178.99,117.91 187.19,126.12 187.19,133.01 186.4,133.81 186.4,135.74 186.92,136.27 186.92,145.31 183.74,148.5 172.45,148.5 172.26,148.69 166.49,148.69 163.77,151.42 158.44,151.42 155.99,153.87 155.99,159.07 154.23,160.83 154.23,162.31 151.63,164.91 151.63,166.82 150.54,167.92 150.54,169.79 153.94,173.19 156.8,173.19 157.32,172.66 157.32,172.18 157.38,172.12 157.38,172.12 v2(157.46,172.03)
  BOTTOM w0.076: v2(175.21,108.24) 175.21,108.11 175.14,108.05 175.06,108.05 174.95,107.94 174.58,107.94 173.22,107.94 173.13,107.85 172.87,107.85 172.74,107.97 172.74,108.08 172.82,108.15 172.97,108.15 CPU1.A21
  BOTTOM w0.107: v2(157.46,172.03) 157.31,172.19 157.31,172.97 157.44,173.09 157.44,173.42 CC12.1
