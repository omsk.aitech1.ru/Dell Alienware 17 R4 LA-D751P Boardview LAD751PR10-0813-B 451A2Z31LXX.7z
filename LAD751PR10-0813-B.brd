# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DEBUG_CTL1: length 2.7
  TOP w0.107: RT66.2 199.14,160.64 198.76,161.02 198.76,161.51 199.02,161.76 v2(199.17,161.76)
  BOTTOM w0.076: UT4.E4 199.47,162.07 v2(199.17,161.76)
DEBUG_CTL2: length 2.9
  TOP w0.102: v1(201.19,160.05) RT67.2
  TOP w0.107: RT67.2 200.03,160.66 199.82,160.88 v2(199.82,161.21)
  BOTTOM w0.076: UT4.D5 200.16,161.54 199.83,161.21 v2(199.82,161.21)
DEMB0: length 3.7
  BOTTOM w0.102: RM75.2 138.39,153.13 v1(137.98,153.54) 137.98,154.01
  BOTTOM w0.107: 137.98,154.01 137.31,154.68 UM8.53 ; RM75.2 RM79.2
DEMB1: length 4.6
  BOTTOM w0.107: 138.5,151.04 138.4,151.14 RM62.2 137.6,151.98 v1(137.75,152.13) 137.75,152.85 137.47,153.13 137.47,153.99 137.29,154.18 UM8.54
DEPOP#_EC: length 363
  TOP w0.102: UE6.2 330.54,40.15 v2(330.84,39.85)
  IN2 w0.102: v2(38.24,20.54) 41.22,23.53 41.22,30.26 40.33,31.15 38.62,31.15 38.35,31.41 38.35,33.81 35.31,36.85 35.31,38.13 34.68,38.77 34.68,44.83 35.98,46.12 48.51,46.12 49.96,44.67 52.96,44.67 53.23,44.41 54.32,44.41 54.97,45.06 57.57,45.06 58.49,45.97 63.83,45.97 64.53,45.27 93.34,45.27 94.08,44.53 96.35,44.53 96.52,44.71 98.59,44.71 98.76,44.55 106.89,44.55 112.76,38.68 132.31,38.68 135.23,35.76 179.2,35.76 186.1,42.66 190.47,42.66 191.05,43.24 198.48,43.24 199.2,43.96 202.48,43.96 202.77,43.67 211.05,43.67 211.28,43.45 212.84,43.45 213.21,43.82 214.71,43.82 215.12,43.41 220.4,43.41 224.42,39.39 230.08,39.39 230.7,40.01 231.75,40.01 233.18,41.45 235.06,41.45 235.89,42.28 237.69,42.28 238.7,41.27 239.67,41.27 241.04,39.9 244.18,39.9 244.84,40.56 266.53,40.56 276.25,30.84 279.64,30.84 283.45,27.03 289.85,27.03 294.89,21.99 295.68,21.99 297.05,23.36 305.02,23.36 305.7,24.05 307.37,24.05 307.54,24.23 308.05,24.23 308.42,24.6 308.42,25.42 309.26,26.27 312.86,26.27 313.3,25.83 318.28,25.83 319.05,25.06 323.18,25.06 v2(323.45,25.33)
  IN3 w0.102: v2(323.45,25.33) 323.67,25.55 323.67,29.17 328.95,34.45 328.95,36.35 329.68,37.07 329.68,38.61 330.84,39.78 v2(330.84,39.85)
  BOTTOM w0.102: DA2.3 38.46,20.77 v2(38.24,20.54)
DET: length 211.7
  TOP w0.107: v2(164.83,181.83) 165.12,181.54 JEDP.28
  IN1 w0.097: 193.27,31.78 194.76,31.78 195.61,30.94 197.45,30.94 198.08,30.3 198.08,29.93 198.46,29.55 199.53,29.55 201.17,27.91 201.17,25.37 201.36,25.18 201.36,24.35 201.63,24.09 201.63,22.87 v2(202.07,22.42)
  IN1 w0.102: 193.27,31.78 192.71,31.78 186.85,37.64 186.85,54.8 186.44,55.21 v2(186.44,55.98)
  IN4 w0.102: v2(186.44,55.98) 184.75,57.67 184.75,65.81 183.8,66.76 183.8,68.49 184.03,68.72 184.03,69.43 184.68,70.07 184.68,71.7 184.42,71.95 184.42,81.68 185.48,82.74 185.48,91.88 183.68,93.68 183.68,99.59 183.87,99.78 183.87,114.61 185.29,116.03 185.29,118.41 191.47,124.59 191.47,128.29 192.15,128.97 192.15,130.54 191.47,131.22 191.47,135.99 193.18,137.7 193.18,140.45 192.13,141.49 192.13,145.67 184.62,153.19 181.9,153.19 180.57,154.53 176.89,154.53 176.27,155.15 172.6,155.15 172.09,154.64 171.96,154.51 169.62,154.51 169.07,155.07 169.07,155.28 166.39,157.96 166.39,160.12 163.36,163.16 163.36,166.83 162.41,167.77 162.41,170.7 163.17,171.45 163.17,174.11 163.64,174.59 163.64,178 164.83,179.19 v2(164.83,181.83)
  BOTTOM w0.102: v1(201.98,14.93) 201.42,14.37 RH584.1 RH585.2
  BOTTOM w0.107: UH1.R35 201.68,22.81 v2(202.07,22.42) 202.07,22.18 202.49,21.76 202.74,21.76 202.95,21.54 202.95,19.72 202.54,19.31 202.54,17.71 202.09,17.25 202.09,16.52 202.45,16.16 202.45,15.4 v1(201.98,14.93)
DEVSLP0: length 51.9
  IN6 w0.102: v2(233.57,16.24) 233.38,16.05 231.29,16.05 230.88,16.46 226.96,16.46 226.55,16.05 220.67,16.05 218.4,18.32 216.29,18.32 215.65,17.69 213.69,17.69 213.37,18 208.73,18 207.86,18.87 v2(207.86,19.39)
  BOTTOM w0.089: UH1.AG42 v2(207.86,19.39)
  BOTTOM w0.102: JSSD3.38 244.77,7.92 243.86,8.83 242.23,8.83 242.07,8.67 242.07,8.05 241.69,7.66 238.63,7.66 238.04,8.25 238.04,10.03 237.51,10.56 233.65,10.56 233.39,10.83 v1(233.39,14.9) 233.39,16.06 v2(233.57,16.24)
DEVSLP1: length 160.1
  IN6 w0.089: 207.39,16.42 207.08,16.73 v2(207.08,17.18)
  IN6 w0.102: v2(319.31,11.57) 319.26,11.52 318.4,11.52 317.28,11.52 315.14,13.67 302.57,13.67 302.08,13.18 300.43,13.18 300.2,13.41 293.59,13.41 291.76,15.24 271.51,15.24 271.42,15.34 259.28,15.34 258.69,15.93 256.01,15.93 255.45,15.37 252.27,15.37 250.63,13.74 242.34,13.74 240.14,15.94 234.55,15.94 233.99,15.37 231.01,15.37 230.6,15.78 227.25,15.78 226.83,15.36 220.33,15.36 219.28,16.42 214.39,16.42 213.76,15.78 213.11,15.78 212.47,16.42 207.39,16.42
  BOTTOM w0.089: v2(207.08,17.18) 207.21,17.3 207.21,18.32 207.36,18.47 UH1.AG43
  BOTTOM w0.107: JSSD1.38 334.76,38.86 335.99,37.62 335.99,24.99 333.64,22.64 328.42,22.64 324.76,18.98 323.17,18.98 321.51,17.32 321.51,15.21 320.11,13.81 320.11,12.37 v2(319.31,11.57)
DEVSLP3: length 98.8
  IN6 w0.097: 183.45,23.39 183.45,25.31 184.76,26.62 191.22,26.62 ; 191.87,25.96 192.06,25.77 201.54,25.77 202.67,24.64 202.67,21.52 204.03,20.16 v2(204.35,20.16)
  IN6 w0.102: v2(120.66,11.48) 123.5,14.32 126.1,14.32 129.15,17.37 156.93,17.37 159.86,20.3 180.36,20.3 183.45,23.39 ; 191.87,25.96 191.22,26.62
  BOTTOM w0.089: UH1.AB41 204.85,19.66 v2(204.35,20.16)
  BOTTOM w0.102: v2(120.66,11.48) 119.91,11.48 119.42,10.99 JHDD.13
DEVSLP4: length 94.5
  TOP w0.102: v2(275.28,25.61) v1(275.28,26.29)
  IN3 w0.089: v2(205.38,20.17) 207.38,18.17 213.92,18.17 214.51,18.76 214.77,18.76 215.08,18.45 215.78,18.45 216.23,18.89 216.23,19.39 217.12,20.29 217.79,20.29 218.03,20.06
  IN3 w0.102: v2(275.28,25.61) 275.13,25.76 268.46,25.76 266.15,23.45 265.54,23.45 263.98,25.01 260.57,25.01 259.99,25.58 258.04,25.58 257.25,26.37 252.43,26.37 251.64,25.58 247.99,25.58 245.03,22.62 241.37,22.62 240.58,21.83 240.58,20.65 237.98,18.06 227.96,18.06 225.85,20.17 223.55,20.17 223.03,19.65 221.81,19.65 221.41,20.06 218.03,20.06
  BOTTOM w0.089: UH1.AB42 205.19,19.31 205.19,19.97 v2(205.38,20.17)
  BOTTOM w0.107: v2(275.28,25.61) 276.22,24.68 276.22,17.23 278.44,15.01 JSSD2.38
DGPU_ENBKL: length 169.2
  TOP w0.102: UV22.11 201.94,6.13 v1(202.12,6.31) 203.34,7.53 v2(203.34,9.57)
  IN3 w0.102: v2(181.51,71.03) 181.5,71.03 179.88,69.41 179.88,58.31 181.02,57.16 181.02,53.96 182.85,52.13 182.85,33.2 177.13,27.48 v2(175.92,27.48)
  IN6 w0.102: v2(216.04,108.62) 213.11,108.62 212.23,107.73 208.16,107.73 203.17,102.74 190.74,102.74 188.64,100.64 187.35,100.64 185.96,99.26 185.96,99.13 185.48,98.65 185.48,93.28 185.77,92.99 185.77,76.37 183.18,73.78 182.7,73.78 182.33,73.41 182.33,72.92 181.5,72.09 181.5,71.04 v2(181.51,71.03)
  BOTTOM w0.1: v2(216.04,108.62) 216.65,109.23 RG501.1 218.52,109.76 218.83,109.45 UG9.BB1
  BOTTOM w0.102: v2(175.92,27.48) 175.92,25.11 178.51,22.52 178.51,20.35 185.24,13.62 185.24,6.32 186.34,5.22 200.34,5.22 203.34,8.21 v2(203.34,9.57)
DGPU_ENVDD: length 202.1
  TOP w0.102: RG151.1 193.44,112 195.27,112 196.19,112.92 197.55,112.92 197.91,113.28 198.08,113.28 198.21,113.4 198.21,114.58 199.62,116 203.35,116 204.85,114.5 211.88,114.5 212.29,114.9 215.34,114.9 215.97,115.54 216.42,115.54 216.71,115.83 v2(216.87,115.83) ; v2(177.3,14.64) v1(179.65,12.29) 181.47,12.29 186.98,6.78 UV22.5
  IN3 w0.102: v2(181.49,73.39) 181.49,71.88 179.65,70.03 179.65,58.21 180.79,57.07 180.79,50.39 181.91,49.27 181.91,34.11 v2(175.29,27.48)
  IN4 w0.102: v2(216.87,115.83) 216.67,116.03 216.67,117.9 217.15,118.38 217.15,123.8 215.91,125.04 212.4,125.04 v2(210.63,126.8)
  IN6 w0.089: v2(216.87,115.83) 216.71,115.83 216.44,115.56 215.83,115.56 215.02,114.75
  IN6 w0.102: 215.02,114.75 214.63,114.36 212.3,114.36 211.82,113.87 209.66,113.87 209.22,114.32 205.43,114.32 201.72,110.61 201.72,109.74 198.72,106.74 197.8,106.74 196.71,105.65 196.69,105.65 196.32,105.28 191.48,105.28 188.65,102.44 188.39,102.44 185.49,99.55 185.49,99.31 185.02,98.84 185.02,93.09 185.31,92.8 185.31,76.56 182.99,74.24 182.51,74.24 181.96,73.69 181.66,73.39 v2(181.49,73.39)
  BOTTOM w0.089: v2(216.87,115.83) 217.52,115.83 217.94,115.41 217.94,113.91 218.51,113.34 220.06,113.34 UG9.BH3
  BOTTOM w0.102: v2(177.3,14.64) 177.64,14.98 177.64,15.5 177.49,15.65 177.49,22.53 174.87,25.16 174.87,27.06 v2(175.29,27.48) ; v2(210.63,126.8) 211.16,126.27 QG506.2
DGPU_HOLD_RST#: length 136
  TOP w0.114: v2(199.12,123.36) 199.12,122.05 196.9,119.83 193.95,119.83 192.94,118.82 187.48,118.82 185.89,117.23 184.57,117.23 181.29,113.95 181.29,99.72 182.16,98.84 183.81,98.84 185,97.65 185,96.49 188.39,93.09 188.39,71.15 190.73,68.81 190.73,67.55 191.38,66.89 v1(191.38,63.8) 191.35,63.77 v2(191.35,61.6)
  IN1 w0.081: v2(209.11,21.56) 208.48,22.19 208.48,23.75 208.38,23.84 208.38,24.95 207.65,25.68 207.65,30.05 207.13,30.57 204.88,30.57 203.44,32.01 203.44,35.67 202.47,36.64 202.47,37.01 200.21,39.28 198.07,39.28 196.75,40.59 193.53,40.59 190.07,44.05 190.07,60.32 v2(191.35,61.6)
  BOTTOM w0.089: UH1.AL36 209.25,21.56 v2(209.11,21.56)
  BOTTOM w0.114: v2(199.12,123.36) RG13.1 RG3.2 199.74,122.54 200.11,122.17 UG10.1
DGPU_INV_PWM: length 117.1
  TOP w0.102: UV22.2 193.69,8.73 193.43,8.48 193.43,8 192.9,7.47 187.55,7.47 v1(181.47,13.55) 180.89,14.13 179.83,14.13 178.57,15.39 v2(178.25,15.39) ; RG536.2 187.89,100.63 188.2,100.33 UG24.6 188.2,99.81 187.91,99.52 187.91,99.09 v2(188.31,98.69)
  IN3 w0.102: v2(175.29,26.9) 176.87,26.9 183.08,33.11 183.08,52.22 181.25,54.06 181.25,57.26 180.11,58.4 180.11,69.26 181.17,70.33 182.41,70.33 v2(183.11,71.03)
  IN6 w0.102: v2(188.31,98.69) 188.31,95.49 186.69,93.87 186.69,74.86 183.11,71.29 v2(183.11,71.03)
  BOTTOM w0.102: v2(178.25,15.39) 178.19,15.39 177.75,15.84 177.75,22.64 175.28,25.11 175.28,26.89 v2(175.29,26.9)
DGPU_PEX_RST#: length 145
  TOP w0.114: v2(214.66,158.59) 214.66,157.91 215.27,157.29 UG22.1 215.27,154.89 213.51,153.13 208.61,153.13 v1(208.38,152.9) 207.26,151.78 v2(207.03,151.78) ; v2(221.99,161.16) 221.99,161.2 222.32,161.53 UX1.2 223.68,161.53 RG25.1
  IN1 w0.081: v2(206.19,119.92) 206.69,119.42 206.69,117.7 v2(206.19,117.2) 206.6,116.8 206.6,116.29 206.31,116 205.83,116 v2(205.48,115.65) 205.48,115.34 205.56,115.26 209.32,115.26 209.94,114.63 210.9,114.63 214.91,118.65 v2(217.64,118.65)
  IN3 w0.127: v2(214.66,158.59) 214.66,158.88 215.25,159.47 216.8,159.47 217.23,159.04 220.76,159.04 221.4,159.67 222.09,159.67 222.36,159.94 222.36,160.79 v2(221.99,161.16) 221.99,161.27 222.3,161.57 222.3,162.08 221.81,162.57 218.17,162.57 v2(217.7,162.1)
  IN6 w0.081: v2(207.03,151.78) 206.44,151.19 206.44,150.76 203.65,147.97 202.32,147.97 v2(201.83,147.48) 201.83,143.44 204.93,140.33 204.93,134.49 208.29,131.13 214.33,131.13 223.7,121.76 224.06,121.76 v2(225.18,120.64)
  BOTTOM w0.089: RG4.1 234.2,120.29 233.85,120.64 v2(225.18,120.64) 225,120.46 223.44,120.46 222.12,119.14 219.09,119.14 218.6,118.65 v2(217.64,118.65)
  BOTTOM w0.114: v2(206.19,117.2) 206.13,117.2 205.83,117.51 QG501.2 QG501.5 ; v2(205.48,115.65) 200.65,115.65 200.39,115.39 DG1.1 198.98,115.39 198.66,115.7 RG7.2 RG6.2 ; QG7.5 QG7.2 205.88,120.24 v2(206.19,119.92) ; QV96.5 216.51,158.96 216.07,158.52 215.13,158.52 215.06,158.59 v2(214.66,158.59) 214.26,158.19 213.21,158.19 213.21,158.19 212.3,158.19 211.87,158.62 UX2.2 ; v2(217.7,162.1) 217.42,162.38 216.68,162.38 216.51,162.2 QV96.2 ; QG6.2 QG6.5 203.34,149.26 201.83,147.75 v2(201.83,147.48)
DGPU_PEX_RST#_R: length 6.1
  BOTTOM w0.089: RG4.2 234.78,119.11 235.72,119.11 v1(235.73,119.09) 235.91,118.92 235.91,116.2 236.12,115.99 236.12,115.55 236.47,115.2 UG9.BK26
DGPU_PRSNT#: length 5.8
  TOP w0.102: v2(217.44,29.74) 217.44,30.45 v1(217.71,30.72) 219.68,30.72 RH135.2
  BOTTOM w0.089: v2(217.44,29.74) 216.95,30.24 215.74,30.24 215.59,30.39 UH1.BC19
DGPU_PWR_EN: length 268.2
  TOP w0.102: v2(301.68,16.6) 301.68,17.5 302.3,18.12 303.09,18.12 303.46,18.49 303.46,20.45 305.54,22.53 UE5.1
  TOP w0.254: v2(207.8,20.04) 207.97,20.04 208.3,19.71 208.3,18.78 208.05,18.52 v1(208.05,18.5) 208.05,17.13 207.71,16.79 v2(207.6,16.79) ; v2(280.08,144.98) 280.08,144.89 279.54,144.34 278.22,144.34 277.52,143.64 RG551.1
  IN3 w0.089: 216.11,20.73 215.15,20.73 213.61,19.18 213.22,19.18 212.56,18.53 209.72,18.53 208.67,19.58 208.26,19.58 v2(207.8,20.04)
  IN3 w0.091: 216.11,20.73 216.45,20.38 216.96,20.38 218.03,21.46 219.18,21.46
  IN3 w0.102: v2(292.2,79.92) 291.8,80.31 291.8,86.36 289.52,91.06 288.89,92.44 288.6,93.39 288.12,94.89 287.57,96.72 287.29,97.78 286.79,99.83 286.59,100.81 286.02,104.04 285.9,104.96 285.79,106.23 285.68,107.75 285.67,109.09 285.68,109.88 285.68,139.44 280.15,144.98 v2(280.08,144.98) ; v2(301.68,16.6) 301.27,17.01 300.02,17.01 299.41,17.62 299.41,19.95 299.82,20.35 299.82,21.6 299.47,21.95 v2(298.54,21.95) 298.28,21.95 297.19,20.86 289.93,20.86 286.69,24.1 284.45,24.1 284,24.54 278.84,24.54 277.34,26.04 268.42,26.04 266.06,23.68 265.63,23.68 264.07,25.24 260.66,25.24 260.09,25.81 258.13,25.81 257.48,26.47 257.34,26.6 252.33,26.6 251.54,25.81 247.9,25.81 244.93,22.85 241.28,22.85 240.35,21.92 240.35,20.75 237.89,18.29 228.06,18.29 225.94,20.4 223.45,20.4 222.93,19.88 221.91,19.88 220.33,21.46 219.18,21.46
  BOTTOM w0.102: v2(292.2,79.92) 292.2,74.53 298.69,68.04 298.69,64.04 299.79,62.94 299.79,62.5 301.83,60.46 302.08,60.46 302.51,60.03 302.51,57.83 302.05,57.37 302.05,50.29 304.45,47.89 304.45,43.73 306.31,41.88 306.31,40.88 306.96,40.23 306.96,39.16 306.49,38.69 306.49,33.02 305.17,31.71 304.95,31.71 302.61,29.37 302.61,27.44 298.54,23.36 v2(298.54,21.95)
  BOTTOM w0.254: RH537.1 207.78,15.48 208.11,15.8 208.11,16.28 v2(207.6,16.79) ; UH1.AJ39 208.18,20.42 v2(207.8,20.04)
DGPU_PWROK: length 142.9
  TOP w0.089: RH516.2 206.52,21.18 208.1,21.18 208.56,20.71 v1(208.56,20.3) 208.56,17.32 v2(208.61,17.28)
  TOP w0.114: v2(328.4,44.22) 328.67,43.95 UE6.19
  IN1 w0.081: v2(328.4,44.22) 328,43.83 328,41.74 326.88,40.62 326.88,38.57 323.86,35.54 322.16,35.54 320.51,33.89 293.83,33.89 293.61,33.67 291.88,33.67 288.84,30.64 275.22,30.64 274.32,29.75 260.13,29.75 259.12,28.73 245.44,28.73 235.1,18.38 227.75,18.38 226.73,17.37 226.33,16.97 223.29,16.97 222.72,17.54 221.89,17.54 221.5,17.94 219.18,17.94 ; v2(208.61,17.28) 209.08,17.75 215.65,17.75 216.42,18.51 218.13,18.51 218.51,18.13
  IN1 w0.089: 219.18,17.94 218.7,17.94 218.51,18.13
  BOTTOM w0.089: v2(208.61,17.28) 208.45,17.43 UH1.AJ44
DGPU_ROM_CS#: length 29.9
  TOP w0.114: v2(212.84,113.54) 212.37,114.01 v1(210.03,114.01) 209.18,114.01 207.96,112.8 205.87,112.8 205.13,113.54 204.79,113.54 203.05,115.28 199.92,115.28 198.92,114.28 198.92,113.11 198.38,112.56 198.2,112.56 197.84,112.2 196.49,112.2 196.06,111.77 196.06,110.97 196.25,110.78 UG16.11
  BOTTOM w0.089: 210.82,108.11 RG74.2 211.77,109.18 212.92,110.33 212.92,111.47 213.11,111.67 213.11,113.27 v2(212.84,113.54)
  BOTTOM w0.114: UG13.1 210.82,108.11
DGPU_ROM_SCLK: length 1.6
  BOTTOM w0.114: UG13.6 RG75.1
DGPU_ROM_SI: length 4
  BOTTOM w0.114: UG13.5 RG77.1 200.68,104.93 200.24,104.93 199.95,105.23 v1(199.22,105.23)
DGPU_ROM_SO: length 25.2
  TOP w0.114: UG16.8 197.1,109.28 197.23,109.15 197.71,109.15 v2(198,108.86)
  BOTTOM w0.114: v2(198,108.86) 198,108.41 198.72,107.7 198.72,105.17 200.12,103.77 204.24,103.77 205.02,104.55 206.38,104.55 207.14,103.8 212.55,103.8 214,105.25 214,106.27 v1(213.84,106.43) 213.43,106.84 RG76.1
DGPU_ROM_SO_R: length 1.6
  BOTTOM w0.089: 210.82,106.84 RG76.2
  BOTTOM w0.114: UG13.2 210.82,106.84
DH_1.2V: length 3.8
  TOP w0.102: v2(89.93,42.94) v1(89.19,42.94)
  IN4 w1.016: 88.27,40.29 88.27,42.39 88.97,43.09
  vias: v2(89.29,39.2) v2(89.29,38.58) v2(90.31,43.39)
DH_CHG: length 13.2
  TOP w0.102: v2(74.81,20.16) v1(75.68,20.16)
  IN1 w1.016: 62.12,21.69 62.12,21.37 64.22,19.27 70.81,19.27 71.53,19.99 73.01,19.99
  vias: v2(61.54,22.57) v2(62.18,22.57) v2(74.18,20.16)
DIMM_CHA_SA0: length 4
  TOP w0.102: v2(177.25,50.42) 177.25,50.27 177.44,50.08 v1(177.78,50.08)
  TOP w0.107: v2(177.25,50.42) 177.36,50.53 RD28.1 RD1.2
  BOTTOM w0.127: v2(177.25,50.42) 177.44,50.61 JDIMM1.256
DIMM_CHA_SA1: length 5.1
  TOP w0.102: RD2.2 179.13,54.08 179.36,54.31 v1(180.08,54.31)
  TOP w0.107: RD2.2 178.6,54.25 RD29.1 v2(177.87,53.5)
  BOTTOM w0.127: v2(177.87,53.5) 178.44,52.93 JDIMM1.260
DIMM_CHA_SA2: length 8.1
  TOP w0.102: v1(157.82,46.77) RD3.2
  TOP w0.107: v2(154.69,49.15) 154.69,47.23 155.15,46.77 RD30.1 RD3.2
  BOTTOM w0.127: JDIMM1.166 154.94,50.71 155.1,50.56 155.1,49.55 v2(154.69,49.15)
DIMM_CHB_SA0: length 5.1
  TOP w0.102: v1(175.45,38.69) RD4.2
  TOP w0.107: RD38.1 176.35,36.8 177.17,37.62 v2(177.17,37.7) 177.17,38.18 RD4.2
  BOTTOM w0.107: v2(177.17,37.7) 177.45,37.98 177.45,38.99 JDIMM2.256
DIMM_CHB_SA1: length 3.9
  TOP w0.107: RD5.2 177.55,38.32 177.81,38.07 v2(177.81,37.69) 177.81,37.37 177.24,36.8 RD39.1
  BOTTOM w0.107: 178.44,38.26 177.88,37.69 v2(177.81,37.69)
  BOTTOM w0.127: JDIMM2.260 178.44,38.26
DIMM_CHB_SA2: length 5.6
  TOP w0.102: v1(154.83,40.96) 155.49,40.96 155.53,40.93 v2(155.54,40.93)
  TOP w0.107: RD6.2 RD40.1 156.23,40.25 v2(155.54,40.93)
  BOTTOM w0.107: v2(155.54,40.93) 154.94,40.33 JDIMM2.166
DISP_CEC: length 3.2
  BOTTOM w0.107: RV18.2 233.45,167.82 v1(233.45,168.69) 233.45,169.48 233.57,169.61 JDP.6
DISP_CLK_AUXP_CONN: length 17.8
  IN1 w0.089: v2(236.62,168.8) 236.53,168.7 235.93,168.7 232.7,165.47 232.7,164.05 231.94,163.3 231.94,162.25 232.21,161.98 232.45,161.98 v2(232.61,161.82)
  BOTTOM w0.089: RV15.2 236.11,167.27 236.32,167.48 236.32,167.6 236.04,167.88 236.04,168.33 236.24,168.52 236.35,168.52 v2(236.62,168.8) 236.81,168.61 236.94,168.61 237.04,168.71 237.04,169.2 236.88,169.36 236.88,169.44 236.57,169.74 JDP.16 ; UV3.4 231.92,161.12 v2(232.61,161.82)
DISP_DAT_AUXN_CONN: length 17.7
  IN1 w0.089: v2(232.62,162.74) 232.62,162.34 232.5,162.22 232.25,162.22 232.14,162.33 232.14,163.21 232.89,163.97 232.89,165.39 236.01,168.5 236.33,168.5 v2(236.62,168.21)
  BOTTOM w0.089: JDP.18 237.18,169.8 237.05,169.68 237.05,169.44 237.22,169.27 237.22,168.63 237.01,168.43 236.84,168.43 v2(236.62,168.21) 236.49,168.35 236.31,168.35 236.22,168.26 236.22,167.96 236.91,167.27 RV16.2 ; v2(232.62,162.74) 232.62,162.82 232.25,163.19 230.92,163.19 230.81,163.07 UV3.7
DISPOFF#: length 30.7
  TOP w0.102: RV1.1 168.18,160.23 168.74,159.67 DV1.1 169.29,158.84 v2(169.29,158.03) ; JEDP.35 v2(168.62,181.2) 168.63,181.2 168.63,181.92 v1(167.92,182.63)
  IN3 w0.102: v2(169.29,158.03) 169.29,159.18 167.59,160.87 167.59,167.18 167.18,167.59 167.18,172.66 168.01,173.49 168.01,176.8 169.17,177.96 169.17,180.65 v2(168.62,181.2)
DL_1.2V: length 7.5
  IN4 w1.016: 91.39,40.66 91.39,39.85 95.51,35.72
  BOTTOM w0.102: v1(90.67,41.27) 91.14,41.74 v2(91.35,41.74)
  vias: v2(91.34,42.35) v2(95.58,34.51) v2(95.58,33.88)
DL_CHG: length 2.2
  IN4 w1.016: 61.79,19.84 63.25,19.84 63.76,20.35
  vias: v2(60.42,20.95) v2(60.85,20.54) v2(64.46,21.05) v2(65.1,21.05)
DMI_CRX_PTX_N0: length 87
  IN1 w0.089: v2(187.94,28.83) 187.94,29.13 187.31,29.76 187.31,29.92 183.44,33.79 183.44,52.51 182.25,53.71 182.25,58.86 180.56,60.54 180.56,63.79 178.98,65.38 178.98,78.58 178.56,79.01 178.56,86.6 177.26,87.9 177.26,91.34 173.7,94.89 173.7,96.96 173.04,97.62 171.23,97.62 170.91,97.94 170.91,98.09 v2(170.71,98.3)
  BOTTOM w0.076: v2(170.71,98.3) 170.71,98.27 170.41,97.91 CPU1.E8
  BOTTOM w0.089: 194.72,26.78 195.03,26.47 195.3,26.47 UH1.C27
  BOTTOM w0.107: v2(187.94,28.83) 188.84,27.92 192.86,27.92 194.01,26.78 194.72,26.78
DMI_CRX_PTX_N1: length 88.1
  IN1 w0.089: v2(188.29,27.03) 188.49,27.23 188.49,27.45 188.37,27.56 188.09,27.56 186.41,29.25 186.41,29.87 182.81,33.47 182.81,52.25 181.61,53.44 181.61,58.55 179.89,60.27 179.89,63.57 178.34,65.11 178.34,70.89 177.92,71.31 177.92,86.3 176.62,87.6 176.62,91.27 173.11,94.78 173.11,96.62 172.64,97.09 170.62,97.09 170.2,97.51 v2(170.06,97.51)
  BOTTOM w0.076: CPU1.F6 169.71,97.17 v2(170.06,97.51)
  BOTTOM w0.099: UH1.B28 195.02,26.23 194.88,26.09 194.25,26.09
  BOTTOM w0.107: v2(188.29,27.03) 188.33,27.03 188.57,26.79 188.57,26.45 188.85,26.16 191.14,26.16 191.44,26.46 193.18,26.46 193.51,26.12 194.22,26.12 194.25,26.09
DMI_CRX_PTX_N2: length 90.7
  IN1 w0.089: v2(170.71,96.72) 170.87,96.56 170.87,96.33 172.31,94.89 172.31,93.95 172.63,93.63 173.55,93.63 175.99,91.2 175.99,87.34 177.29,86.04 177.29,70.74 177.71,70.32 177.71,64.85 179.25,63.31 179.25,60.01 180.98,58.28 180.98,46.77 181.64,46.11 181.64,32.87 188.36,26.15 189.88,26.15 190.7,25.33 190.7,23.54 190.99,23.25 191.58,23.25 v2(191.73,23.11)
  BOTTOM w0.076: v2(170.71,96.72) 170.38,96.4 CPU1.E5
  BOTTOM w0.089: 194.04,25.68 194.84,25.68 195.04,25.48 195.14,25.48 195.22,25.55 195.22,25.67 UH1.B29
  BOTTOM w0.107: v2(191.73,23.11) 191.73,23.16 192.17,23.61 192.17,25.62 192.28,25.72 193.99,25.72 194.04,25.68
DMI_CRX_PTX_N3: length 96.2
  IN1 w0.089: v2(168.7,99.09) 169.04,98.75 169.18,98.75 169.5,98.43 169.5,97.33 170.14,96.7 170.14,95.91 171.74,94.31 171.74,93.82 172.26,93.3 173.48,93.3 175.52,91.27 175.52,87.14 176.82,85.84 176.82,70.55 177.24,70.13 177.24,64.66 178.78,63.11 178.78,59.81 180.48,58.11 180.48,46.58 181.17,45.89 181.17,32.68 187.02,26.83 187.02,24.99 187.49,24.53 189.49,24.53 190.23,23.79 190.23,22.52 190.67,22.08 191.57,22.08 v2(191.75,22.27)
  BOTTOM w0.076: v2(168.7,99.09) 168.68,98.97 168.42,98.78 CPU1.J9
  BOTTOM w0.089: UH1.B30 195.14,25.1 194.81,25.43
  BOTTOM w0.107: 194.81,25.43 192.96,25.43 192.53,25 192.53,23.41 192.27,23.15 192.27,22.36 192.17,22.25 191.77,22.25 v2(191.75,22.27)
DMI_CRX_PTX_P0: length 87
  IN1 w0.089: v2(188.35,29.24) 188.06,29.24 187.48,29.83 187.48,29.99 183.61,33.86 183.61,52.58 182.41,53.78 182.41,58.93 180.73,60.61 180.73,63.86 179.14,65.45 179.14,78.65 178.72,79.07 178.72,86.67 177.42,87.97 177.42,91.4 173.86,94.96 173.86,97.03 173.11,97.78 171.3,97.78 171.08,98.01 171.08,98.2 171.18,98.3 v2(171.36,98.3)
  BOTTOM w0.076: v2(171.36,98.3) 171.03,97.97 CPU1.D8
  BOTTOM w0.089: 194.93,27.13 195.17,27.13 195.19,27.1 195.25,27.1 195.37,26.99
  BOTTOM w0.107: UH1.B27 195.25,26.71 195.37,26.83 195.37,26.99 ; 194.93,27.13 194.78,26.98 194.78,26.98 194.09,26.98 192.95,28.12 188.93,28.12 188.35,28.71 188.35,29.24 v2(188.35,29.24)
DMI_CRX_PTX_P1: length 88.1
  IN1 w0.089: v2(170.71,97.51) 170.71,97.34 170.8,97.25 172.71,97.25 173.27,96.68 173.27,94.85 176.79,91.34 176.79,87.67 178.09,86.37 178.09,71.38 178.51,70.96 178.51,65.18 180.05,63.64 180.05,60.34 181.78,58.62 181.78,53.51 182.97,52.31 182.97,33.54 186.57,29.94 186.57,29.32 188.16,27.73 188.44,27.73 188.65,27.51 188.65,27.21 188.85,27.02 v2(189.18,27.02)
  BOTTOM w0.076: CPU1.E6 170.38,97.23 170.67,97.51 v2(170.71,97.51)
  BOTTOM w0.099: 194.46,26.54 194.5,26.59 194.65,26.59 194.79,26.45 194.79,26.36 UH1.A28
  BOTTOM w0.107: v2(189.18,27.02) 189.18,27.14 189.07,27.24 188.88,27.24 188.77,27.14 188.77,26.53 188.94,26.36 191.06,26.36 191.36,26.66 193.26,26.66 193.6,26.33 194.35,26.33 194.46,26.43 194.46,26.54
DMI_CRX_PTX_P2: length 90.7
  IN1 w0.089: v2(171.36,96.72) 171.19,96.72 171.04,96.58 171.04,96.4 172.48,94.96 172.48,94.02 172.7,93.8 173.62,93.8 176.15,91.27 176.15,87.4 177.45,86.1 177.45,70.81 177.87,70.39 177.87,64.92 179.42,63.38 179.42,60.07 181.14,58.35 181.14,46.84 181.81,46.17 181.81,32.94 188.43,26.31 189.94,26.31 190.86,25.39 190.86,23.61 191.05,23.42 191.37,23.42 191.46,23.5 191.46,23.6 191.55,23.69 v2(191.73,23.69)
  BOTTOM w0.076: v2(171.36,96.72) 171.03,96.4 CPU1.D5
  BOTTOM w0.089: UH1.C29 195.55,25.72 195.3,25.97 195.07,25.97 194.98,25.88 194.18,25.88
  BOTTOM w0.107: v2(191.73,23.69) 191.79,23.69 191.97,23.87 191.97,25.71 192.19,25.93 194.13,25.93 194.18,25.88
DMI_CRX_PTX_P3: length 95.9
  IN1 w0.089: v2(168.76,98.3) 168.76,98.41 168.93,98.59 169.11,98.59 169.34,98.36 169.34,97.26 169.97,96.63 169.97,95.84 171.57,94.24 171.57,93.75 172.19,93.14 173.41,93.14 175.35,91.2 175.35,87.07 176.65,85.77 176.65,70.48 177.07,70.06 177.07,64.59 178.62,63.04 178.62,59.74 180.31,58.05 180.31,46.52 181.01,45.82 181.01,32.61 186.86,26.76 186.86,24.93 187.42,24.36 189.42,24.36 190.06,23.72 190.06,22.45 190.6,21.91 191.52,21.91 v2(191.75,21.68)
  BOTTOM w0.076: CPU1.J8 168.44,98.3 v2(168.76,98.3)
  BOTTOM w0.107: UH1.A30 194.63,25.23 193.04,25.23 192.73,24.92 192.73,23.32 192.48,23.07 192.48,22.27 192.25,22.05 192.24,22.05 192.13,21.94 192.13,21.73 192,21.59 191.85,21.59 v2(191.75,21.68)
DMI_CTX_PRX_N0: length 96.2
  IN1 w0.089: v2(199.21,26.37) 199.54,26.69 199.54,27.65 198.14,29.05 194.21,29.05 185.98,37.28 185.98,53.56 184.79,54.76 184.79,61.72 183.48,63.03 183.48,65.63 183.01,66.1 182.38,66.1 182.13,66.34 182.13,68.44 182.55,68.85 182.55,72.26 182.13,72.68 182.13,73.89 183.84,75.6 183.84,86.27 186.06,88.48 186.06,92.12 183.34,94.84 179.28,94.84 177.86,96.26 176.89,96.26 176.59,96.56 176.59,96.69 v2(176.41,96.87)
  BOTTOM w0.076: CPU1.A8 172.87,97.79 172.69,97.79 172.62,97.86 172.62,98.1 172.73,98.21 173.28,98.21 173.45,98.39 174.07,98.39 174.34,98.12 174.8,98.12 174.83,98.1 174.83,98.1
  BOTTOM w0.107: UH1.L27 199.68,26.74 199.31,26.37 v2(199.21,26.37) ; 174.83,98.1 175.18,98.1 175.78,97.5 176.64,97.5 176.79,97.36 176.79,97.19 176.47,96.87 v2(176.41,96.87)
DMI_CTX_PRX_N1: length 93.6
  IN1 w0.089: v2(174.66,96.93) 174.73,96.93 175.08,96.58 175.08,96 175.45,95.62 177.59,95.62 179.02,94.2 183.08,94.2 185.42,91.86 185.42,88.74 182.39,85.71 182.39,75.09 180.88,73.58 180.88,72.72 181.91,71.69 181.91,69.49 180.88,68.47 180.88,66.34 182.84,64.38 182.84,62.69 184.15,61.38 184.15,54.5 185.35,53.3 185.35,37.02 194.5,27.87 197,27.87 197.09,27.78 197.09,27.51 v2(196.99,27.41)
  BOTTOM w0.076: 174.14,97.42 172.09,97.42 171.97,97.3 171.97,97 172.06,96.91 172.29,96.91 172.33,96.96 CPU1.B6
  BOTTOM w0.101: UH1.E24 v2(196.99,27.41)
  BOTTOM w0.107: 174.14,97.42 174.16,97.45 174.57,97.45 174.57,97.45 174.73,97.45 174.85,97.32 174.85,97.12 v2(174.66,96.93)
DMI_CTX_PRX_N2: length 94.4
  IN1 w0.089: v2(176.38,94.96) 177.77,93.57 182.81,93.57 184.79,91.59 184.79,89.01 180.25,84.47 180.25,72.31 180.64,71.93 180.64,69.17 180.25,68.78 180.25,66.07 182.21,64.11 182.21,61.56 182.34,61.43 182.34,60.56 183.52,59.39 183.52,54.23 184.71,53.04 184.71,34.39 190.37,28.73 191.65,28.73 194.65,25.74 197.22,25.74 197.4,25.92 197.4,26.02 v2(197.75,26.37)
  BOTTOM w0.076: CPU1.A5 173.12,96.22 173.33,96.22 173.4,96.28 173.4,96.37 173.24,96.52 173.24,96.57 173.28,96.61 173.43,96.61 173.46,96.59 173.48,96.59
  BOTTOM w0.107: v2(176.38,94.96) 176.48,94.86 176.6,94.86 176.8,95.06 176.8,95.38 175.9,96.27 174.34,96.27 174.03,96.59 173.48,96.59 ; UH1.G27 197.41,26.83 197.75,26.38 v2(197.75,26.37)
DMI_CTX_PRX_N3: length 94.6
  IN1 w0.089: v2(199.97,25.1) 199.97,24.87 200.53,24.32 200.53,22.79 200.22,22.47 199.51,22.47 199.23,22.75 199.23,23.08 198.82,23.49 195.92,23.49 194.92,24.48 194.64,24.48 191.28,27.83 190.35,27.83 184.08,34.11 184.08,52.77 182.88,53.97 182.88,59.12 181.71,60.3 181.71,60.8 181.57,60.93 181.57,63.85 179.61,65.81 179.61,69.18 180,69.57 180,71.62 179.61,72.01 179.61,79.4 179.23,79.78 179.23,87.26 177.94,88.55 177.94,91.41 174.82,94.53 174.82,94.78 v2(174.64,94.96)
  BOTTOM w0.076: 173.54,95.83 173.52,95.83 173.48,95.87 172.56,95.87 172.48,95.8 172.48,95.42 172.41,95.34 172.22,95.34 172.15,95.28 171.81,95.28 171.7,95.39 171.7,95.57 171.81,95.68 171.95,95.68 CPU1.B4
  BOTTOM w0.099: v2(199.97,25.1) 199.68,25.39 UH1.L29
  BOTTOM w0.107: 173.54,95.83 173.67,95.83 174.09,95.42 174.62,95.42 174.71,95.33 174.71,95.03 v2(174.64,94.96)
DMI_CTX_PRX_P0: length 96.3
  IN1 w0.089: v2(199.85,26.38) 199.7,26.53 199.7,27.72 198.21,29.22 194.28,29.22 186.15,37.35 186.15,53.63 184.95,54.83 184.95,61.79 183.64,63.09 183.64,65.7 183.08,66.26 182.44,66.26 182.3,66.41 182.3,68.37 182.71,68.78 182.71,72.33 182.3,72.75 182.3,73.82 184.01,75.53 184.01,86.2 186.22,88.41 186.22,92.19 183.41,95 179.35,95 177.93,96.43 176.95,96.43 176.75,96.63 176.75,96.75 176.87,96.87 v2(176.99,96.87)
  BOTTOM w0.076: CPU1.B8 172.39,97.96 172.39,98.15 172.43,98.18 172.65,98.41 173.2,98.41 173.37,98.58 174.15,98.58 174.42,98.32 174.81,98.32 174.82,98.3
  BOTTOM w0.107: v2(199.85,26.38) 200.3,26.83 UH1.N27 ; v2(176.99,96.87) 176.99,97.44 176.72,97.71 175.86,97.71 175.27,98.3 174.82,98.3
DMI_CTX_PRX_P1: length 93.6
  IN1 w0.089: v2(175.25,96.93) 175.25,96.07 175.52,95.79 177.66,95.79 179.08,94.37 183.14,94.37 185.59,91.92 185.59,88.68 182.55,85.64 182.55,75.02 181.05,73.52 181.05,72.79 182.08,71.76 182.08,69.42 181.05,68.4 181.05,66.41 183.01,64.45 183.01,62.76 184.32,61.45 184.32,54.57 185.51,53.37 185.51,37.08 194.57,28.03 197.07,28.03 197.68,27.41 v2(197.75,27.41)
  BOTTOM w0.076: CPU1.C6 171.79,97.22 171.79,97.39 172.02,97.62 174.04,97.62 174.05,97.63 174.1,97.63 174.13,97.65 174.14,97.65
  BOTTOM w0.101: UH1.G24 v2(197.75,27.41)
  BOTTOM w0.107: v2(175.25,96.93) 175.05,97.12 175.05,97.41 174.81,97.65 174.14,97.65
DMI_CTX_PRX_P2: length 94.4
  IN1 w0.089: v2(196.99,26.37) 197.24,26.12 197.24,25.99 197.15,25.9 194.72,25.9 191.72,28.9 190.44,28.9 184.88,34.46 184.88,53.11 183.68,54.3 183.68,59.46 182.51,60.63 182.51,61.5 182.37,61.63 182.37,64.18 180.41,66.14 180.41,68.72 180.8,69.1 180.8,71.99 180.41,72.38 180.41,84.4 184.95,88.94 184.95,91.66 182.88,93.73 177.84,93.73 176.74,94.83 176.74,95.1 176.88,95.24 177.09,95.24 v2(177.17,95.17)
  BOTTOM w0.076: CPU1.B5 172.51,96.33 172.62,96.44 172.98,96.8 173.43,96.8 173.46,96.83 173.48,96.83
  BOTTOM w0.101: UH1.E26 v2(196.99,26.37)
  BOTTOM w0.107: 173.48,96.83 174.07,96.83 174.42,96.48 175.98,96.48 177,95.46 177,95.33 v2(177.17,95.17)
DMI_CTX_PRX_P3: length 94.6
  IN1 w0.089: v2(175.22,94.96) 175.1,94.96 174.98,94.85 174.98,94.59 178.1,91.48 178.1,88.62 179.4,87.32 179.4,79.85 179.78,79.47 179.78,72.08 180.17,71.69 180.17,69.5 179.78,69.11 179.78,65.88 181.74,63.92 181.74,61 181.87,60.86 181.87,60.37 183.05,59.19 183.05,54.04 184.24,52.84 184.24,34.17 190.42,28 191.35,28 194.7,24.64 194.86,24.64 194.99,24.64 195.99,23.65 198.89,23.65 199.4,23.15 199.4,22.82 199.58,22.64 200.15,22.64 200.36,22.85 200.36,24.25 199.86,24.76 199.8,24.76 199.61,24.95 199.61,25.01 199.53,25.1 v2(199.21,25.1)
  BOTTOM w0.076: 173.54,96.08 173.52,96.08 173.5,96.05 172.45,96.05 172.35,95.95 171.8,95.95 CPU1.D4
  BOTTOM w0.099: UH1.K29 198.92,25.39 v2(199.21,25.1)
  BOTTOM w0.107: 173.54,96.08 173.71,96.08 174.17,95.62 174.71,95.62 174.91,95.41 174.91,95.21 175.16,94.96 v2(175.22,94.96)
DMIC_CLK1_R: length 3.5
  BOTTOM w0.099: UA1.53 33.62,34.91 v1(34.08,35.38) 34.36,35.66 34.36,36.46 LA6.2
DMIC_DATA1_R: length 3.6
  BOTTOM w0.099: UA1.54 34.02,34.63 34.22,34.83 35.66,34.83 35.76,34.93 35.76,35.18 35.66,35.27 35.41,35.27 35.31,35.37 RA19.2
DP_AUXN_C: length 4.9
  BOTTOM w0.089: UV3.5 228.73,161.77 227.81,160.85 227.44,160.85 226.98,161.31 v3(226.65,161.31) 226.27,161.31 226.03,161.07 226.03,160.61 CV25.1
DP_AUXP_C: length 4.8
  BOTTOM w0.089: CV24.1 226.21,160.65 226.21,160.99 226.3,161.09 226.95,161.09 227.37,160.67 228,160.67 v1(228.07,160.6) 228.45,160.6 228.53,160.52 228.53,160.14 228.85,159.82 UV3.2
DP_CBL_DET: length 154.7
  TOP w0.102: v2(233.44,158.78) 234.43,159.77 v1(235.8,159.77) 238.22,162.2 238.22,166.57 237.35,167.44 236.37,167.44 235.67,168.14 233.4,168.14 v2(232.8,168.74)
  IN4 w0.102: v2(220.72,120.31) 220.72,120.23 223.36,117.6 225.48,117.6 226.1,118.22 226.1,120.03 229.77,123.69 236.11,123.69 239.25,126.83 261.99,126.83 264.75,129.58 268.68,129.58 269.78,130.68 269.78,143.07 264.04,148.81 257.7,148.81 257.15,149.37 253.4,149.37 252.42,148.39 244.78,148.39 243.21,149.97 241.24,149.97 240.03,151.18 239.07,151.18 238.48,151.78 238.48,156.41 236.1,158.78 v2(233.44,158.78)
  BOTTOM w0.089: 211.19,121.97 211.48,121.69 211.48,121.23 212.6,120.11 213.04,120.11 214.21,118.94 215.95,118.94 216.4,119.39 218.56,119.39 219.48,120.31 v2(220.72,120.31)
  BOTTOM w0.102: v2(233.44,158.78) 230.67,158.78 230.27,159.17 UV3.1 228.66,159.17 228.55,159.06 228.55,158.12 RV17.1 ; QG500.2 209.62,122.17 209.89,122.44 210.72,122.44 211.19,121.97
  BOTTOM w0.107: JDP.4 232.97,169.41 232.8,169.24 v2(232.8,168.74)
DP_CBL_DET#: length 41.6
  TOP w0.089: v1(221.83,110.91) v2(221.47,110.55)
  IN2 w0.089: v2(221.47,110.55) 221.47,109.01 223.2,107.28 224.56,107.28 226,108.72 226,110.58 226.06,110.64 226.06,116.23 225.3,116.99 225.3,118.07 225.12,118.24 225.12,118.69 226.04,119.62 226.04,120.56
  IN2 w0.102: 226.04,120.56 226.04,122.17 223.97,124.24 216.57,124.24 215.6,125.21 210.1,125.21 v2(209.91,125.03)
  BOTTOM w0.089: UG9.BD5 v2(221.47,110.55)
  BOTTOM w0.102: RG540.1 208.7,125.41 209.08,125.03 v2(209.91,125.03)
DP_HPD_GPU#: length 158.1
  TOP w0.102: v2(221.5,156.46) v1(221.5,156.98) 221.5,158.03 RX5.2 221.81,158.4 221.81,159.18 221.55,159.44 220.86,159.44 220.25,158.84 QV97.3
  IN4 w0.102: v2(221.5,156.46) 222.36,156.46 224.19,154.63 231.41,154.63 232.01,155.24 232.01,163.18 232.11,163.28 236.35,163.28 237.28,162.35 237.28,158.77 238.71,157.35 238.71,151.87 239.17,151.41 240.12,151.41 241.34,150.2 243.3,150.2 244.88,148.62 252.33,148.62 253.3,149.6 257.26,149.6 257.79,149.07 264.11,149.07 270.01,143.16 270.01,130.59 268.78,129.36 264.84,129.36 262.09,126.6 239.34,126.6 236.21,123.46 229.86,123.46 226.29,119.89 226.29,118.14 224.96,116.81 222.98,116.81 221.74,118.05 218.44,118.05 217.43,117.05 217.43,113.82 v2(217.07,113.46)
  BOTTOM w0.1: UG9.BE3 220.16,111.55 219.83,111.88 219.54,111.88 219.26,112.16 218.4,112.16 217.75,112.81 217.74,112.81 217.61,112.93 217.6,112.93 v2(217.07,113.46)
DP_HPD_PCH: length 207.3
  TOP w0.102: UX1.1 222.87,160.45 222.91,160.41 RX4.1 222.91,159.61 222.28,158.99 v2(222.28,158.93) 222.28,158.92 222.59,158.62 v1(222.59,158.53)
  IN2 w0.102: v2(222.28,158.93) 222.06,158.93 221.51,158.39 217.34,158.39 217.13,158.6 216.85,158.6 216.58,158.34 216.58,157.63 216.31,157.36 215.22,157.36 214.32,158.26 211.1,158.26 210.69,157.85 210.69,157.07 210.28,156.66 210.05,156.66 208.87,155.48 208.87,154.61 206.18,151.92 206.18,150 196.47,140.28 196.47,137.87 190.34,131.74 190.34,126.21 185.03,120.9 185.03,115.63 183.84,114.45 183.84,105.34 181.59,103.09 181.59,96.74 186.47,91.86 186.47,87.12 177.78,78.44 177.78,71.63 179.23,70.19 180.48,70.19 180.62,70.33 185.02,70.33 190.61,64.74 190.61,62.95 192.12,61.44 v2(192.63,61.44)
  IN3 w0.089: 198.34,42.08 198.34,41.85 199.03,41.17 200.31,41.17 200.55,40.93 200.55,40.15 201.55,39.15 201.55,38.25 202.36,37.44 202.36,36.54 202.75,36.14 202.75,32.65 200.98,30.88 200.98,28.85 201.79,28.05 201.79,25.44 202.86,24.37 202.86,23.88 203.38,23.36 204.32,23.36 205.26,22.42 207.99,22.42 208.52,21.9 208.52,21.32 208.98,20.86 209.62,20.86 209.88,21.11 210.27,21.11 210.7,20.68 210.7,20.38 211.01,20.07 211.91,20.07 v2(212.17,19.81)
  IN3 w0.102: v2(192.63,61.44) 192.58,61.38 192.58,53.17 198.34,47.4 198.34,42.08
  BOTTOM w0.089: v2(212.17,19.81) 212.16,19.81 211.65,19.3 211.65,18.53 UH1.AT44
  BOTTOM w0.102: v2(222.28,158.93) 223.3,158.93 223.61,159.24 223.61,160.04 224.23,160.66 224.68,160.66 227.13,163.11 QX2.3
DPSNK_RBIAS: length 2.6
  TOP w0.089: UT1.Y18 v2(183.26,161.2)
  BOTTOM w0.102: v2(183.26,161.2) 183.26,160.9 v1(183.93,160.23)
  BOTTOM w0.107: RT19.1 183.88,161.83 v2(183.26,161.2)
DPSRC_RBIAS: length 1.4
  TOP w0.102: v2(178.7,163.81) UT1.N6
  BOTTOM w0.127: RT5.1 178.6,163.81 v2(178.7,163.81)
EAP: length 2.6
  BOTTOM w0.203: PR6018.2 270.79,140.43 271.66,140.43 272.42,139.67 PU6000.29
EAPD#: length 9.2
  TOP w0.107: v2(33.9,35.89) 34.21,35.58 v1(34.58,35.58) 34.82,35.58 35.25,36.01 35.25,39.04 DA3.2
  BOTTOM w0.107: UA1.52 33.22,35.52 RA22.1 33.64,36.44 RA21.2 33.73,36.06 v2(33.9,35.89)
EC_AC_BAT#: length 260.3
  TOP w0.089: v2(222.07,111.95) 222.07,112.28 RG16.1
  TOP w0.102: v1(334.69,41.88) 334.52,42.05 v2(334.52,42.45) UE6.9
  IN6 w0.102: v2(334.52,42.45) 334.52,43.92 328.12,50.32 322.61,50.32 321.1,51.84 321.1,55.08 320.7,55.48 316.76,55.48 316.06,56.18 312.54,56.18 312.13,56.59 310.88,56.59 309.88,57.59 298.04,57.59 296.63,56.17 296.63,50.71 293.53,47.62 277.55,47.62 276.71,48.47 273.43,48.47 272.34,49.56 260.49,49.56 259.42,48.5 249.83,48.5 248.92,49.41 241.13,49.41 240.55,48.84 233.4,48.84 232.11,50.13 227.89,50.13 227.11,50.9 220.23,50.9 219.96,51.17 213.37,51.17 212.33,52.21 212.33,54.65 209.76,57.22 209.76,64.17 207.6,66.34 191.89,66.34 188.59,69.64 183.14,69.64 182.39,70.39 182.39,70.89 186.46,74.95 186.46,93.28 186.17,93.57 186.17,98.36 187.75,99.94 188.91,99.94 191.02,102.05 207.25,102.05 209.74,104.54 213.62,104.54 216.86,107.78 216.86,109.62 217.33,110.09 217.92,110.09 219.41,111.58 221.7,111.58 v2(222.07,111.95)
  BOTTOM w0.1: UG9.BE6 v2(222.07,111.95)
EC_ESB_CLK: length 72.1
  TOP w0.102: v2(330.21,39.85) 330.04,40.02 UE6.1 ; UE10.1 316.26,55.3 v2(315.89,54.93) ; RE642.2 299.03,25.8 v2(299.03,25.22) 298.97,25.15 298.97,24.87 298.97,24.78 299.14,24.61 UE5.17
  IN2 w0.102: v2(330.21,39.85) 330.03,40.02 328.74,40.02 327.9,39.19 322.9,39.19 321.68,37.98 321.68,34.48 318.19,30.99 311.51,30.99 306.54,26.03 299.54,26.03 298.95,25.44 298.95,25.3 v2(299.03,25.22)
  BOTTOM w0.102: v2(315.89,54.93) 316.56,55.59 318.98,55.59 319.5,55.07 319.5,52.24 319.67,52.08 319.67,51.27 320.74,50.2 v1(323.17,50.2) 328.43,50.2 329.13,49.5 329.13,41.87 330.21,40.79 v2(330.21,39.85)
EC_ESB_DAT: length 70.1
  TOP w0.102: RE643.2 298.27,25.35 v2(298.4,25.22) 298.4,25.11 298.74,24.77 UE5.18 ; v2(331.86,39.85) 331.54,40.17 UE6.4 ; v2(317.7,54.83) 317.7,54.96 317.76,55.02 UE10.4
  IN2 w0.102: v2(298.4,25.22) 299.44,26.26 306.45,26.26 311.41,31.22 318.1,31.22 321.45,34.58 321.45,38.07 322.8,39.42 327.81,39.42 328.64,40.25 331.45,40.25 v2(331.86,39.85)
  IN6 w0.102: v2(317.7,54.83) 318.46,54.07 319.79,54.07 320.87,52.99 320.87,51.74 322.52,50.1 326.53,50.1 328.56,48.06 328.56,45.94 329.83,44.67 329.83,43.14 331.86,41.11 v2(331.86,39.85)
EC_MUTE#: length 350.9
  TOP w0.102: UE10.11 320.38,58.44 320.89,57.93 320.89,52.17 v1(320.65,51.93) 320.48,51.76 319.16,51.76 318.44,52.48 315.79,52.48 315.55,52.72 314.45,52.72 v2(313.89,52.17)
  TOP w0.107: v2(35.79,38.83) DA3.3
  IN2 w0.102: v2(35.79,38.83) 35.79,42.75 38.93,45.9 48.42,45.9 49.87,44.44 52.87,44.44 53.13,44.18 54.42,44.18 55.07,44.83 57.67,44.83 58.58,45.74 61.56,45.74 62.27,45.03 93.26,45.03 93.98,44.3 96.44,44.3 96.62,44.48 98.5,44.48 100.52,42.46 108.65,42.46 112.66,38.45 130.89,38.45 133.81,35.53 179.29,35.53 186.17,42.4 203.45,42.4 203.58,42.27 204.36,42.27 205.53,43.45 210.95,43.45 211.18,43.22 212.93,43.22 213.31,43.59 214.62,43.59 215.03,43.18 220.3,43.18 224.32,39.16 230.17,39.16 230.79,39.78 231.84,39.78 233.28,41.22 238.31,41.22 239.07,40.46 240.16,40.46 240.95,39.67 244.27,39.67 244.94,40.33 266.44,40.33 276.15,30.61 279.54,30.61 283.35,26.8 289.76,26.8 294.8,21.76 296.76,21.76 298.14,23.13 305.11,23.13 305.79,23.82 307.46,23.82 307.64,24 308.14,24 308.65,24.5 308.65,25.33 309.36,26.04 312.45,26.04 v2(313.12,25.37)
  IN3 w0.102: v2(313.89,52.17) 313.06,51.34 313.06,47.59 310.88,45.41 310.88,36.95 311.76,36.07 311.76,33.78 313.12,32.41 v2(313.12,25.37)
EC_ON: length 279.8
  TOP w0.102: v2(59.36,45.34) 58.88,45.34 58.3,44.76 58.3,44.23 v1(58.07,44)
  TOP w0.107: UE5.112 305.2,15.81 304.86,15.47 304.86,14.92 304.93,14.85 304.93,14.14 304.69,13.91 304.12,13.91 303.23,14.79 301.27,14.79 300.81,15.24 300.81,16.78 300.48,17.11 299.79,17.11 299.4,17.5 299.4,20.34 300.14,21.08 v2(300.14,21.94)
  TOP w0.254: PD100.2 59.1,45.89 59.36,45.64 v2(59.36,45.34)
  IN2 w0.102: v2(300.14,21.94) 299.62,22.46 297.86,22.46 296.94,21.53 294.7,21.53 289.66,26.57 283.26,26.57 279.45,30.38 276.06,30.38 266.34,40.1 245.03,40.1 244.37,39.44 240.85,39.44 240.59,39.71 236.38,39.71 235.3,40.79 233.17,40.79 231.94,39.55 230.89,39.55 230.27,38.93 224.23,38.93 220.21,42.95 214.93,42.95 214.52,43.36 213.4,43.36 213.03,42.99 211.09,42.99 210.86,43.22 205.62,43.22 204.49,42.08 203.5,42.08 203.4,42.18 186.26,42.18 179.39,35.3 133.71,35.3 130.79,38.22 112.57,38.22 108.56,42.23 95.73,42.23 95.2,42.77 92.72,42.77 91.51,43.97 88.68,43.97 87.9,44.76 62.22,44.76 61.64,45.34 v2(59.36,45.34)
EC_RSMRST#: length 126.8
  TOP w0.089: RH88.2 213.06,35.87 v2(213.77,35.17) 213.77,35.02 v1(213.39,34.65)
  TOP w0.107: UE5.100 304.63,11.01 v2(301.76,13.89)
  IN3 w0.127: v2(301.76,13.89) 301.91,13.74 302.68,13.74 303.04,14.1 303.04,14.88 303.43,15.26 303.43,19.15 302.75,19.83 302.75,22.53 300.55,24.73 300.13,24.73 294.66,24.73 294.01,25.38 292.54,25.38 289.04,28.88 281.42,28.88 280.45,29.85 277.05,29.85 276.16,30.74 271.92,30.74 271.4,30.22 265.5,30.22 264.98,30.74 258.36,30.74 257.65,30.03 244.68,30.03 240.81,26.16 238.65,26.16 237.35,24.86 236.04,24.86 235.4,24.23 235.4,23.53 235.17,23.3 233.89,23.3 233.03,24.16 231.22,24.16 228.55,26.83 228.55,30.45 227.4,31.59 226.39,31.59 v2(224.94,33.04)
  IN6 w0.081: 219.56,33.75 216.61,33.75 215.59,34.77 214.17,34.77 v2(213.77,35.17)
  IN6 w0.102: v2(224.94,33.04) 225.15,33.26 225.15,33.78 224.84,34.1 224.06,34.1 223.11,33.15 220.16,33.15 219.56,33.75
  BOTTOM w0.089: v2(213.77,35.17) 214.27,34.67 UH1.BA11
  BOTTOM w0.102: v2(224.94,33.04) 225.34,33.45 DE2.2
EC_RTCRST: length 5.1
  TOP w0.102: v1(287.93,20.2) QE5.2 288.66,21.47 288.81,21.32 RE650.1 289.77,21.81 UE5.34
EC_RX: length 70.7
  TOP w0.107: v2(294.37,11.18) 294.37,14.35 295.09,15.07 295.09,18.95 294.7,19.33 294.7,21.82 293.54,22.99 UE5.31 293.54,24.75 294.2,25.41 294.2,27.43 292.58,29.05 v1(292.58,32.18) 292.58,32.81 289.76,35.64 v2(289.76,36.71)
  IN1 w0.102: v2(289.76,36.71) 289.76,38.57 290.2,39.02 298.54,39.02 299.94,40.42 304.67,40.42 305.9,41.65 308.5,41.65 v2(309.7,42.85)
  BOTTOM w0.107: JEC.7 283.71,11.44 283.22,10.95 283.22,8.29 283.68,7.83 285.22,7.83 286.41,9.02 290.93,9.02 292.62,10.71 293.89,10.71 v2(294.37,11.18) ; v2(309.7,42.85) 310.11,42.44 310.11,42.13 310.07,42.09 JWLAN.32
EC_SCI#: length 125.1
  TOP w0.089: v2(212.54,26.45) 212.84,26.15 212.84,23.84 212.43,23.43 212.03,23.43 210.8,22.19 v1(210.28,22.19) 209.84,22.19 209.59,21.94 208.79,21.94 208.54,22.19 206.78,22.19 RH521.2
  TOP w0.107: v2(297.25,13.81) 297.06,14 297.06,21.56 297.94,22.44 UE5.20
  IN2 w0.089: v2(212.54,26.45) 212.95,26.04 215.44,26.04 216.28,26.89 216.73,26.89 217.89,28.05 219.18,28.05
  IN2 w0.102: 219.18,28.05 219.5,28.05 220.94,26.61 221.78,26.61 224.29,24.1 224.29,23.14 225.01,22.42 225.01,21.89 226.7,20.2 226.7,19.39 227.63,18.47 228.14,18.47 229.91,16.71 235.02,16.71 235.35,16.38 245.33,16.38 246.89,17.95 246.89,19.94 246.4,20.43 246.4,22.51 248.15,24.25 256.04,24.25 256.71,23.58 256.71,23.08 259.78,20.01 264.63,20.01 265.98,18.66 267.65,18.66 267.76,18.55 275.59,18.55 279.72,14.42 291.26,14.42 291.86,13.81 v2(297.25,13.81)
  BOTTOM w0.089: v2(212.54,26.45) 212.83,26.16 212.83,25.69 UH1.AV29
EC_SMB_CK1: length 280.3
  TOP w0.114: v2(297.65,10.13) 297.82,9.95 297.82,9.61 298.01,9.42 298.01,9.13 297.94,9.06 UE5.77 297.94,6.87 297.82,6.75 RE90.4 ; PR721.1 52.61,21.43 52.28,21.43 v2(52.14,21.29) ; v2(83.98,18.07) 83.84,17.92 83.84,17.16 83.52,16.85 83.52,14.86 PD2.2 83.9,14.41 83.52,14.04 83.52,13.92 83.27,13.68 82.38,13.68 82.19,13.48 82.19,13.04 PR19.2
  IN1 w0.081: v2(297.65,10.13) 297.5,10.13 297.42,10.21 297.42,10.44 297.5,10.52 297.94,10.52 298.02,10.61 298.02,10.93 297.68,11.27 296.45,11.27 295.26,12.46 292.81,12.46 291.61,13.66 273.09,13.66 271.86,12.43 269.78,12.43 268.83,11.49 255.35,11.49 254.58,12.26 242.35,12.26 240.41,10.32 229.72,10.32 229.41,10.02 212.95,10.02 212.62,9.69 207.81,9.69 206.41,8.29 192.94,8.29 192.32,8.9 186.32,8.9 186.19,9.03 186.18,9.03 174.88,20.33 130.46,20.33 130.33,20.2 130.33,20.06 130.48,19.91 v2(130.51,19.91)
  IN6 w0.081: v2(52.14,21.29) 52.32,21.47 52.99,21.47 56.4,18.07 58.64,18.07 59.68,17.03 59.68,15.06 62.12,12.62 72.92,12.62 74.9,14.6 81.54,14.6 83.98,17.04 v2(83.98,18.07) 83.8,18.25 83.8,18.41 84.55,19.16 91.46,19.16 93.8,16.82 124.96,16.82 127.26,19.11 129.96,19.11 130.32,19.48 130.32,19.72 v2(130.51,19.91)
EC_SMB_CK2: length 434.5
  TOP w0.114: RE90.2 298.82,6.67 298.74,6.75 UE5.79 298.74,9.09 298.82,9.16 298.82,14.19 298.09,14.92 298.09,18.86 298.4,19.17 298.4,20.1 298.28,20.21 298.06,20.21 v2(297.94,20.09)
  IN1 w0.081: v2(297.94,20.09) 297.77,20.27 281.65,20.27 279.54,22.38 272.96,22.38 270.85,24.49 267.18,24.49 266.3,23.6 264.57,23.6 264.28,23.89 261.82,23.89 260.04,22.11 257.48,22.11 255.95,23.64 248.57,23.64 246.55,21.62 246.55,17.33 245.64,16.42 240.63,16.42 237.59,13.37 228.58,13.37 228.18,12.98 220.01,12.98 219.24,13.75 217.41,13.75 216.64,12.98 211.72,12.98 211.4,12.65 206.22,12.65 205.66,12.09 v2(205.66,12.09) 205.58,12.02 204.95,12.02 204.72,12.25 204.72,12.58 204.72,12.58 204.72,12.65 204.82,12.75 204.82,13.11 204.62,13.31 202.18,13.31 200.8,11.93 194.3,11.93 190.08,16.14 186.26,16.14 183.37,19.03 183.37,20.59 183.13,20.83 183.13,25.88 182.69,26.32 v2(182.39,26.32) ; v2(205.13,151.16) 204.91,150.95 204.25,150.95 203.59,151.61 203.59,153 202.21,154.38 202.21,158.07 200.03,160.24 199.08,160.24 198.32,161 198.32,164.2 198.85,164.73 199.89,164.73 200.48,165.32 200.48,165.8 201.21,166.53 201.21,167.13 200.26,168.07 197.64,168.07 196.13,169.58 190.13,169.58 188.69,171.02 188.69,171.99 187.39,173.29 183.34,173.29 182.25,174.37 180.71,174.37 180.14,174.94 175.75,174.94 175.4,174.59 171.08,174.59 170.02,173.53 165.7,173.53 164.76,172.59 164.76,170.06 164.08,169.39 162.38,169.39 161.68,170.09 158.01,170.09 157.87,169.94 156.28,169.94 155.79,170.42 152.04,170.42 151.72,170.1 149.24,170.1 145.92,166.78 145.92,161.29 142.73,158.1 138.86,158.1 138.17,157.41 138.17,156.51 138.37,156.31 138.68,156.31 v2(138.82,156.17)
  IN3 w0.127: v2(182.39,26.32) 182.39,26.63 182.1,26.92 182.1,30.48 184.21,32.6 184.21,52.8 182.44,54.57 182.44,58.02 181.72,58.75 181.72,63.33 181.36,63.68 181.36,68.58 183.76,70.97 183.76,87.4 184.81,88.45 184.81,93.11 184.47,93.45 184.47,98.83 184.66,99.02 184.66,104.52 192.41,112.27 192.41,113.99 193.72,115.3 195.68,115.3 196.24,115.86 198.62,115.86 199.56,116.8 199.56,120.9 200.43,121.76 200.88,121.76 201.81,122.69 201.81,123.52 202.43,124.13 204.92,126.63 204.92,127.01 205.27,127.36 205.27,128.99 205.04,129.22 205.04,132.55 205.73,133.24 205.73,136.46 205.31,136.88 205.31,141.47 203.72,143.07 203.72,150.44 204.25,150.97 204.94,150.97 v2(205.13,151.16)
  BOTTOM w0.114: UM8.50 137.51,156.18 137.7,156.37 138.61,156.37 v2(138.82,156.17) ; U2407.10 185.89,40.37 183.78,38.26 183.78,31.59 181.89,29.7 181.89,29.18 181.89,28.85 181.89,26.99 182.38,26.5 182.39,26.5 v2(182.39,26.32) ; QH5.1 211,15.48 211.23,15.26 211.23,14.02 210.89,13.68 209.67,13.68 209.57,13.58 209.57,13.37 209.32,13.11 206.55,13.11 205.66,12.22 v2(205.66,12.09) ; QG6.3 207.26,148.61 207.71,149.06 207.71,150.85 207.23,151.33 206.47,151.33 206.31,151.16 v2(205.13,151.16) 205.13,151.57 205.81,152.25 RT60.1
EC_SMB_DA1: length 280.2
  TOP w0.114: v2(83.4,18.07) 83.6,17.87 83.6,17.26 83.28,16.95 83.28,14.86 PD2.3 83.28,14.1 83.28,14.02 83.17,13.92 82.28,13.92 81.94,13.58 81.94,13.09 PR21.2 ; v2(298.23,10.13) 298.08,9.97 298.08,9.97 298.08,9.96 298.08,9.96 298.07,9.94 298.07,9.71 298.25,9.52 298.25,9.19 298.34,9.1 UE5.78 298.34,6.75 298.32,6.73 RE90.3 ; v2(52.14,21.88) 52.35,21.67 52.58,21.67 PR720.1
  IN1 w0.081: v2(298.23,10.13) 298.23,11.01 297.77,11.48 296.53,11.48 295.35,12.66 292.9,12.66 291.69,13.87 273,13.87 271.77,12.64 269.69,12.64 268.75,11.7 255.44,11.7 254.67,12.47 242.26,12.47 240.32,10.53 229.63,10.53 229.32,10.23 212.86,10.23 212.53,9.89 207.72,9.89 206.32,8.5 193.03,8.5 192.41,9.11 186.41,9.11 186.28,9.24 186.27,9.24 174.96,20.54 130.37,20.54 130.12,20.28 130.12,20.05 129.98,19.91 v2(129.93,19.91)
  IN6 w0.081: v2(52.14,21.88) 52.34,21.68 53.08,21.68 56.48,18.27 58.73,18.27 59.89,17.11 59.89,15.14 62.21,12.83 72.84,12.83 74.82,14.81 81.46,14.81 83.78,17.12 83.78,17.69 v2(83.4,18.07) 83.58,18.25 83.58,18.49 84.46,19.37 91.54,19.37 93.89,17.02 124.87,17.02 127.17,19.32 129.87,19.32 130.12,19.56 130.12,19.72 v2(129.93,19.91)
EC_SMB_DA2: length 426.4
  TOP w0.114: v2(297.94,20.68) 298.17,20.45 298.38,20.45 298.64,20.2 298.64,19.07 298.33,18.76 298.33,15.02 299.06,14.29 299.06,9.16 299.14,9.08 UE5.80 299.14,8.18 299.14,6.89 299.32,6.71 RE90.1
  IN1 w0.081: v2(205.13,150.53) 204.91,150.74 204.16,150.74 203.38,151.52 203.38,152.92 202,154.3 202,157.98 199.95,160.03 199,160.03 198.11,160.92 198.11,164.29 198.76,164.94 199.8,164.94 200.27,165.41 200.27,165.89 201,166.61 201,167.04 200.18,167.86 197.56,167.86 196.05,169.37 190.04,169.37 188.48,170.93 188.48,171.9 187.3,173.08 183.25,173.08 182.16,174.16 180.63,174.16 180.06,174.74 175.83,174.74 175.48,174.39 171.16,174.39 170.11,173.33 165.79,173.33 164.97,172.51 164.97,169.98 164.17,169.18 162.29,169.18 161.59,169.88 158.1,169.88 157.95,169.73 156.19,169.73 155.71,170.21 152.13,170.21 151.81,169.89 149.33,169.89 146.13,166.69 146.13,161.2 142.82,157.89 138.95,157.89 138.38,157.32 138.38,156.6 138.46,156.51 138.58,156.51 v2(138.82,156.75) ; v2(297.94,20.68) 297.74,20.48 281.73,20.48 279.62,22.59 273.04,22.59 270.94,24.7 267.1,24.7 266.21,23.81 264.65,23.81 264.36,24.1 261.74,24.1 259.96,22.32 257.56,22.32 256.04,23.84 248.48,23.84 246.35,21.71 246.35,17.41 245.56,16.62 240.54,16.62 237.5,13.58 228.49,13.58 228.1,13.19 220.1,13.19 219.33,13.96 217.32,13.96 216.55,13.19 211.63,13.19 211.31,12.86 206.14,12.86 205.79,12.52 205.22,12.52 v2(205.11,12.41) 205.03,12.5 205.03,13.2 204.7,13.52 202.1,13.52 200.71,12.14 194.38,12.14 190.17,16.35 186.35,16.35 183.58,19.12 183.58,20.68 183.34,20.92 183.34,25.96 182.8,26.5 v2(182.8,26.73)
  IN3 w0.127: v2(182.8,26.73) 182.65,26.73 182.35,27.03 182.35,30.38 184.47,32.49 184.47,52.91 182.7,54.68 182.7,58.13 181.97,58.85 181.97,63.43 181.62,63.79 181.62,68.47 184.01,70.86 184.01,87.29 185.06,88.34 185.06,93.22 184.72,93.56 184.72,98.72 184.91,98.91 184.91,104.41 192.67,112.17 192.67,113.88 193.83,115.04 195.78,115.04 196.34,115.6 198.73,115.6 199.82,116.69 199.82,120.79 200.53,121.51 200.99,121.51 202.07,122.59 202.07,123.41 205.18,126.52 205.18,126.91 205.52,127.25 205.52,129.09 205.29,129.33 205.29,132.44 205.98,133.13 205.98,136.57 205.57,136.98 205.57,141.57 203.97,143.17 203.97,150.34 204.35,150.72 204.94,150.72 v2(205.13,150.53)
  BOTTOM w0.114: v2(205.11,12.41) 205.37,12.41 205.46,12.5 205.6,12.5 206.45,13.35 209.22,13.35 209.33,13.47 209.33,13.65 208.8,14.18 QH5.4 ; U2407.9 186.39,40.53 184.02,38.16 184.02,31.49 182.13,29.6 182.13,29.18 182.13,28.85 182.13,27.09 182.49,26.73 v2(182.8,26.73) ; v2(138.82,156.75) 138.68,156.61 137.57,156.61 137.51,156.68 UM8.49 ; QG6.6 205.38,149.91 205.49,150.02 205.49,150.34 205.3,150.53 v2(205.13,150.53) 204.61,151.05 RT59.1
