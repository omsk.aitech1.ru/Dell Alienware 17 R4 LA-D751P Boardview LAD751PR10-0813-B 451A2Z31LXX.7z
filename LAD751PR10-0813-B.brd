# Allegro board LAD751PR10-0813-B.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PR574  4.7_0603_1%  [R_0603]  178.35 147.69 270 bottom
PR575  10_1206_5%  [R_1206]  175.46 137.89 0 top
PR576  0_0402_5%  [R0402_0OHM]  175.16 147.3 270 bottom
PR577  3.65K_0603_1%  [R_0603]  175.27 136.23 0 top
PR578  100K_0402_1%  [R_0402]  176.1 135.1 180 top
PR579  10_0402_1%  [R_0402]  176.09 133.25 90 top
PR580  100K_0402_1%  [R_0402]  175.14 133.25 90 top
PR581  100K_0402_1%  [R_0402]  174.25 133.25 90 top
PR582  20M_0402_5%  [R_0402]  187.2 132.1 90 top
PR583  4.7_0603_1%  [R_0603]  145.66 150.96 270 bottom
PR584  4.7_1206_5%  [R_1206]  142.56 141.07 0 top
PR585  0_0402_5%  [R0402_0OHM]  142.47 150.56 270 bottom
PR586  3.65K_0603_1%  [R_0603]  142.47 139.44 0 top
PR587  100K_0402_1%  [R_0402]  143.31 138.38 180 top
PR588  10_0402_1%  [R_0402]  143.32 136.59 90 top
PR589  100K_0402_1%  [R_0402]  142.34 136.58 90 top
PR590  0_0402_5%  [R0402_0OHM]  141.58 150.56 270 bottom
PR591  0_0402_5%  [R0402_0OHM]  149.91 150.59 270 bottom
PR592  4.7_0603_1%  [R_0603]  154 150.98 270 bottom
PR593  4.7_1206_5%  [R_1206]  151.2 141.07 0 top
PR594  0_0402_5%  [R0402_0OHM]  150.8 150.59 270 bottom
PR595  3.65K_0603_1%  [R_0603]  150.58 139.4 0 top
PR596  100K_0402_1%  [R_0402]  151.4 138.34 180 top
PR597  10_0402_1%  [R_0402]  151.42 136.58 90 top
PR598  100K_0402_1%  [R_0402]  150.47 136.58 90 top
PR599  10K_0402_1%  [R_0402]  157.34 144.15 270 top
PR700  1M_0402_1%  [R_0402]  63.56 31.84 90 top
PR701  3M_0402_5%  [R_0402]  64.5 32.74 270 top
PR702  0.005_2512_1%  [R_2512_4P]  58.75 42.32 180 bottom
PR703  0_0402_5%  [R0402_0OHM]  59.63 27.23 270 top
PR704  0_0402_5%  [R0402_0OHM]  60.51 27.23 270 top
PR705  4.12K_0603_1%  [R_0603]  57.07 27.6 270 top
PR706  4.12K_0603_1%  [R_0603]  58.29 27.6 270 top
PR707  10_1206_1%  [R_1206]  62.02 18.71 90 bottom
PR708  2.2_0603_5%  [R_0603]  62.81 21.69 180 top
PR709  20K_0402_1%  [R_0402]  59.25 18.59 270 top
PR710  5.11K_0402_1%  [R_0402]  63.64 16.91 90 top
PR711  3.16K_0402_1%  [R_0402]  60.14 18.59 270 top
PR712  0.01_1206_1%  [R_1206_4P-D]  79.83 26.32 270 bottom
PR713  4.7_1206_5%  [R_1206]  67.38 19.59 180 top
PR714  100K_0402_1%  [R_0402]  56.04 27.04 270 top
PR715  120K_0402_5%  [R_0402]  57.24 24.86 270 bottom
PR716  324K_0402_1%  [R_0402]  55.16 27.04 270 top
PR717  0_0402_5%  [R0402_0OHM]  53.88 25.62 180 top
PR718  10K_0402_1%  [R_0402]  56.14 18.65 270 top
PR719  49.9K_0402_1%  [R_0402]  55.32 24.87 270 bottom
PR720  0_0402_5%  [R0402_0OHM]  52.91 22.01 0 top
PR721  0_0402_5%  [R0402_0OHM]  52.92 21.12 0 top
PR722  10_0402_1%  [R_0402]  58.37 18.59 270 top
PR723  10_0402_1%  [R_0402]  57.48 18.59 270 top
PR724  0_0402_5%  [R_0402]  52.91 22.89 0 top
PR725  4.7_0402_5%  [R_0402]  67.26 33.37 0 top
PR726  4.7_0402_5%  [R_0402]  66.21 40.56 0 top
PR727  0_0402_5%  [R0402_0OHM]  55.25 17.74 90 top
PR728  0_0402_5%  [R_0402]  56.27 22.56 180 bottom
PR729  1M_0402_1%  [R_0402]  122.32 76.17 180 top
PR730  1M_0402_1%  [R_0402]  120.79 79.71 0 top
PR731  200K_0402_1%  [R_0402]  117.75 76.92 90 top
PR732  3.3K_0402_1%  [R_0402]  118.63 76.92 90 top
PR733  10K_0402_1%  [R_0402]  79.89 27.4 180 top
PR734  10_0402_1%  [R_0402]  78.9 29.39 270 top
PR801  0_0402_5%  [R_0402]  238.08 40.74 180 bottom
PR802  1M_0402_1%  [R_0402]  238.08 38.96 180 bottom
PR803  4.7_0603_5%  [R_0603]  247.24 44.16 0 bottom
PR804  21.5K_0402_1%  [R_0402]  237.17 42.51 0 bottom
PR805  31.6K_0402_1%  [R_0402]  238.08 41.62 180 bottom
PR806  0_0603_5%  [R_0603]  247.24 41.75 0 bottom
PR807  0_0402_5%  [R0402_0OHM]  224.04 38.56 90 bottom
PR808  1M_0402_1%  [R_0402]  225.05 38.56 90 bottom
PR809  4.7_0603_5%  [R_0603]  232.1 43.85 0 bottom
PR810  20K_0402_1%  [R_0402]  221.43 42.53 270 bottom
PR811  10K_0402_1%  [R_0402]  223.47 41.61 90 bottom
PR812  0_0402_5%  [R_0402]  238.08 41.94 180 top
PR813  0_0402_5%  [R0402_0OHM]  237.17 41.05 0 top
PR814  0_0402_5%  [R_0402]  226.08 41.24 180 bottom
PR815  0_0402_5%  [R0402_0OHM]  225.17 40.35 0 bottom
PR816  0_0603_5%  [R_0603]  232.67 41.05 0 bottom
PR820  10K_0402_5%  [R_0402]  228.55 37.26 270 bottom
PR821  10K_0402_5%  [R_0402]  241.26 39.08 180 top
PR823  0_0402_5%  [R_0402]  210.89 157.88 90 top
PR1300  100K_0402_1%  [R_0402]  97.52 49.71 270 bottom
PR1301  0_0402_5%  [R0402_0OHM]  98.34 50.71 90 bottom
PR1302  1M_0402_1%  [R_0402]  99.23 50.71 90 bottom
PR1304  21.5K_0402_1%  [R_0402]  101.17 42.17 180 bottom
PR1305  10K_0402_1%  [R_0402]  99.35 42.16 180 bottom
PR5001  0_0402_5%  [R0402_0OHM]  180.6 144.93 90 bottom
PR5002  4.7_1206_5%  [R_1206]  185.33 133.58 90 top
PR5003  3.65K_0603_1%  [R_0603]  184.83 132.31 0 top
PR5004  1_0402_5%  [R_0402]  167.7 146.36 90 bottom
PR5005  1_0603_5%  [R_0603]  185.17 146.15 270 bottom
PR5006  0_0402_5%  [R0402_0OHM]  181.49 145.84 270 bottom
PR5007  0_0402_5%  [R0402_0OHM]  125.5 116.81 180 bottom
PR5008  1M_0402_1%  [R_0402]  124.58 118.59 0 bottom
PR5009  4.7_1206_5%  [R_1206]  121.04 110.33 180 bottom
PR5010  0_0603_5%  [R_0603]  118.31 114.78 270 bottom
PR5011  10K_0402_1%  [R_0402]  166.81 142.77 180 top
PR5012  21K_0402_1%  [R_0402]  121.19 121.07 90 bottom
PR5014  10_0402_1%  [R_0402]  122.11 121.99 270 bottom
PR5015  35.7K_0402_1%  [R_0402]  120.31 121.97 270 bottom
PR5016  10K_0402_5%  [R_0402]  122.77 120.17 270 bottom
PR5017  0_0402_5%  [R0402_0OHM]  123.31 121.13 0 bottom
PR5018  0_0402_5%  [R0402_0OHM]  123.31 122.02 0 bottom
PR5019  10K_0402_1%  [R_0402]  174.02 144.19 270 top
PR5020  1_0402_5%  [R_0402]  176.05 146.38 90 bottom
PR5021  10K_0402_1%  [R_0402]  141.33 147.45 270 top
PR5022  1_0402_5%  [R_0402]  143.36 149.65 90 bottom
PR5023  10K_0402_1%  [R_0402]  149.66 147.47 270 top
PR5024  1_0402_5%  [R_0402]  151.69 149.67 90 bottom
PR5025  1_0402_5%  [R_0402]  182.38 144.93 90 bottom
PR5026  1_0402_5%  [R_0402]  182 143.36 270 top
PR5027  10_0402_1%  [R_0402]  187.51 132.31 180 bottom
PR5028  1_0402_5%  [R_0402]  157.3 142.36 0 top
PR5029  1_0402_5%  [R_0402]  165.91 141.9 270 top
PR5030  1_0402_5%  [R_0402]  174.87 142.42 180 top
PR5031  1_0402_5%  [R_0402]  142.22 145.66 180 top
PR5032  1_0402_5%  [R_0402]  150.55 145.71 180 top
PR5033  0_0402_5%  [R_0402]  124.58 114.84 0 bottom
PR5034  0_0402_5%  [R0402_0OHM]  125.5 115.79 180 bottom
PR6000  10K_0402_5%  [R_0402]  267.28 141.5 90 bottom
PR6001  20K_0402_1%  [R_0402]  265.11 137.7 0 bottom
PR6002  20K_0402_1%  [R_0402]  265.11 135.86 0 bottom
PR6003  20K_0402_1%  [R_0402]  265.11 133.95 0 bottom
PR6004  20K_0402_1%  [R_0402]  265.11 132.07 0 bottom
PR6005  0_0402_5%  [R0402_0OHM]  268.89 137.64 90 bottom
PR6006  91K_0402_1%  [R_0402]  266.39 142.41 270 bottom
PR6007  12.4K_0402_1%  [R_0402]  269.76 138.53 0 bottom
PR6008  0_0402_5%  [R_0402]  270.7 136.71 180 bottom
PR6009  0_0402_5%  [R_0402]  268.89 136.71 270 bottom
PR6010  1_0402_1%  [R_0402]  265.11 136.81 0 bottom
PR6011  1_0402_1%  [R_0402]  265.11 134.97 0 bottom
PR6012  0_0402_5%  [R_0402]  266.9 135.87 270 bottom
PR6013  1_0402_1%  [R_0402]  265.11 133.06 0 bottom
PR6014  1_0402_1%  [R_0402]  265.11 131.16 0 bottom
PR6015  0_0402_5%  [R0402_0OHM]  267.29 139.73 180 bottom
PR6016  0_0402_5%  [R0402_0OHM]  268.88 140.3 270 bottom
PR6017  2.4K_0402_1%  [R_0402]  270.66 141.19 180 bottom
PR6018  0_0402_5%  [R0402_0OHM]  269.74 140.3 0 bottom
PR6019  0_0402_5%  [R0402_0OHM]  269.74 142.97 0 bottom
PR6020  499_0402_1%  [R_0402]  269.78 135.82 0 bottom
PR6021  0_0402_5%  [R0402_0OHM]  247.99 121.38 180 top
PR6022  0_0402_5%  [R_0402]  269.76 143.91 90 bottom
PR6023  100_0402_5%  [R_0402]  248.85 121.38 0 top
PR6024  1K_0402_1%  [R_0402]  271.53 143.91 90 bottom
PR6025  0_0402_5%  [R0402_0OHM]  244.92 121.38 0 top
PR6026  2.2K_0402_1%  [R_0402]  271.65 132.18 90 bottom
PR6027  2.2K_0402_1%  [R_0402]  272.6 132.18 90 bottom
PR6028  2K_0402_1%  [R_0402]  273.57 132.73 90 bottom
PR6029  100_0402_5%  [R_0402]  244.05 121.38 180 top
PR6030  2K_0402_1%  [R_0402]  274.46 132.73 90 bottom
PR6031  0_0402_5%  [R0402_0OHM]  279.62 139.15 0 bottom
PR6032  100K_0402_5%  [R_0402]  276.23 132.73 90 bottom
PR6034  30K_0402_5%  [R_0402]  274.89 141.43 270 top
PR6035  2.2_0603_1%  [R_0603]  277.31 132.18 90 bottom
PR6036  0_0402_5%  [R_0402]  275.92 148.69 90 top
PR6037  0_0402_5%  [R_0402]  276.54 143.2 90 top
PR6038  33K_0402_5%  [R_0402]  282.73 139.12 180 bottom
PR6039  0_0402_5%  [R0402_0OHM]  276.42 143.34 90 bottom
PR6040  6.19K_0402_1%  [R_0402]  279.09 143.34 90 bottom
PR6041  0_0402_5%  [R_0402]  276.65 140.52 90 top
PR6042  100K_0402_5%  [R_0402]  277.31 144.25 270 bottom
PR6043  0_0402_5%  [R0402_0OHM]  280.56 135.6 180 bottom
PR6044  0_0402_5%  [R0402_0OHM]  278.2 144.25 270 bottom
PR6045  4.32K_0402_1%  [R_0402]  280.56 141.83 180 bottom
PR6046  43K_0402_5%  [R_0402]  279.66 131.5 270 bottom
PR6047  10K_0402_5%  [R_0402]  282.43 137.07 0 bottom
PR6048  51K_0402_5%  [R_0402]  278.44 131.5 270 bottom
PR6049  0_0402_5%  [R0402_0OHM]  280.56 136.49 180 bottom
PR6050  36K_0402_5%  [R_0402]  280.87 131.5 270 bottom
PR6051  10K_0402_5%  [R_0402]  282.43 135.22 0 bottom
PR6052  10K_0402_5%  [R_0402]  282.43 133.38 0 bottom
PR6053  16.5K_0402_1%  [R_0402]  279.65 140.94 0 bottom
PR6054  0_0402_5%  [R0402_0OHM]  280.56 137.38 180 bottom
PR6055  0_0402_5%  [R_0402]  280.56 138.27 180 bottom
PR6056  8.2K_0402_5%  [R_0402]  279.66 133.66 270 bottom
PR6057  8.2K_0402_5%  [R_0402]  280.87 133.66 270 bottom
PR6058  0_0402_5%  [R_0402]  283.35 137.95 180 bottom
PR6059  0_0402_5%  [R_0402]  283.35 136.1 180 bottom
PR6060  0_0402_5%  [R_0402]  278.44 133.66 270 bottom
PR6061  309_0402_1%  [R_0402]  281.81 140.94 0 bottom
PR6062  0_0402_5%  [R_0402]  283.35 134.26 180 bottom
PR6063  20.5K_0402_1%  [R_0402]  279.65 140.05 0 bottom
PR6064  0_0402_5%  [R_0402]  280.56 138.27 180 top
PR6065  0_0402_5%  [R_0402]  280.56 137.38 180 top
PR6066  0_0402_5%  [R_0402]  280.56 136.49 180 top
PR6067  0_0402_5%  [R_0402]  280.56 135.6 180 top
PR6068  0_0402_5%  [R_0402]  271.87 145.76 180 bottom
PR6069  10K_0402_5%  [R_0402]  280.03 148.56 90 top
PR6070  100K_0402_5%  [R_0402]  275.34 132.73 90 bottom
PR6100  0.005_2512_1%  [RL-3264-9W-R005-FNH_2512_2512]  87.41 25.36 0 top
PR6101  0.005_2512_1%  [RL-3264-9W-R005-FNH_2512_2512]  201.81 145.66 270 bottom
PR6102  0_0402_5%  [R_0402]  252.05 152.69 180 bottom
PR6103  10K_0402_1%  [R_0402]  251.15 150.9 90 bottom
PR6104  1K_0402_1%  [R_0402]  253.49 151.59 270 top
PR6105  0_0402_5%  [R_0402]  252.6 150.68 90 top
PR6106  2.2_0603_1%  [R_0603]  250.71 151.61 270 top
PR6107  0_0402_5%  [R0402_0OHM]  255.09 153.78 270 top
PR6108  2.2_0603_1%  [R_0603]  257.88 143.8 270 top
PR6109  0_0402_5%  [R_0402]  238.27 152.62 180 bottom
PR6110  10K_0402_1%  [R_0402]  237.37 150.83 90 bottom
PR6111  1K_0402_1%  [R_0402]  239.68 151.54 270 top
PR6112  0_0402_5%  [R_0402]  238.79 150.63 90 top
PR6113  2.2_0603_1%  [R_0603]  236.93 151.54 270 top
PR6114  0_0402_5%  [R0402_0OHM]  241.25 153.78 270 top
PR6115  2.2_0603_1%  [R_0603]  244.1 143.67 270 top
PR6200  0_0402_5%  [R_0402]  225.45 152.81 180 bottom
PR6201  10K_0402_1%  [R_0402]  223.59 151.28 90 bottom
PR6202  1K_0402_1%  [R_0402]  225.98 151.43 270 top
PR6203  0_0402_5%  [R_0402]  225.09 150.51 90 top
PR6204  2.2_0603_1%  [R_0603]  223.27 150.34 270 bottom
PR6205  0_0402_5%  [R0402_0OHM]  227.59 153.65 270 top
PR6206  2.2_0603_1%  [R_0603]  230.39 143.61 270 top
PR6207  0_0402_5%  [R_0402]  210.78 152.56 180 bottom
PR6208  10K_0402_1%  [R_0402]  210.02 151.54 180 bottom
PR6209  1K_0402_1%  [R_0402]  211.65 152.99 90 bottom
PR6210  0_0402_5%  [R_0402]  211.59 150.39 90 top
PR6211  2.2_0603_1%  [R_0603]  209.62 150.59 270 bottom
PR6212  0_0402_1%  [R_0402]  213.81 153.84 270 bottom
PR6213  2.2_0603_1%  [R_0603]  209.01 140.63 180 bottom
PR6400  2.2_0603_1%  [R_0603]  304.63 47.06 90 top
PR6401  0.005_2512_1%  [RL-3264-9W-R005-FNH_2512_2512]  272.29 33.3 0 bottom
PR6403  0_0402_5%  [R_0402]  308.19 55.72 180 top
PR6404  100K_0402_1%  [R_0402]  308.2 53.05 180 top
PR6405  2.2_0603_1%  [R_0603]  306.71 51.02 0 top
PR6406  0_0402_5%  [R_0402]  311.17 55.97 180 top
PR6407  2.2_0603_1%  [R_0603]  300.03 51.62 180 top
PR6408  10K_0402_5%  [R_0402]  299.74 53.75 180 top
PR6409  2.2_0603_1%  [R_0603]  289 50.78 180 top
PR6410  0_0402_5%  [R0402_0OHM]  311.17 54.04 180 top
PR6411  51.1K_0402_1%  [R_0402]  299.71 55.53 270 top
PR6412  0_0402_5%  [R0402_0OHM]  308.2 57.47 180 top
PR6413  0_0402_5%  [R_0402]  310.26 55.09 0 top
PR6414  49.9_0603_1%  [R_0603]  299.74 58.59 270 top
PR6415  10K_0402_5%  [R_0402]  297.8 57.38 0 top
PR6416  6.19K_0402_1%  [R_0402]  305.91 57.36 90 top
PR6417  4.32K_0402_1%  [R_0402]  304.98 57.35 90 top
PR6418  16.5K_0402_1%  [R_0402]  303.22 57.35 90 top
PR6419  46.4K_0402_1%  [R_0402]  302.31 58.23 270 top
PR6420  84.5K_0402_1%  [R_0402]  301.4 57.35 90 top
PR6421  0_0402_5%  [R0402_0OHM]  298.82 60.81 270 top
PR6422  0_0402_5%  [R0402_0OHM]  297.86 60.81 270 top
PR6423  309_0402_1%  [R_0402]  303.23 59.13 0 top
PR6424  2.2_0603_1%  [R_0603]  278.93 52.21 180 top
PR6425  100_0402_5%  [R_0402]  250.64 119.09 180 bottom
PR6426  20.5K_0402_1%  [R_0402]  302.45 60.27 0 top
PR6427  100_0402_5%  [R_0402]  247.98 119.09 0 bottom
PR6428  0_0402_5%  [R0402_0OHM]  306.26 48.67 0 top
PR6429  0_0402_5%  [R0402_0OHM]  307.27 52.17 0 top
PR6430  100K_0402_5%  [R_0402]  308.43 48.72 90 top
PR6431  0_0402_5%  [R0402_0OHM]  299.74 52.86 180 top
PR6432  0_0402_5%  [R0402_0OHM]  300.19 49.24 180 top
PR6433  100K_0402_5%  [R_0402]  297.67 51.4 90 top
PR6434  100K_0402_5%  [R_0402]  304.24 49.42 90 top
PR6435  100K_0402_5%  [R_0402]  302.84 49.42 90 top
PR6436  30K_0402_5%  [R_0402]  307.27 56.6 0 top
PR8200  2.2_0603_5%  [R_0603]  247.97 33.25 0 bottom
PR8201  2.2_0402_1%  [R_0402]  240.53 35.4 0 bottom
PR8202  383K_0402_1%  [R_0402]  241.45 33.62 180 bottom
PR8203  100K_0402_1%  [R_0402]  244.99 36.4 90 bottom
PR8204  4.7_1206_5%  [R_1206]  265.12 33.56 270 top
PR8205  2.2_0603_5%  [R_0603]  247.59 29.82 180 bottom
PR8206  8.66K_0402_1%  [R_0402]  248.81 32.16 180 bottom
PR8207  2.2_0603_5%  [R_0603]  246.45 37.31 270 bottom
PR8208  10K_0402_1%  [R_0402]  241.69 31.67 270 bottom
PR8209  100_0402_5%  [R_0402]  244.1 36.4 90 bottom
PR8210  4.7_1206_5%  [R_1206]  252.48 33.62 270 top
PR8211  34.8K_0402_1%  [R_0402]  241.58 33.55 180 top
PR8214  0_0402_5%  [R_0402]  238.25 28.61 0 bottom
PR8215  52.3K_0402_1%  [R_0402]  240.66 30.88 0 top
PR8216  0_0402_5%  [R0402_0OHM]  312.89 57.39 180 top
PR8217  0_0402_5%  [R_0402]  237.17 38.06 0 bottom
PR8218  68.1K_0402_1%  [R_0402]  240.66 32.66 0 top
PR8219  0_0402_5%  [R0402_0OHM]  244.04 28.85 90 top
PR8220  10K_0402_5%  [R_0402]  239.66 34.26 180 bottom
PU100  TPS51225CRUKR_QFN20_3X3  [TPS51225CRUKR_QFN20_3X3-S]  53.06 47.23 0 bottom
PU201  RT8207PGQW_WQFN20_3X3  [RT8207PGQW_WQFN20_3X3-S]  91.89 45.55 0 bottom
PU300  TPS51212DSCR_SON10_3X3  [TPS51212DSCR_SON10_3X3-S]  243.27 18.99 270 top
PU500  ISL95829HRTZ-T_TQFN48_6X6  [ISL95855HRTZ-T_TQFN48_6X6-S]  123.45 138.88 0 bottom
PU502  -  [SIC632CDT1GE3_POWERPAK31_5X5]  158.08 144.95 270 bottom
PU503  -  [SIC632CDT1GE3_POWERPAK31_5X5]  166.41 144.9 270 bottom
PU504  -  [SIC632CDT1GE3_POWERPAK31_5X5]  174.75 144.92 270 bottom
PU507  -  [SIC632CDT1GE3_POWERPAK31_5X5]  142.06 148.19 270 bottom
PU509  -  [SY8286RAC_QFN20_3X3]  120.06 115.4 0 bottom
PU510  -  [SIC632CDT1GE3_POWERPAK31_5X5]  150.39 148.21 270 bottom
PU511  -  [SIC531CDT1GE3_POWERPAK22_4X3]  182.43 143.38 270 bottom
PU700  BQ24780SRUYR_QFN28_4X4  [BQ24780RUYR_WQFN28_4X4-S]  58.64 24.28 270 top
PU800  -  [SY8286RAC_QFN20_3X3]  243.37 41.95 180 bottom
PU802  -  [SY8286RAC_QFN20_3X3]  231.17 41.38 180 bottom
PU1300  -  [RT9059GSP_SO8]  98.98 49 0 bottom
PU6000  -  [UP9511PQGJ_VQFN40_5X5]  277.96 140.07 180 bottom
PU6100  -  [SIC632CDT1GE3_POWERPAK31_5X5]  253.21 151.38 270 bottom
PU6101  -  [SIC632CDT1GE3_POWERPAK31_5X5]  239.43 151.31 270 bottom
PU6200  -  [SIC632CDT1GE3_POWERPAK31_5X5]  225.72 151.25 270 bottom
PU6201  -  [SIC632CDT1GE3_POWERPAK31_5X5]  212.06 151.25 270 bottom
PU6400  -  [UP1666QQKF_WQFN20_3X3]  304.99 52.85 180 top
PU8200  RT8812AGQW-GP  [RT8812AGQW_WQFN20_3X3-S]  245.53 31.36 180 bottom
Q7  -  [DMN65D8LDW-7_SOT363-6]  321.19 45 180 top
Q8  -  [DMN65D8LDW-7_SOT363-6]  322.54 41.05 180 top
Q9  -  [DMN65D8LDW-7_SOT363-6]  327.75 41.05 180 top
Q28  -  [DMN66D0LDW-7_SOT363-6]  112.88 22.49 0 top
Q29  -  [DMN66D0LDW-7_SOT363-6]  118.22 22.45 0 top
Q34  -  [DMN66D0LDW-7_SOT363-6]  107.74 22.49 0 top
Q2407  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  143.58 131.1 270 bottom
Q2408  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  275.73 130.8 180 top
Q2409  SI3456DDV-T1-GE3_TSOP6~D  [SI3456DDV-T1-GE3_TSOP6]  194.26 16.72 180 top
Q2410  L2N7002WT1G 1N SC-70-3  [SSM3K7002FU_SC70-3]  194.21 18.83 270 top
Q2411  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  286.14 33.12 180 bottom
QE1  -  [DMN66D0LDW-7_SOT363-6]  325.27 41.05 180 top
QE2  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  309.8 7.69 180 top
QE3  -  [DMN66D0LDW-7_SOT363-6]  326.48 44.99 180 top
QE4  -  [DMN66D0LDW-7_SOT363-6]  323.94 44.99 180 top
QE5  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  286.33 22.12 270 top
QE8  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  208.45 160.66 180 top
QE13  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  203.24 173.35 180 top
QE21  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  200.76 173.35 180 top
QE22  DMN66D0LDW-7_SOT363-6~D  [DMN66D0LDW-7_SOT363-6]  205.71 173.35 180 top
QE29  -  [MMDT3904-7-F_SOT363-6]  233.95 30.62 90 bottom
QE39  -  [MMDT3904-7-F_SOT363-6]  228.04 20.91 90 bottom
QE40  -  [MMDT3904-7-F_SOT363-6]  228.04 24.15 90 bottom
QE41  -  [MMDT3904-7-F_SOT363-6]  228.04 27.39 90 bottom
QE42  -  [MMDT3904-7-F_SOT363-6]  228.04 30.62 90 bottom
QE43  -  [MMDT3904-7-F_SOT363-6]  233.95 27.39 90 bottom
QE44  -  [MMDT3904-7-F_SOT363-6]  233.95 24.15 90 bottom
QE45  -  [MMDT3904-7-F_SOT363-6]  233.95 20.91 90 bottom
QE46  -  [MMDT3904-7-F_SOT363-6]  235.85 30.62 90 top
QE47  -  [MMDT3904-7-F_SOT363-6]  235.85 27.39 90 top
QE48  -  [MMDT3904-7-F_SOT363-6]  235.85 24.15 90 top
QE49  -  [DMN66D0LDW-7_SOT363-6]  228.02 25.45 270 top
QE50  -  [DMN66D0LDW-7_SOT363-6]  225.94 22.57 180 top
QE51  -  [DMN66D0LDW-7_SOT363-6]  228.02 28.69 270 top
QE52  -  [DMN66D0LDW-7_SOT363-6]  228.02 22.21 270 top
QE53  -  [DMN66D0LDW-7_SOT363-6]  228.02 31.92 270 top
QE54  -  [BC857BS_SOT363-6]  225.94 25.94 180 top
QE55  -  [BC857BS_SOT363-6]  225.94 29.01 180 top
QE56  -  [BC857BS_SOT363-6]  224.54 32.16 180 top
QE57  -  [DMN66D0LDW-7_SOT363-6]  271.22 34.48 0 top
QG2  -  [MESS138W-G_SOT323-3]  284.06 102.05 180 bottom
QG3  -  [MESS138W-G_SOT323-3]  284.1 67.23 180 bottom
QG4  -  [MESS138W-G_SOT323-3]  230.35 51.86 90 bottom
QG5  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  194.57 121.24 90 bottom
QG6  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  206.42 149.91 270 bottom
QG7  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  205.21 120.89 270 bottom
QG8  -  [MESS138W-G_SOT323-3]  191.73 84.62 0 bottom
QG500  -  [DMN66D0LDW-7_SOT363-6]  210.27 121.95 180 bottom
QG501  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  205.21 118.16 270 bottom
QG502  DMN53D0LDW-7_SOT363-6  [2N7002DW-7-F_SOT363-6]  212.05 156.22 0 top
QG503  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  191.33 110.32 90 top
QG504  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  188.89 105.1 0 top
QG505  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  192.58 105.1 0 top
QG506  -  [MESS138W-G_SOT323-3]  209.43 125.62 270 bottom
QG507  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  289.53 86.22 0 bottom
QG508  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  290.39 78.24 180 bottom
QG510  -  [MESS138W-G_SOT323-3]  198.23 121.59 180 bottom
QG511  -  [MESS138W-G_SOT323-3]  310.18 50.94 180 top
QH5  DMN66D0LDW-7  [DMN66D0LDW-7_SOT363-6]  210.57 15.48 270 bottom
QL3  -  [2N7002K_SOT23-3]  267.83 158.34 270 top
QM1  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  143.65 164.8 90 bottom
QM2  -  [DMN66D0LDW-7_SOT363-6]  151.45 166.42 270 bottom
QM3  LP2301ALT1G 1P SOT-23-3  [SI2301CDS-T1-GE3_SOT23-3]  154.25 163.58 180 bottom
QS3  DMN65D8LW-7_SOT323-3  [SSM3K7002FU_SC70-3]  188.54 66.39 0 top
QU1  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  295.84 61.56 0 top
QV1  -  [SI3457CDV-T1-GE3_TSOP6]  159.84 170.72 270 bottom
QV2  2N7002W-T/R7_SOT323-3  [2N7002W-T-R7_SOT323-3]  160.33 161.98 270 bottom
QV95  SSM3K7002FU_SC70-3~D  [SSM3K7002FU_SC70-3]  206.76 135.92 180 bottom
QV96  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  215.86 161.56 0 bottom
QV97  DMN53D0LDW-7 2N SOT363-6  [2N7002DW-7-F_SOT363-6]  219.58 157.54 90 top
QX1  -  [BSS138-G_SOT23-3]  220.77 163.42 90 bottom
QX2  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  227.78 167.1 0 bottom
QX3  S TR METR3904W-G NPN SOT323-3  [MMST3904-7-F_SOT323-3]  209.39 156.68 180 bottom
R2  0_0603_5%  [R0603_0OHM]  193.56 13.43 180 bottom
R144  2.2K_0402_5%  [R_0402]  111.82 21.65 90 top
R145  2.2K_0402_5%  [R_0402]  110.04 21.65 90 top
R146  2.2K_0402_5%  [R_0402]  111.82 23.55 90 top
R147  2.2K_0402_5%  [R_0402]  110.04 24.47 270 top
R150  2.2K_0402_5%  [R_0402]  116.15 24.11 270 top
R154  2.2K_0402_5%  [R_0402]  117.09 23.17 90 top
R174  10K_0402_5%  [R_0402]  64.44 17.84 270 bottom
R179  300K_0402_5%~D  [R_0402]  193 20.05 180 top
R180  1.5M_0402_5%~D  [R_0402]  193 19.15 180 top
R181  10K_0402_5%  [R_0402]  186.43 39.72 0 bottom
R182  0_0402_5%  [R_0402]  63.48 17.84 270 bottom
R184  0_0402_5%  [R0402_0OHM]  186.96 49.09 270 bottom
R185  0_0402_5%  [R0402_0OHM]  189.18 41.12 90 bottom
R307  100K_0402_1%  [R_0402]  321.32 36.85 90 top
R325  100K_0402_1%  [R_0402]  326.4 37.17 90 top
R363  10K_0201_5%  [R_0201]  327.84 31.26 0 top
R364  10K_0201_5%  [R_0201]  235.19 19.27 180 bottom
R365  10K_0201_5%  [R_0201]  274.01 7.27 0 top
R366  10K_0201_5%  [R_0201]  207.5 25.11 180 top
R367  10K_0402_5%  [R_0402]  228.75 43.01 0 top
RA1  0_0603_5%  [R0603_0OHM]  16.79 27.78 90 top
RA2  22_0402_1%  [R_0402]  37.47 27.65 0 bottom
RA3  0_0603_5%  [R0603_0OHM]  27.25 40.23 270 top
RA4  0_0603_5%  [R0603_0OHM]  25.54 16.92 270 top
RA5  0_0603_5%  [R_0603]  33.8 22.95 0 bottom
RA6  0_0603_5%  [R0603_0OHM]  28.65 33.43 0 top
RA7  0_0603_5%  [R0603_0OHM]  15.07 1.8 0 top
RA8  0_0603_5%  [R0603_0OHM]  29.17 36.79 0 top
RA9  10K_0402_5%  [R_0402]  36.6 25.1 90 top
RA10  22_0402_1%  [R_0402]  36.03 25.31 270 bottom
RA11  0_0603_5%  [R0603_0OHM]  40.79 29.94 270 top
RA12  0_0201_5%  [R_0201]  31.28 22.7 0 bottom
RA13  10K_0402_5%  [R_0402]  20.85 25.31 180 top
RA15  1K_0402_1%  [R_0402]  31.2 21.8 90 top
RA16  10K_0402_5%  [R_0402]  30.23 21.8 90 top
RA17  0_0201_5%  [R_0201]  37.74 26.25 180 bottom
RA18  22_0402_5%  [R_0402]  38.07 25.36 180 bottom
RA19  0_0201_5%  [R0201_0OHM]  35.9 35.72 180 bottom
RA21  100K_0201_1%  [R_0201]  33.73 37.03 270 bottom
RA22  1K_0402_1%  [R_0402]  32.97 35.77 90 bottom
RA24  10K_0402_5%  [R_0402]  38.39 31.46 180 top
RA25  0_0201_5%  [R0201_0OHM]  38.06 28.79 180 top
RA26  2.2K_0201_5%  [R_0201]  25.69 19.63 0 bottom
RA27  33_0402_5%  [R_0402]  37.28 34.56 90 top
RA28  2.2K_0201_5%  [R_0201]  27.68 22 0 top
RA29  33_0402_5%  [R_0402]  35.82 34.63 90 top
RA30  33_0402_5%  [R_0402]  37.28 33.61 90 bottom
RA31  33_0402_5%  [R_0402]  37.22 32.6 0 bottom
RA32  100K_0402_1%  [R_0402]  38.39 28.79 180 bottom
RA33  33_0402_5%  [R_0402]  38.55 32.59 90 top
RA34  200K_0402_1%  [R_0402]  37.47 29.68 0 top
RA35  2_0402_1%  [R_0402]  26.04 17.76 270 bottom
RA36  100K_0402_1%  [R_0402]  37.47 30.57 0 top
RA37  2_0402_1%  [R_0402]  20.02 20.67 180 top
RA38  0_0201_5%  [R0201_0OHM]  22.67 20.72 180 top
RA39  0_0201_5%  [R0201_0OHM]  19.34 21.43 0 top
RA40  2.2K_0201_5%  [R_0201]  25.37 25.11 180 top
RA41  2.2K_0201_5%  [R_0201]  25.37 26.57 180 top
RA42  8.2_0402_5%~D  [R_0402]  25.37 24.22 180 top
RA43  8.2_0402_5%~D  [R_0402]  25.37 27.52 180 top
RA44  22K_0201_5%  [R_0201]  22.75 24.99 180 top
RA45  22K_0201_5%  [R_0201]  23.52 21.94 270 top
RA46  0_0201_5%  [R0201_0OHM]  24.43 28.86 180 top
RA47  0_0201_5%  [R0201_0OHM]  22.68 26.22 90 top
RA50  1K_0402_5%  [R_0402]  40.15 10.52 180 bottom
RA51  0_0402_5%  [R0402_0OHM]  37.53 10.53 270 bottom
RA52  1K_0201_1%  [R_0201]  37.6 11.3 90 bottom
RA53  1K_0402_5%  [R_0402]  40.15 9.63 180 bottom
RA55  0_0402_5%  [R0402_0OHM]  40.45 16.31 270 top
RA56  0_0402_5%  [R0402_0OHM]  39.57 16.31 270 top
RA57  0.2_0805_1%  [R_0805]  38.17 1.78 90 bottom
RA58  39K_0402_0.1%  [R_0402]  33.34 16.31 270 top
RA59  39K_0402_0.1%  [R_0402]  32.46 16.24 270 top
RA60  0.2_0805_1%  [R_0805]  32.39 3.46 180 bottom
RA61  39K_0402_0.1%  [R_0402]  29.79 16.24 270 top
RA62  22.1K_0402_1%  [R_0402]  38.38 7.84 180 bottom
RA63  39K_0402_0.1%  [R_0402]  28.84 15.79 270 top
RA64  39K_0402_0.1%  [R_0402]  27.74 13.95 0 top
RA65  39K_0402_0.1%  [R_0402]  27.74 11.22 0 top
RA66  10K_0402_5%  [R_0402]  35.64 15.92 270 bottom
RA67  10K_0402_5%  [R_0402]  34.74 15.01 90 bottom
RA68  0_0603_5%  [R0603_0OHM]  29.22 38.51 180 bottom
RA69  0_0603_5%  [R_0603]  34.44 36.79 90 top
RA70  10K_0402_5%  [R_0402]  37.79 16.3 270 top
RA73  10_0402_1%  [R_0402]  40.21 5.23 45 bottom
RA74  10_0402_1%  [R_0402]  35.81 1.62 0 top
RA75  10_0402_1%  [R_0402]  33.73 2.78 270 bottom
RA76  10_0402_1%  [R_0402]  31.07 1.56 180 top
RA77  10K_0402_0.1%  [R_0402]  34.23 15.39 90 top
RA78  10K_0402_0.1%  [R_0402]  31.56 15.33 90 top
RA79  10K_0402_0.1%  [R_0402]  30.67 15.33 90 top
RA80  10K_0402_0.1%  [R_0402]  27.96 15.08 180 top
RA81  10K_0402_0.1%  [R_0402]  28.65 13.06 180 top
RA82  10K_0402_0.1%  [R_0402]  28.65 12.1 180 top
RA83  0_0805_5%  [R_0805]  28.77 4.82 270 bottom
RA84  0_0201_5%  [R0201_0OHM]  21.18 28.28 180 top
RA85  0_0201_5%  [R_0201]  21.18 27.64 180 top
RC2  24.9_0402_1%  [R_0402]  170.95 89.92 180 bottom
RC9  1K_0402_5%  [R_0402]  127.47 160.88 180 top
RC30  24.9_0402_1%  [R_0402]  176.35 121.39 270 bottom
RC35  51_0402_1%  [R_0402]  126.62 156.56 0 top
RC62  49.9K_0402_1%  [R_0402]  213.31 14.46 270 bottom
RC63  49.9K_0402_1%  [R_0402]  207.72 15.92 270 top
RC65  49.9K_0402_1%  [R_0402]  215.1 13.24 180 bottom
RC66  20_0402_5%  [R_0402]  175.72 114.6 270 bottom
RC348  51_0402_1%  [R_0402]  126.62 157.45 0 top
RC353  1K_0402_5%  [R_0402]  129.37 158.78 180 top
RC354  1K_0402_1%  [R_0402]  128.33 160.88 0 top
RC355  1K_0402_1%  [R_0402]  126.68 158.78 0 top
RD1  0_0402_5%  [R_0402]  178.25 52.18 270 top
RD2  0_0402_5%  [R_0402]  178.76 53.17 90 top
RD3  0_0402_5%  [R_0402]  156.55 47.69 270 top
RD4  0_0402_5%  [R_0402]  176.67 39.61 270 top
RD5  0_0402_5%  [R_0402]  177.55 39.61 270 top
RD6  0_0402_5%  [R_0402]  157.12 38.52 90 top
RD28  0_0402_5%  [R_0402]  177.36 51.26 90 top
RD29  0_0402_5%  [R_0402]  177.87 54.25 90 top
RD30  0_0402_5%  [R_0402]  155.66 46.77 90 top
RD31  0_0402_5%  [R_0402]  138.32 51.35 90 top
RD35  470_0402_1%  [R_0402]  136.54 51.35 90 top
RD38  0_0402_5%  [R_0402]  176.35 36.75 270 top
RD39  0_0402_5%  [R_0402]  177.24 36.75 270 top
RD40  0_0402_5%  [R_0402]  156.23 39.43 270 top
RE1  4.7K_0402_5%  [R_0402]  311.56 20.63 270 top
RE2  4.7K_0402_5%  [R_0402]  312.45 20.63 270 top
RE7  1K_0402_1%~D  [R_0402]  323.67 10.7 180 top
RE8  10K_0402_5%  [R_0402]  315.1 20.62 270 top
RE9  15_0402_5%  [R_0402]  99.18 25.52 90 bottom
RE10  15_0402_5%  [R_0402]  101.99 15.2 270 bottom
RE11  15_0402_5%  [R_0402]  100.14 25.52 90 bottom
RE12  10K_0402_5%~D  [R_0402]  102.94 14.28 90 bottom
RE13  10K_0402_5%~D  [R_0402]  102.36 26.43 270 bottom
RE14  10K_0402_5%~D  [R_0402]  101.09 14.28 90 bottom
RE15  100K_0402_5%  [R_0402]  290.72 28.3 270 top
RE16  100K_0402_5%  [R_0402]  323.48 47.1 270 top
RE17  100K_0402_5%  [R_0402]  325 47.1 270 top
RE20  10K_0402_5%  [R_0402]  99.39 28.47 90 bottom
RE21  100K_0402_5%  [R_0402]  326.4 47.1 270 top
RE23  100K_0402_5%  [R_0402]  324.81 36.91 90 top
RE24  0_0603_5%  [R0603_0OHM]  309.17 20.75 0 top
RE25  4.7K_0402_1%  [R_0402]  224.47 161.64 0 top
RE26  4.7K_0402_1%~D  [R_0402]  185.63 24.97 270 top
RE27  4.7K_0402_1%  [R_0402]  186.58 24.06 90 top
RE28  100K_0402_5%  [R_0402]  205.94 157.7 90 top
RE29  4.7K_0402_1%~D  [R_0402]  183.87 22.17 180 top
RE30  4.7K_0402_1%  [R_0402]  183.87 21.21 180 top
RE31  10K_0402_5%~D  [R_0402]  225.19 157.64 180 top
RE32  4.7K_0402_1%  [R_0402]  191.03 24.72 270 top
RE37  10K_0402_5%  [R_0402]  187.54 24.06 90 top
RE40  4.7K_0402_1%~D  [R_0402]  224.28 155.86 0 top
RE42  4.7K_0402_1%~D  [R_0402]  225.12 154.54 270 top
RE43  4.7K_0402_1%~D  [R_0402]  224.28 156.75 0 top
RE44  4.7K_0402_1%~D  [R_0402]  226.01 154.54 270 top
RE63  100K_0402_5%  [R_0402]  310.02 14.93 180 top
RE64  100K_0402_1%  [R_0402]  288.06 8.3 270 top
RE66  0_0402_1%  [R_0402]  288.96 7.39 90 top
RE70  10K_0402_5%  [R_0402]  310.02 16.84 180 top
RE74  43_0402_1%  [R_0402]  310.02 12.9 180 top
RE75  10K_0402_5%  [R_0402]  292.16 25.48 90 top
RE76  43_0402_1%  [R_0402]  309.11 18.62 0 top
RE78  0_0402_5%  [R0402_0OHM]  307.78 5.67 90 top
RE79  10K_0402_5%  [R_0402]  309.11 10.01 270 top
RE83  10K_0402_5%  [R_0402]  309.11 23.95 0 top
RE84  10K_0402_5%  [R_0402]  310.02 12.01 180 top
RE85  53.6K_0402_5%  [R_0402]  310.02 11 180 top
RE89  0_0402_5%  [R_0402]  302.13 26.82 270 top
RE90  2.2K_0804_8P4R_5%  [RP_0804_8P4R]  299.32 6.07 270 top
RE91  47K_0402_5%  [R_0402]  330.46 38.31 90 top
RE100  4.7K_0402_5%  [R_0402]  301.79 4.76 90 top
RE101  4.7K_0402_5%  [R_0402]  302.68 4.76 90 top
RE102  100K_0402_5%  [R_0402]  288.36 12.41 180 top
RE154  10K_0402_5%  [R_0402]  201.91 175.19 270 top
RE155  1K_0402_1%  [R_0402]  200.53 175.22 270 top
RE156  10K_0402_5%  [R_0402]  198.41 172.03 90 top
RE157  1K_0402_1%  [R_0402]  205.74 174.3 90 top
RE158  10K_0402_5%  [R_0402]  204.31 175.23 270 top
RE160  1K_0402_1%  [R_0402]  203.32 175.22 270 top
RE161  10K_0402_5%  [R_0402]  152.47 164.13 270 top
RE162  4.7K_0402_1%  [R_0402]  304.92 30.21 270 top
RE163  4.7K_0402_1%  [R_0402]  301.89 31.97 180 top
RE164  4.7K_0402_1%  [R_0402]  301.89 32.99 180 top
RE165  4.7K_0402_1%  [R_0402]  303.91 29.29 90 top
RE166  4.7K_0402_1%  [R_0402]  300.78 37.12 0 top
RE167  10K_0402_5%~D  [R_0402]  301.89 34 180 top
RE300  10K_0201_1%  [R_0201]  158.23 163.23 180 top
RE396  10K_0201_1%  [R_0201]  236.74 30.35 90 bottom
RE397  1M_0201_1%  [R_0201]  236.74 31.62 90 bottom
RE398  1M_0201_1%  [R_0201]  234.62 32.86 180 bottom
RE399  10K_0201_1%  [R_0201]  233.05 32.2 270 bottom
RE400  1M_0201_1%  [R_0201]  235.3 32.86 0 bottom
RE401  1M_0201_1%  [R_0201]  233.05 30.93 270 bottom
RE449  10K_0201_1%  [R_0201]  227.15 25.72 270 top
RE451  1M_0201_1%  [R_0201]  229.4 23.15 0 bottom
RE452  1M_0201_1%  [R_0201]  228.71 23.15 180 bottom
RE453  1M_0201_1%  [R_0201]  227.15 21.28 270 bottom
RE454  10K_0201_1%  [R_0201]  227.15 22.49 270 bottom
RE455  10K_0201_1%  [R_0201]  230.83 20.63 90 bottom
RE456  1M_0201_1%  [R_0201]  230.83 21.9 90 bottom
RE457  1M_0201_1%  [R_0201]  229.4 26.38 0 bottom
RE458  1M_0201_1%  [R_0201]  227.15 24.26 270 bottom
RE459  1M_0201_1%  [R_0201]  228.71 26.38 180 bottom
RE460  10K_0201_1%  [R_0201]  227.15 25.47 270 bottom
RE461  10K_0201_1%  [R_0201]  230.83 23.87 90 bottom
RE462  1M_0201_1%  [R_0201]  230.83 25.14 90 bottom
RE463  1M_0201_1%  [R_0201]  229.4 29.62 0 bottom
RE464  1M_0201_1%  [R_0201]  228.71 29.62 180 bottom
RE465  1M_0201_1%  [R_0201]  227.15 27.76 270 bottom
RE466  10K_0201_1%  [R_0201]  230.83 27.11 90 bottom
RE467  10K_0201_1%  [R_0201]  227.15 28.96 270 bottom
RE468  1M_0201_1%  [R_0201]  230.83 28.38 90 bottom
RE469  1M_0201_1%  [R_0201]  228.71 32.86 180 bottom
RE470  1M_0201_1%  [R_0201]  229.4 32.86 0 bottom
RE471  10K_0201_1%  [R_0201]  230.83 30.35 90 bottom
RE472  1M_0201_1%  [R_0201]  227.15 30.99 270 bottom
RE473  1M_0201_1%  [R_0201]  230.83 31.62 90 bottom
RE474  10K_0201_1%  [R_0201]  227.15 32.2 270 bottom
RE475  1M_0201_1%  [R_0201]  234.62 29.62 180 bottom
RE476  10K_0201_1%  [R_0201]  236.74 27.11 90 bottom
RE477  1M_0201_1%  [R_0201]  235.3 29.62 0 bottom
RE478  1M_0201_1%  [R_0201]  236.74 28.38 90 bottom
RE479  1M_0201_1%  [R_0201]  233.05 27.69 270 bottom
RE480  10K_0201_1%  [R_0201]  233.05 28.96 270 bottom
RE481  1M_0201_1%  [R_0201]  234.62 26.38 180 bottom
RE482  10K_0201_1%  [R_0201]  236.74 23.87 90 bottom
RE483  1M_0201_1%  [R_0201]  235.3 26.38 0 bottom
RE484  1M_0201_1%  [R_0201]  236.74 25.14 90 bottom
RE485  1M_0201_1%  [R_0201]  233.05 24.45 270 bottom
RE486  10K_0201_1%  [R_0201]  233.05 25.72 270 bottom
RE487  1M_0201_1%  [R_0201]  234.62 23.15 180 bottom
RE488  10K_0201_1%  [R_0201]  236.74 20.63 90 bottom
RE489  1M_0201_1%  [R_0201]  235.3 23.15 0 bottom
RE490  1M_0201_1%  [R_0201]  236.74 21.9 90 bottom
RE491  1M_0201_1%  [R_0201]  233.05 21.22 270 bottom
RE492  10K_0201_1%  [R_0201]  233.05 22.49 270 bottom
RE493  1M_0201_1%  [R_0201]  235.3 32.86 0 top
RE494  1M_0201_1%  [R_0201]  234.62 32.86 180 top
RE495  10K_0201_1%  [R_0201]  233.05 30.45 90 top
RE496  1M_0201_1%  [R_0201]  236.74 30.93 270 top
RE497  1M_0201_1%  [R_0201]  233.05 31.62 90 top
RE498  10K_0201_1%  [R_0201]  236.74 32.2 270 top
RE499  1M_0201_1%  [R_0201]  234.7 29.62 180 top
RE500  1M_0201_1%  [R_0201]  235.3 29.62 0 top
RE501  1M_0201_1%  [R_0201]  236.74 27.69 270 top
RE502  10K_0201_1%  [R_0201]  233.05 26.87 90 top
RE503  10K_0201_1%  [R_0201]  236.74 28.96 270 top
RE504  1M_0201_1%  [R_0201]  233.05 28.07 90 top
RE505  1M_0201_1%  [R_0201]  235.3 26.38 0 top
RE506  1M_0201_1%  [R_0201]  234.62 26.38 180 top
RE507  10K_0201_1%  [R_0201]  233.05 23.93 90 top
RE508  1M_0201_1%  [R_0201]  236.74 24.52 270 top
RE509  1M_0201_1%  [R_0201]  233.05 25.14 90 top
RE510  10K_0201_1%  [R_0201]  236.74 25.79 270 top
RE511  10K_0201_1%  [R_0201]  227.15 24.45 270 top
RE512  1M_0201_1%  [R_0201]  230.83 24.45 270 top
RE513  1K_0201_1%  [R_0201]  230.83 25.72 270 top
RE514  10K_0201_1%  [R_0201]  223.4 24.33 270 top
RE515  1M_0201_1%  [R_0201]  223.4 21.34 270 top
RE516  1K_0201_1%  [R_0201]  223.4 22.61 270 top
RE517  10K_0201_1%  [R_0201]  223.4 25.53 270 top
RE518  10K_0201_1%  [R_0201]  227.15 27.69 270 top
RE519  1M_0201_1%  [R_0201]  230.83 27.69 270 top
RE520  1K_0201_1%  [R_0201]  230.83 28.96 270 top
RE521  10K_0201_1%  [R_0201]  227.15 28.96 270 top
RE522  10K_0201_1%  [R_0201]  227.15 21.22 270 top
RE523  1M_0201_1%  [R_0201]  230.83 21.22 270 top
RE524  1K_0201_1%  [R_0201]  230.83 22.49 270 top
RE525  10K_0201_1%  [R_0201]  227.15 22.49 270 top
RE526  10K_0201_1%  [R_0201]  227.15 30.93 270 top
RE527  1M_0201_1%  [R_0201]  230.83 30.93 270 top
RE528  1K_0201_1%  [R_0201]  230.83 32.2 270 top
RE529  10K_0201_1%  [R_0201]  227.15 32.2 270 top
RE530  47K_0402_5%  [R_0402]  318.16 54.26 180 top
RE630  100K_0201_1%  [R_0201]  143.26 9.09 270 top
RE631  100K_0201_1%  [R_0201]  143.9 9.09 270 top
RE632  100K_0201_1%  [R_0201]  144.53 9.09 270 top
RE633  100K_0201_1%  [R_0201]  145.17 9.09 270 top
RE634  100K_0201_1%  [R_0201]  145.87 9.09 270 top
RE635  100K_0201_1%  [R_0201]  146.5 9.09 270 top
RE636  1.1K_0402_1%  [R_0402]  273.44 33.52 180 top
RE637  1K_0201_1%  [R_0201]  272.64 37.79 180 top
RE638  1M_0201_1%  [R_0201]  272.06 37.22 0 top
RE639  1.1K_0402_1%  [R_0402]  270.33 37.42 0 top
RE640  1K_0201_1%  [R_0201]  271.17 33.04 0 top
RE641  1M_0201_1%  [R_0201]  271.75 33.67 180 top
RE642  4.7K_0402_5%  [R_0402]  299.16 26.84 270 top
RE643  4.7K_0402_5%  [R_0402]  298.27 26.84 270 top
RE644  100K_0402_5%  [R_0402]  206.82 116.87 0 bottom
RE645  10K_0402_5%  [R_0402]  319.54 25.83 180 top
RE646  0_0201_5%  [R_0201]  305.06 26.42 270 top
RE647  0_0402_5%  [R_0402]  157.11 161.63 90 bottom
RE648  0_0402_5%  [R_0402]  156.22 161.63 90 bottom
RE649  10K_0402_5%  [R_0402]  19.05 51.85 0 top
RE650  10K_0402_5%  [R_0402]  289.28 21.32 90 top
RE651  0_0402_5%  [R_0402]  316.52 19.64 90 top
RE652  10K_0402_5%  [R_0402]  144.45 164.6 90 top
RF1  10K_0402_5%  [R_0402]  104.2 57.82 0 top
RF2  10K_0402_5%  [R_0402]  104.21 61.26 270 top
RF3  10K_0402_5%  [R_0402]  104.2 59.41 0 top
RF4  10K_0402_5%  [R_0402]  287.69 73.78 180 top
RF5  10K_0402_5%  [R_0402]  287.69 74.68 180 top
RF6  10K_0402_5%  [R_0402]  292.83 73.55 90 top
RG1  0_0201_5%  [R_0201]  197.28 118.38 270 bottom
RG2  10K_0201_5%  [R_0201]  234.77 119.69 90 bottom
RG3  10K_0201_5%  [R_0201]  200.33 122.78 180 bottom
RG4  0_0201_5%  [R_0201]  234.2 120.28 270 bottom
RG6  10K_0201_5%  [R_0201]  197 116.29 270 bottom
RG7  0_0201_5%  [R_0201]  197.57 116.29 270 bottom
RG8  10K_0201_5%  [R_0201]  216.58 111.67 180 bottom
RG9  10K_0201_5%  [R_0201]  197.96 123.54 0 bottom
RG11  1.8K_0402_1%  [R_0402]  207.73 120.62 180 bottom
RG12  1.8K_0402_1%  [R_0402]  207.73 119.67 180 bottom
RG13  10K_0201_5%  [R_0201]  199.12 122.78 180 bottom
RG14  10K_0201_5%  [R_0201]  200.39 119.03 0 bottom
RG15  10K_0201_5%  [R_0201]  214.23 110.78 180 bottom
RG16  100K_0201_5%  [R_0201]  222.28 112.49 0 top
RG17  1.8K_0402_5%  [R_0402]  207.73 121.89 180 bottom
RG18  1.8K_0402_5%  [R_0402]  207.73 122.78 180 bottom
RG19  1.8K_0402_5%  [R_0402]  208.97 119.86 0 bottom
RG20  1.8K_0402_5%  [R_0402]  207.73 118.13 180 bottom
RG21  10K_0201_5%  [R_0201]  196.67 117.79 90 bottom
RG22  10K_0201_5%  [R_0201]  226.3 23.84 180 bottom
RG23  2.49K_0402_1%  [R_0402]  243.4 114.38 90 top
RG24  100K_0201_5%  [R_0201]  191.11 100.49 0 top
RG25  1M_0201_1%  [R_0201]  223.76 161.6 90 top
RG26  10K_0201_5%  [R_0201]  230.64 119.69 90 bottom
RG36  1K_0402_1%  [R_0402]  243.06 119.81 90 bottom
RG37  1K_0402_1%  [R_0402]  232.1 114.51 90 top
RG38  1K_0402_1%  [R_0402]  228.71 113.87 90 top
RG47  10K_0402_5%  [R_0402]  277.71 87.73 180 top
RG48  10K_0402_5%  [R_0402]  277.69 116.25 270 top
RG49  10K_0402_5%  [R_0402]  250.83 57.49 90 top
RG50  10K_0402_5%  [R_0402]  276.11 77.17 90 top
RG51  10K_0402_5%  [R_0402]  219.22 58.58 180 top
RG52  10K_0402_5%  [R_0402]  244.56 57.69 180 top
RG53  10K_0402_5%  [R_0402]  275.41 116.19 270 top
RG54  10K_0402_5%  [R_0402]  275.47 87.46 90 top
RG55  10K_0402_5%  [R_0402]  275.23 78.01 180 top
RG56  10K_0402_5%  [R_0402]  250.69 60.04 0 top
RG57  10K_0402_5%  [R_0402]  244.5 59.99 180 top
RG58  10K_0402_5%  [R_0402]  218.31 59.53 0 top
RG59  10_0402_1%  [R_0402]  191.86 111.73 180 bottom
RG60  1.8K_0402_1%  [R_0402]  195.92 117.3 180 bottom
RG61  1.8K_0402_1%  [R_0402]  195.92 116.41 180 bottom
RG62  10_0402_1%  [R_0402]  189.04 111.73 0 bottom
RG63  10K_0402_1%  [R_0402]  195.92 115.53 180 bottom
RG64  10_0402_1%  [R_0402]  186.44 115.27 90 bottom
RG65  10K_0402_1%  [R_0402]  195.92 118.19 180 bottom
RG66  10_0402_1%  [R_0402]  186.44 117.96 270 bottom
RG67  40.2_0402_1%  [R_0402]  247.74 90.2 180 top
RG68  40.2_0402_1%  [R_0402]  254.25 89.69 0 top
RG69  60.4_0402_1%  [R_0402]  254.2 90.63 90 top
RG70  10K_0402_5%  [R_0402]  195 114.65 0 bottom
RG71  4.7K_0402_1%  [R_0402]  198.87 112.8 90 bottom
RG74  10K_0402_5%  [R_0402]  212.68 108.11 180 bottom
RG75  33_0402_5%  [R_0402]  201.32 105.57 180 bottom
RG76  33_0402_5%  [R_0402]  212.68 106.84 180 bottom
RG77  33_0402_5%  [R_0402]  201.32 104.3 180 bottom
RG78  100K_0402_1%  [R_0402]  205.25 109.51 180 top
RG79  100K_0402_1%  [R_0402]  205.25 110.4 180 top
RG80  100K_0402_1%  [R_0402]  215.54 115.54 180 bottom
RG81  100K_0402_1%  [R_0402]  201.61 109.51 0 top
RG82  100K_0402_1%  [R_0402]  201.93 110.4 0 top
RG83  100K_0402_1%  [R_0402]  217.88 114.09 270 top
RG84  10K_0402_1%  [R_0402]  200.4 108.55 0 bottom
RG85  10K_0402_1%  [R_0402]  200.57 110.57 180 top
RG86  10K_0402_1%  [R_0402]  201.32 112.94 180 bottom
RG87  10K_0402_1%  [R_0402]  201.32 109.44 180 bottom
RG88  10K_0402_1%  [R_0402]  199.65 111.45 0 top
RG89  10K_0402_1%  [R_0402]  201.32 106.59 180 bottom
RG90  100K_0402_1%  [R_0402]  204.34 108.62 0 top
RG91  100K_0402_1%  [R_0402]  203.7 111.28 0 top
RG92  100K_0402_1%  [R_0402]  214.63 116.43 0 bottom
RG93  100K_0402_1%  [R_0402]  202.52 108.62 180 top
RG94  100K_0402_1%  [R_0402]  202.84 111.54 180 top
RG95  100K_0402_1%  [R_0402]  222.2 113.81 90 top
RG98  100K_0402_5%  [R_0402]  215.54 114.65 180 bottom
RG99  10M_0402_5%  [R_0402]  213.11 117.58 270 bottom
RG101  10K_0402_5%  [R_0402]  195.83 106.94 90 top
RG102  40.2_0402_1%  [R_0402]  274.51 100.49 90 top
RG103  40.2_0402_1%  [R_0402]  273.62 103.47 270 top
RG104  1K_0402_1%  [R_0402]  276.5 85.76 180 top
RG105  1K_0402_1%  [R_0402]  274.72 117.7 180 top
RG106  1K_0402_1%  [R_0402]  275.8 93.82 180 top
RG107  1K_0402_1%  [R_0402]  276.25 109 180 top
RG108  121_0402_1%  [R_0402]  276.25 98.57 180 top
RG109  121_0402_1%  [R_0402]  276.93 106.47 270 top
RG110  549_0402_1%  [R_0402]  278.66 100.81 180 bottom
RG111  931_0402_1%  [R_0402]  278.66 101.82 180 bottom
RG112  1.33K_0402_1%  [R_0402]  276.86 101.1 180 bottom
RG113  40.2_0402_1%  [R_0402]  263.41 62.08 0 bottom
RG114  40.2_0402_1%  [R_0402]  273.68 68.47 270 top
RG115  1K_0402_1%  [R_0402]  249.06 58.85 270 top
RG116  1K_0402_1%  [R_0402]  275.23 82.96 180 top
RG117  1K_0402_1%  [R_0402]  257.5 58.4 270 top
RG118  1K_0402_1%  [R_0402]  277.05 74.45 0 top
RG119  121_0402_1%  [R_0402]  260.47 58.58 0 top
RG120  121_0402_1%  [R_0402]  276.36 70.53 270 top
RG121  549_0402_1%  [R_0402]  263.98 56.79 90 bottom
RG122  931_0402_1%  [R_0402]  277.26 67.98 180 bottom
RG123  1.33K_0402_1%  [R_0402]  263.98 58.57 90 bottom
RG124  40.2_0402_1%  [R_0402]  228.48 62.08 0 top
RG125  40.2_0402_1%  [R_0402]  231.85 62.08 180 top
RG126  1K_0402_1%  [R_0402]  218.31 57.69 0 top
RG127  1K_0402_1%  [R_0402]  246.26 58.88 90 top
RG128  1K_0402_1%  [R_0402]  222.26 59.77 90 top
RG129  1K_0402_1%  [R_0402]  238.71 58.27 270 top
RG130  121_0402_1%  [R_0402]  226.07 59.26 90 top
RG131  121_0402_1%  [R_0402]  234.15 59.21 180 top
RG132  549_0402_1%  [R_0402]  228.04 56.79 90 bottom
RG133  931_0402_1%  [R_0402]  228.93 56.79 90 bottom
RG134  1.33K_0402_1%  [R_0402]  228.93 58.57 90 bottom
RG137  10_0402_1%  [R_0402]  191.86 121.44 180 bottom
RG138  10_0402_1%  [R_0402]  189.16 121.44 0 bottom
RG146  33_0402_5%  [R_0402]  212.62 112.94 180 bottom
RG147  10K_0402_5%  [R_0402]  212.62 114.14 180 bottom
RG148  33_0402_5%  [R_0402]  201.32 111.6 180 bottom
RG149  33_0402_5%  [R_0402]  201.32 110.33 180 bottom
RG150  100K_0201_5%  [R_0201]  188.79 102.48 90 top
RG151  100K_0201_5%  [R_0201]  193.43 112 270 top
RG154  1.33K_0402_1%  [R_0402]  196.4 84.23 0 bottom
RG155  549_0402_1%  [R_0402]  194.62 86.01 0 bottom
RG156  931_0402_1%  [R_0402]  194.62 85.12 0 bottom
RG157  121_0402_1%  [R_0402]  198.71 90.08 180 top
RG158  1K_0402_1%  [R_0402]  198.97 101.51 180 top
RG159  1K_0402_1%  [R_0402]  198.52 94.01 180 top
RG160  40.2_0402_1%  [R_0402]  201.06 86.96 270 bottom
RG161  1K_0402_1%  [R_0402]  199.13 69.25 0 top
RG162  121_0402_1%  [R_0402]  198.65 80.55 180 top
RG163  1K_0402_1%  [R_0402]  198.52 76.8 180 top
RG164  40.2_0402_1%  [R_0402]  201.89 83.57 90 bottom
RG450  10K_0402_5%  [R_0402]  200.12 70.91 90 top
RG451  10K_0402_5%  [R_0402]  197.8 99.66 0 top
RG452  10K_0402_5%  [R_0402]  197.87 70.95 90 top
RG453  10K_0402_5%  [R_0402]  200.06 99.74 270 top
RG500  10K_0201_5%  [R_0201]  206 123.06 90 bottom
RG501  100K_0201_5%  [R_0201]  216.65 109.76 180 bottom
RG502  10K_0201_5%  [R_0201]  211.91 123.44 90 bottom
RG503  10K_0201_5%  [R_0201]  220.04 111.59 0 top
RG504  10K_0201_5%  [R_0201]  219.38 113.25 180 top
RG506  10K_0201_5%  [R_0201]  214.18 157.41 90 top
RG507  0_0201_5%  [R_0201]  203.31 124.49 180 bottom
RG508  0_0201_5%  [R_0201]  203.72 127.12 90 bottom
RG509  10K_0402_5%  [R_0402]  188.48 110.06 90 top
RG510  51_0402_5%  [R_0402]  192.29 110.99 90 top
RG511  10K_0402_5%  [R_0402]  188.72 108.05 0 top
RG512  51_0402_5%  [R_0402]  190.71 104.11 180 top
RG513  10K_0402_5%  [R_0402]  191.27 107.04 270 top
RG514  51_0402_5%  [R_0402]  194.92 106.05 270 top
RG515  10K_0402_5%  [R_0402]  192.63 104.07 0 top
RG516  10K_0201_5%  [R_0201]  211.93 158.92 90 top
RG517  10K_0201_5%  [R_0201]  207.91 126.14 0 bottom
RG518  10K_0201_5%  [R_0201]  233.12 119.69 90 bottom
RG519  100K_0201_5%  [R_0201]  211.15 123.44 90 bottom
RG522  10K_0201_5%  [R_0201]  195.35 119.49 0 bottom
RG523  40.2_0402_1%  [R_0402]  275.42 100.49 90 top
RG524  40.2_0402_1%  [R_0402]  274.53 103.47 270 top
RG525  40.2_0402_1%  [R_0402]  263.41 61.17 0 bottom
RG526  40.2_0402_1%  [R_0402]  274.6 68.47 270 top
RG527  40.2_0402_1%  [R_0402]  228.48 61.17 0 top
RG528  40.2_0402_1%  [R_0402]  231.85 61.17 180 top
RG529  0_0201_5%  [R_0201]  191.92 113.09 270 bottom
RG530  10K_0201_5%  [R_0201]  207.77 124.82 90 bottom
RG531  40.2_0402_1%  [R_0402]  200.15 86.96 270 bottom
RG532  40.2_0402_1%  [R_0402]  201.01 83.57 90 bottom
RG533  100K_0201_5%  [R_0201]  306.64 60.84 0 top
RG534  10K_0201_1%  [R_0201]  309.15 58.12 0 top
RG535  100K_0201_5%  [R_0201]  188.32 97.24 0 top
RG536  2.2K_0201_5%  [R_0201]  188.48 100.87 180 top
RG537  0_0201_5%  [R_0201]  202.13 118.5 270 bottom
RG540  0_0201_5%  [R_0201]  208.45 125.41 270 bottom
RG541  10K_0402_5%  [R_0402]  290.25 83.13 180 bottom
RG542  10K_0402_5%  [R_0402]  289.96 87.34 0 bottom
RG543  10K_0402_5%  [R_0402]  290.6 81.2 180 bottom
RG544  10K_0402_5%  [R_0402]  287.96 79.32 270 bottom
RG545  2.2K_0201_1%  [R_0201]  278.74 155.16 0 top
RG549  100K_0402_5%  [R_0402]  280.73 163.44 0 top
RG550  39K_0402_1%  [R_0402]  276.63 164.85 270 top
RG551  0_0201_5%  [R_0201]  277.31 143.64 90 top
RG552  0_0201_5%  [R_0201]  279.4 147.03 270 top
RG553  0_0201_5%  [R_0201]  212.11 155 0 top
RG554  0_0201_5%  [R_0201]  217.03 157.37 270 bottom
RG555  10K_0201_1%  [R_0201]  187.68 35.27 0 bottom
RG556  10K_0201_1%  [R_0201]  187.68 35.91 0 bottom
RG557  10K_0402_1%  [R_0402]  312.87 58.26 180 top
RG561  100K_0201_5%  [R_0201]  312.9 54.38 270 top
RG562  100K_0402_5%  [R_0402]  204.38 122.18 90 bottom
RG563  0_0201_5%  [R_0201]  212.31 25.84 270 top
RG564  0_0201_5%  [R_0201]  220.58 113.25 180 top
RG565  0_0201_5%  [R_0201]  217.13 111.09 0 top
RH1  1K_0402_1%  [R_0402]  224.04 24.56 270 bottom
RH2  10K_0402_5%  [R_0402]  208.76 35.68 270 top
RH4  0_0402_5%  [R_0402]  217.5 33.49 0 top
RH5  1K_0402_5%  [R_0402]  214.01 43.11 90 bottom
RH6  0_0603_5%  [R_0603]  202.76 24.92 0 top
RH7  0_0603_5%  [R_0603]  212.35 31.97 90 top
RH9  100K_0402_5%  [R_0402]  219.66 39.77 270 bottom
RH12  0_0805_5%  [R_0805]  191.63 31.25 0 top
RH16  1K_0402_1%  [R_0402]  214.38 36.84 90 top
RH21  10K_0201_5%  [R_0201]  196.2 13.18 180 bottom
RH22  10K_0201_5%  [R_0201]  196.82 13.18 0 bottom
RH23  10K_0201_5%  [R_0201]  210.54 24.54 0 top
RH24  10K_0201_5%  [R_0201]  209.91 24.54 180 top
RH25  10K_0201_5%  [R_0201]  199.03 13.88 270 bottom
RH26  10K_0201_5%  [R_0201]  199.03 14.5 90 bottom
RH27  10K_0201_5%  [R_0201]  196.2 14.26 180 bottom
RH28  10K_0201_5%  [R_0201]  196.82 14.26 0 bottom
RH29  10K_0201_5%  [R_0201]  198.41 13.88 270 bottom
RH30  10K_0201_5%  [R_0201]  198.41 14.48 90 bottom
RH38  30_0402_5%  [R_0402]  212.87 45.23 180 bottom
RH39  30_0402_5%  [R_0402]  212.87 46.18 180 bottom
RH57  49.9_0402_1%  [R_0402]  128.95 108.59 0 bottom
RH58  49.9_0402_1%  [R_0402]  128.95 110.37 0 bottom
RH59  49.9_0402_1%  [R_0402]  129.87 109.48 180 bottom
RH70  10M_0402_5%  [R_0402]  218.77 36.15 270 bottom
RH71  2.7K_0402_1%  [R_0402]  198.01 41.75 180 top
RH72  1M_0402_5%~D  [R_0402]  193.37 42.61 0 bottom
RH73  12.1_0402_1%  [R_0402]  211.08 46.31 90 bottom
RH74  3.3K_0402_5%  [R_0402]  220.63 19.31 180 bottom
RH75  1K_0402_5%  [R_0402]  220.82 22.8 180 top
RH78  1K_0402_5%  [R_0402]  220.82 21.91 180 top
RH79  620_0402_5%  [R_0402]  210.16 46.29 90 bottom
RH83  20K_0402_5%~D  [R_0402]  216.22 34.03 270 top
RH84  20K_0402_5%~D  [R_0402]  216.24 35.76 90 top
RH85  8.2K_0402_5%  [R_0402]  220.02 27.91 0 top
RH88  10K_0402_5%  [R_0402]  212.87 36.79 270 top
RH89  22_0402_5%  [R_0402]  220.51 29.04 180 bottom
RH90  100K_0402_5%  [R_0402]  211.92 36.34 270 top
RH104  15_0402_1%  [R_0402]  223.62 19.58 180 bottom
RH109  113_0402_1%  [R_0402]  206.28 42.65 90 bottom
RH111  10K_0402_5%~D  [R_0402]  222.45 28.29 270 bottom
RH130  4.7K_0402_5%~D  [R_0402]  210.69 25.69 0 top
RH135  10K_0402_5%  [R_0402]  220.95 30.36 180 top
RH148  121_0402_1%  [R_0402]  172.79 89.92 180 bottom
RH149  75_0402_1%  [R_0402]  169.16 89.85 90 bottom
RH150  100_0402_1%  [R_0402]  168.27 89.85 90 bottom
RH151  100_0402_1%  [R_0402]  126.73 118.81 0 bottom
RH152  56.2_0402_1%  [R_0402]  126.73 119.77 0 bottom
RH153  220_0402_5%  [R_0402]  126.73 120.72 0 bottom
RH154  60.4_0402_1%  [R_0402]  174.26 100.73 90 top
RH155  20_0402_5%  [R_0402]  126.73 116.78 0 bottom
RH156  51_0402_5%  [R_0402]  128.95 114.88 0 bottom
RH158  499_0402_1%  [R_0402]  128.95 115.83 0 bottom
RH163  1K_0402_5%  [R_0402]  167.94 115.38 180 top
RH164  1K_0402_5%  [R_0402]  174.26 98.95 90 top
RH165  1K_0402_5%  [R_0402]  126.73 115.83 0 bottom
RH166  49.9_0402_1%  [R_0402]  126.73 114.88 0 bottom
RH167  30_0402_5%  [R_0402]  175.9 109.16 180 top
RH184  1K_0402_5%  [R_0402]  133.25 111.66 180 top
RH185  1K_0402_5%  [R_0402]  129.87 105.42 180 bottom
RH186  1K_0402_5%  [R_0402]  134.77 105.78 180 top
RH187  1K_0402_5%  [R_0402]  129.87 106.37 180 bottom
RH188  1K_0402_5%  [R_0402]  129.87 107.32 180 bottom
RH192  30_0402_5%  [R_0402]  175.9 110.11 180 top
RH193  100_0402_1%  [R_0402]  192.55 31.9 270 bottom
RH196  0_0402_5%  [R_0402]  216.23 24.91 90 top
RH197  100_0402_1%  [R_0402]  155.59 122.51 90 bottom
RH199  100K_0402_5%  [R_0402]  215.01 20.8 0 top
RH201  100_0402_1%  [R_0402]  173.37 124.31 270 bottom
RH203  100_0402_1%  [R_0402]  151.4 122.51 90 bottom
RH206  1K_0402_1%~D  [R_0402]  153.56 52.26 270 top
RH207  1K_0402_1%~D  [R_0402]  152.66 39.42 0 top
RH209  1K_0402_1%~D  [R_0402]  155.34 51.35 90 top
RH210  1K_0402_1%~D  [R_0402]  154.44 38.53 0 top
RH211  24.9_0402_1%  [R_0402]  154.45 54.48 270 top
RH212  24.9_0402_1%  [R_0402]  154.44 37.58 0 top
RH453  10K_0402_5%  [R_0402]  219.59 32.01 0 bottom
RH455  1K_0402_5%  [R_0402]  220.81 20.61 180 top
RH460  1K_0402_5%  [R_0402]  209.11 12.38 90 top
RH461  1K_0402_5%  [R_0402]  210 12.38 90 top
RH462  1K_0402_5%  [R_0402]  214.32 14.69 90 top
RH463  1K_0402_5%  [R_0402]  213.37 14.69 90 top
