# Allegro board LAD751PR10-0813-B.brd (continued)
## Nets (continued)
PEG_CTX_C_GRX_N0: CC1.2 UG9.BK27
PEG_CTX_C_GRX_N1: CC2.2 UG9.BL29
PEG_CTX_C_GRX_N2: CC3.2 UG9.BM30
PEG_CTX_C_GRX_N3: CC4.2 UG9.BK30
PEG_CTX_C_GRX_N4: CC5.2 UG9.BL32
PEG_CTX_C_GRX_N5: CC6.2 UG9.BM33
PEG_CTX_C_GRX_N6: CC7.2 UG9.BK33
PEG_CTX_C_GRX_N7: CC8.2 UG9.BL35
PEG_CTX_C_GRX_N8: CC9.2 JCDRA.4
PEG_CTX_C_GRX_N9: CC10.2 JCDRA.7
PEG_CTX_C_GRX_N10: CC11.2 JCDRA.10
PEG_CTX_C_GRX_N11: CC12.2 JCDRA.13
PEG_CTX_C_GRX_P0: CC13.2 UG9.BL27
PEG_CTX_C_GRX_P1: CC14.2 UG9.BK29
PEG_CTX_C_GRX_P2: CC15.2 UG9.BM29
PEG_CTX_C_GRX_P3: CC16.2 UG9.BL30
PEG_CTX_C_GRX_P4: CC17.2 UG9.BK32
PEG_CTX_C_GRX_P5: CC18.2 UG9.BM32
PEG_CTX_C_GRX_P6: CC19.2 UG9.BL33
PEG_CTX_C_GRX_P7: CC20.2 UG9.BK35
PEG_CTX_C_GRX_P8: CC21.2 JCDRA.3
PEG_CTX_C_GRX_P9: CC22.2 JCDRA.6
PEG_CTX_C_GRX_P10: CC23.2 JCDRA.9
PEG_CTX_C_GRX_P11: CC24.2 JCDRA.12
PEG_CTX_GRX_N0: CC1.1 CPU1.B10
PEG_CTX_GRX_N1: CC2.1 CPU1.B11
PEG_CTX_GRX_N2: CC3.1 CPU1.B12
PEG_CTX_GRX_N3: CC4.1 CPU1.B13
PEG_CTX_GRX_N4: CC5.1 CPU1.B14
PEG_CTX_GRX_N5: CC6.1 CPU1.B15
PEG_CTX_GRX_N6: CC7.1 CPU1.B16
PEG_CTX_GRX_N7: CC8.1 CPU1.B17
PEG_CTX_GRX_N8: CC9.1 CPU1.C18
PEG_CTX_GRX_N9: CC10.1 CPU1.A19
PEG_CTX_GRX_N10: CC11.1 CPU1.C20
PEG_CTX_GRX_N11: CC12.1 CPU1.A21
PEG_CTX_GRX_P0: CC13.1 CPU1.C10
PEG_CTX_GRX_P1: CC14.1 CPU1.A11
PEG_CTX_GRX_P2: CC15.1 CPU1.C12
PEG_CTX_GRX_P3: CC16.1 CPU1.A13
PEG_CTX_GRX_P4: CC17.1 CPU1.C14
PEG_CTX_GRX_P5: CC18.1 CPU1.A15
PEG_CTX_GRX_P6: CC19.1 CPU1.C16
PEG_CTX_GRX_P7: CC20.1 CPU1.A17
PEG_CTX_GRX_P8: CC21.1 CPU1.B18
PEG_CTX_GRX_P9: CC22.1 CPU1.B19
PEG_CTX_GRX_P10: CC23.1 CPU1.B20
PEG_CTX_GRX_P11: CC24.1 CPU1.B21
PEG_CTX_TRX_N12: CPU1.C22 CT15.1
PEG_CTX_TRX_N12_C: CT15.2 UT1.Y22
PEG_CTX_TRX_N13: CPU1.A23 CT13.1
PEG_CTX_TRX_N13_C: CT13.2 UT1.T22
PEG_CTX_TRX_N14: CPU1.C24 CT18.1
PEG_CTX_TRX_N14_C: CT18.2 UT1.M22
PEG_CTX_TRX_N15: CPU1.A25 CT21.1
PEG_CTX_TRX_N15_C: CT21.2 UT1.H22
PEG_CTX_TRX_P12: CPU1.B22 CT3.1
PEG_CTX_TRX_P12_C: CT3.2 UT1.Y23
PEG_CTX_TRX_P13: CPU1.B23 CT1.1
PEG_CTX_TRX_P13_C: CT1.2 UT1.T23
PEG_CTX_TRX_P14: CPU1.B24 CT4.1
PEG_CTX_TRX_P14_C: CT4.2 UT1.M23
PEG_CTX_TRX_P15: CPU1.B25 CT5.1
PEG_CTX_TRX_P15_C: CT5.2 UT1.H23
PEG_RCOMP: CPU1.G2 RC2.2
PEX_CLKREQ#: QG510.3 RG2.1 UG9.BL26
PEX_TERMP: RG23.2 UG9.BL44
PEX_VDD_EN: PR823.1 UE10.17
PEX_VDD_ENP: PC801.1 PR801.1 PR802.1 PR823.2 PR8217.2 PU800.11
PI0: RV622.1 RV623.1 UV21.56
PLTRST_CPU#: CH195.1 CPU1.BP35 UH1.AK2
PM_SLP_S3#: CE41.1 Q8.2 QE1.5 UE5.6 UH1.AW15
PM_SLP_S3_H: Q7.2 Q7.5 Q8.5 Q8.6 R307.2
PM_SLP_S4#: PR1301.2 Q9.2 UE5.73 UH1.BD15
PM_SLP_S4_H: Q9.5 Q9.6 R325.2
PM_SLP_S5#: CE45.1 QE4.5 UE5.14 UH1.BA13
PM_SLP_SUS#: UE5.38 UH1.BB13
POK: DE2.1 DE3.1 DE4.1 PR14.1 PR17.2 PU100.7
POWER_LED: QE4.6 QE8.2 RE28.2
PQ703_S: PC725.2 PL700.2 PQ703.1 PQ703.2 PQ703.3 PR712.1 PR734.1
PROC_DETECT#: RH519.1 UH1.Y44
PS_ID: PR3.1 PR4.2 UE5.16
PSID: PJPDC1.1 PL2.2
PSID-1: PQ2.2 PR6.1 PR9.2
PSID-2: PQ2.1 PQ7.2 PR8.2
PSID-3: PQ7.3 PR4.1
PWM1: PR6043.2 PR6067.2 PU6000.11
PWM1_GT: PR590.1 PU500.12
PWM1_VCORE: PR552.1 PU500.25
PWM2: PR6049.2 PR6066.2 PU6000.10
PWM2_GT: PR591.1 PU500.13
PWM2_VCORE: PR563.1 PU500.26
PWM3: PR6054.2 PR6065.2 PU6000.9
PWM3_VCORE: PR573.1 PU500.27
PWM4: PR6055.2 PR6064.2 PU6000.8
PWM_SA: PR5001.2 PU500.35
PWR_B#: JPWR.4 QE13.3 RE154.2 RE160.1
PWR_B_7313#: QE13.4 UE3.17
PWR_B_EC: QE13.2 UE6.22
PWR_G#: JPWR.3 QE21.3 RE155.1 RE156.2
PWR_G_7313#: QE21.4 UE3.16
PWR_G_EC: QE21.2 UE6.10
PWR_LED#: QE4.2 UE5.92
PWR_R#: JPWR.2 QE22.3 RE157.1 RE158.2
PWR_R_7313#: QE22.4 UE3.15
PWR_R_EC: QE22.2 UE6.6
PWR_SRC_ON: CV15.2 QV1.3 RV9.2 RV12.1
PWR_VGA_CORE_BOOT1: PR8205.2 PU8200.1
PWR_VGA_CORE_BOOT1_1: PC8206.2 PR8205.1
PWR_VGA_CORE_BOOT2: PR8207.2 PU8200.15
PWR_VGA_CORE_BOOT2_1: PC8213.2 PR8207.1
PWR_VGA_CORE_LGATE1: PQ8200.6 PR8206.2 PU8200.19
PWR_VGA_CORE_LGATE2: PQ8201.6 PU8200.17
PWR_VGA_CORE_PHASE1: PC8206.1 PL8200.1 PQ8200.7 PR8204.1 PU8200.20
PWR_VGA_CORE_PHASE2: PC8213.1 PL8201.1 PQ8201.7 PR8210.1 PU8200.16
PWR_VGA_CORE_SS: PC8216.1 PU8200.11
PWR_VGA_CORE_TON: PR8202.1 PU8200.9
PWR_VGA_CORE_TON_1: PC8205.1 PR8201.1 PR8202.2
PWR_VGA_CORE_UGATE1: PQ8200.1 PU8200.2
PWR_VGA_CORE_UGATE2: PQ8201.1 PU8200.14
PWRSHARE_EN_EC#: UE5.119 UU1.5
REFADJ: PR6040.1 PU6000.40
REFIN: PR6045.1 PR6053.1 PU6000.1
REGN_CHG: PC710.1 PR714.1 PU700.24
REMOTE1+: C2500.1 C2502.1 Q2407.1 Q2407.2 U2407.2
REMOTE1-: C2500.2 C2502.2 Q2407.3 R184.1
REMOTE2+: C2504.1 C2505.1 Q2408.1 Q2408.2 U2407.4
REMOTE2-: C2504.2 C2505.2 Q2408.3 R184.2 U2407.3
REMOTE3+: C2510.1 C2511.1 Q2411.1 Q2411.2 U2407.5
REMOTE3-: C2510.2 C2511.2 Q2411.3 R185.2
RESET_N: RT102.1 UT4.F11
RF_+1VALWP: PR306.1 PU300.5
RING2: LA8.2 RA28.2 UA1.36
RING2_R: CA46.1 CA92.1 DA5.2 JACK1.4 LA8.1
RJ45_CT: CL30.2 RL9.2 RL10.2 RL11.2 RL12.2
RJ45_CT0: RL12.1 TL1.15
RJ45_CT1: RL11.1 TL1.16
RJ45_CT2: RL10.1 TL1.21
RJ45_CT3: RL9.1 TL1.22
RJ45_MDI0+: JLAN.1 TL1.13
RJ45_MDI0-: JLAN.2 TL1.14
RJ45_MDI1+: JLAN.3 TL1.17
RJ45_MDI1-: JLAN.6 TL1.18
RJ45_MDI2+: JLAN.4 TL1.19
RJ45_MDI2-: JLAN.5 TL1.20
RJ45_MDI3+: JLAN.7 TL1.23
RJ45_MDI3-: JLAN.8 TL1.24
ROM_CS#: UG9.BJ4 UG16.1
ROM_SCLK: RG75.2 RG86.1 RG89.2 RG148.2 UG9.BK3
ROM_SI: RG77.2 RG84.1 RG87.2 RG149.2 UG9.BK2
ROM_SO: RG85.1 RG88.2 UG9.BK4 UG16.4
RPD_G1: RT64.1 UT4.K9
RPD_G2: RT65.1 UT4.K10
RST#: CE55.2 RE91.2 UE6.3
RT8812_PVCC: PC8200.1 PR8200.1 PU8200.18
RTD3_CIO_PWR_EN: RT16.2 UH1.AR44
RTD3_CIO_PWR_EN_R: RT16.1 RT36.1 UT1.F1
RTD3_USB_PWR_EN: RT12.2 UH1.AR41
RTD3_USB_PWR_EN_R: RT12.1 RT37.1 UT1.D4
SATA_DET#: JHDD.19 RS8.2
SATA_GP0: JSSD3.69 R364.1 UH1.AG36
SATA_GP1: JSSD1.69 R363.1 UH1.AG35
SATA_GP3: JHDD.16 RS2.1 RS3.1 UH1.AD35
SATA_GP4: JSSD2.69 R365.1 UH1.AD31
SATA_PRX_DTX_N3: JHDD.1 UH1.D43
SATA_PRX_DTX_P3: JHDD.2 UH1.E42
SATA_PTX_DRX_N3: JHDD.4 UH1.A41
SATA_PTX_DRX_P3: JHDD.5 UH1.A40
SERIRQ: RH111.1 UE5.3 UH1.BA17
SLEEVE: LA7.2 RA26.2 UA1.37
SLEEVE_R: CA45.1 CA91.1 DA5.3 JACK1.3 LA7.1
SLP_S3: QE1.3 RE15.2 UE1.26
SLP_S5: QE4.3 RE16.2 UE1.21
SM_PG_CTRL: PR211.2 RH525.2 UC1.4
SML0CLK: RH501.2 RV632.1 UH1.AY44 UM4.11
SML0DATA: RH502.2 RV633.1 UH1.BB39 UM4.10
SML1CLK: QH5.6 RH460.2 UH1.AW42
SML1DATA: QH5.3 RH461.2 UH1.AW45
SNB_1.0VS_VGAP: PC802.1 PR803.2
SNB_+1.8VGS: PC806.1 PR809.2
SNB_VCCIO: PC591.1 PR5009.2
SNUB_CHG: PC715.1 PR713.2
SPEAKER_SEL: JSPK.5 UE10.2
SPI_MOCLK: CE57.1 RE11.2 UE1.2
SPI_MOCS#: RE12.2 UE1.31 UE2.1
SPI_MOSI: RE9.2 UE1.32
SPI_MOSO: RE10.2 UE1.1
SPK_L+_CONN: CA255.1 DA7.2 JSPK.4 LA51.2 RA61.1
SPK_L-_CONN: DA7.3 JSPK.3 RA57.2 RA59.1
SPK_R+_CONN: CA257.1 DA8.2 JSPK.2 LA53.2 RA65.1
SPK_R-_CONN: DA8.3 JSPK.1 RA60.2 RA64.1
SS: PC6002.2 PC6017.1 PR6015.2 PU6000.28
STRAP0: RG78.1 RG90.2 UG9.BL3
STRAP1: RG79.1 RG91.2 UG9.BL4
STRAP2: RG80.1 RG92.2 UG9.BM4
STRAP3: DG8.2 RG81.1 RG93.2 UG9.BM5
STRAP3_PCH: DG8.1 RG555.2 UH1.L43
STRAP4: RG82.1 RG94.2 UG9.BK5
STRAP5: DG9.2 RG83.1 RG95.2 UG9.BJ5
STRAP5_PCH: DG9.1 RG556.2 UH1.L44
SUSACK#: UE5.97 UH1.BB19
SUSCLK: JSSD1.68 JSSD2.68 JSSD3.68 JWLAN.42 UH1.AN15
SUSP#: PR209.2 PR807.2 PR5007.1 Q8.3 R174.1 R182.1 RT15.2 U16.4 U20.4 UE5.116 UZ21.3
SUSP#_R: RT15.1 RT30.2 UT1.D2
SW_1.2V: PC204.2 PL201.2 PQ200.1 PQ200.2 PQ200.3 PQ201.5 PR202.1 PU201.16
SW_+1VALWP: PC305.2 PL300.1 PQ300.1 PQ300.2 PQ300.3 PQ301.5 PR305.1 PU300.8
SW_USB20_N1: LU3.1 UU1.11
SW_USB20_P1: LU3.4 UU1.10
SYNC_OUT: TC24.1(TP-1) UA4.38
SYS_PEX_RST_MON#: DG1.2 RG21.1 RG537.2 UG9.BE2
SYS_PWROK: CE46.1 UE5.74 UH1.AY1
SYS_RESET#: CH175.1 RH5.2 RH571.1 UH1.AW1
SYSON: CE42.1 PR208.1 Q9.3 U19.4 UE5.95
TB_STAT#_CHG: PQ705.2 PR718.1 PU700.16
TBT_A_AUX_N: CT44.2 UT1.W15
TBT_A_AUX_N_C: CT44.1 RT70.2 UT4.J2
TBT_A_AUX_P: CT43.2 UT1.Y15
TBT_A_AUX_P_C: CT43.1 RT73.1 UT4.J1
TBT_A_USB20_L_NB: DT10.4 DT10.7 JUSBC1.B7 LT3.3
TBT_A_USB20_L_NT: DT10.2 DT10.8 JUSBC1.A7 LT2.2
TBT_A_USB20_L_PB: DT10.5 DT10.6 JUSBC1.B6 LT3.2
TBT_A_USB20_L_PT: DT10.1 DT10.9 JUSBC1.A6 LT2.3
TBT_A_USB20_N: UT1.D20 UT4.K5
TBT_A_USB20_NB: LT3.4 UT4.L7
TBT_A_USB20_NT: LT2.1 UT4.L6
TBT_A_USB20_P: UT1.E20 UT4.L5
TBT_A_USB20_PB: LT3.1 UT4.K7
TBT_A_USB20_PT: LT2.4 UT4.K6
TBT_CIO_PLUG_EVENT#: RT29.2 UH1.AN43 UT1.W2
TBT_EE_CLK: RT101.1 UT1.AB4 UT2.6
TBT_EE_CS_N: RT50.2 RT100.1 UT1.AC3 UT2.1
TBT_EE_DI: RT98.1 UT1.AB3 UT2.5
TBT_EE_DO: RT49.1 RT99.1 UT1.AC4 UT2.2
TBT_EE_WP_N: RT48.2 UT1.V1 UT2.3
TBT_FORCE_PWR: RT13.2 UH1.P43
TBT_FORCE_PWR_R: RT13.1 RT35.1 RT94.2 UT1.H4
TBT_HDMI_DDC_CLK: T9.1(TP-1) UT1.Y2
TBT_HDMI_DDC_DATA: T7.1(TP-1) UT1.Y1
TBT_HOLD_N: RT51.2 UT2.7
TBT_I2C_SCL: RT27.2 UT1.U2 UT4.D2
TBT_I2C_SDA: RT26.2 UT1.U1 UT4.D1
TBT_PCIE_WAKE#: RT10.2 UE5.70
TBT_PCIE_WAKE_N: RT10.1 RT28.2 UT1.W1
TBT_RBIAS: RT25.1 UT1.H6
TBT_RESET_N: RT23.1 RT80.1 RT102.2 UT1.F4
TBT_RESET_N_EC: RT23.2 UE5.15
TBT_RSENSE: RT25.2 UT1.J6
TBT_RST#_R: RT1.2 UT1.L4
TBT_SRC_CFG1: RT11.1 UT1.AA1
TBT_SRC_HPD: RT4.1 UT1.G1
TBT_SVR_IND: LT1.1 UT1.C1 UT1.C2 UT1.D1
TBT_TCK: RT7.2 UT1.T4
TBT_TDI: RT9.2 UT1.Y4
TBT_TDO: RT6.2 UT1.W4
TBT_TEST_EN: RT17.1 UT1.E1
TBT_TEST_PWG: RT18.1 UT1.AB5
TBT_TMS: RT8.2 UT1.V4
TBT_TMU_CLK_OUT: RT34.1 T2.1(TP-1) UT1.V2
TBT_XTAL_25_IN: CT37.1 UT1.D22 YT1.1
TBT_XTAL_25_OUT: CT38.1 UT1.D23 YT1.3
TBTA_CC1: CT112.1 DT11.1 JUSBC1.A5 UT4.L9
TBTA_CC2: CT113.1 DT12.1 JUSBC1.B5 UT4.L10
TBTA_DEBUG1: RT71.1 UT4.L2
TBTA_DEBUG2: RT72.1 UT4.K2
TBTA_DIG_AUD_N: RT69.1 UT4.K3
TBTA_DIG_AUD_P: RT68.1 UT4.L3
TBTA_HPD: RT41.1 UT1.M4 UT4.C10
TBTA_I2C_INT: RT32.2 UT1.J4 UT4.C1
TBTA_I2C_SCL1_R: RT57.2 RT60.2 UT4.B5
TBTA_I2C_SDA1_R: RT58.2 RT59.2 UT4.A5
TBTA_LDO_BMC: CT98.1 UT4.E1
TBTA_LSRX: RT42.1 UT1.A4 UT4.K4
TBTA_LSTX: RT21.2 RT40.1 UT1.A5 UT4.L4
TBTA_MRESET: RT63.1 UT4.E11
TBTA_ROSC: RT75.1 UT4.G2
TBTA_SBU1: DT13.1 JUSBC1.A8 UT4.K8
TBTA_SBU2: DT14.1 JUSBC1.B8 UT4.L8
TBTB_I2C_INT: RT33.2 UT1.E2
THERMDA: UT1.AB23 UT1.AC23
TMDS_C_TX0N: CV1060.1 LV4.1 RV643.1 RX31.1
TMDS_C_TX0P: CV1059.1 LV4.4 RV646.1 RX32.1
TMDS_C_TX1N: CV1062.1 LV5.1 RV642.1 RX35.1
TMDS_C_TX1P: CV1061.1 LV5.4 RV639.1 RX36.1
TMDS_C_TX2N: CV1064.1 LV6.1 RV645.1 RX37.1
TMDS_C_TX2P: CV1063.1 LV6.4 RV638.1 RX38.1
TMDS_C_TXCN: CV1057.1 LV3.1 RV641.1 RX33.1
TMDS_C_TXCP: CV1058.1 LV3.4 RV640.1 RX34.1
TMDS_CTRLCLK_R: JHDMI.15 RV651.1
TMDS_CTRLDAT_R: JHDMI.16 RV650.1
TMDS_L_TX0N: LV4.2 RV27.1 RV501.2 RV643.2
TMDS_L_TX0P: LV4.3 RV28.1 RV501.1 RV646.2
TMDS_L_TX1N: LV5.2 RV29.1 RV502.2 RV642.2
TMDS_L_TX1P: LV5.3 RV30.1 RV502.1 RV639.2
TMDS_L_TX2N: LV6.2 RV33.1 RV503.2 RV645.2
TMDS_L_TX2P: LV6.3 RV34.1 RV503.1 RV638.2
TMDS_L_TXCN: LV3.2 RV500.2 RV641.2 RV673.1
TMDS_L_TXCP: LV3.3 RV500.1 RV640.2 RV674.1
TMDS_R_TX0N: JHDMI.9 RV27.2
TMDS_R_TX0P: JHDMI.7 RV28.2
TMDS_R_TX1N: JHDMI.6 RV29.2
TMDS_R_TX1P: JHDMI.4 RV30.2
TMDS_R_TX2N: JHDMI.3 RV33.2
TMDS_R_TX2P: JHDMI.1 RV34.2
TMDS_R_TXCN: JHDMI.12 RV673.2
TMDS_R_TXCP: JHDMI.10 RV674.2
TMDS_SCLF: QV96.3 RV649.1 RV651.2
TMDS_SDAF: QV96.6 RV650.2 RV653.1
TMDS_TX0N: CV1060.2 UG9.BF18
TMDS_TX0P: CV1059.2 UG9.BG18
TMDS_TX1N: CV1062.2 UG9.BG20
TMDS_TX1P: CV1061.2 UG9.BH20
TMDS_TX2N: CV1064.2 UG9.BF20
TMDS_TX2P: CV1063.2 UG9.BE20
TMDS_TXCN: CV1057.2 UG9.BF17
TMDS_TXCP: CV1058.2 UG9.BE17
TOBII_INT: JTOBII.6 RE300.1 RE651.2
TOBII_PWR_EN#: CE79.1 RE652.2 UE6.17 UE12.4
TON_1.2V: PR206.2 PU201.9
TP_CLK: JTP.12 RE100.2 UE5.87
TP_DATA: JTP.13 RE101.2 UE5.88
TP_LED_B#: Q28.5 R146.2 UE3.14
TP_LED_B#_DRV: Q28.2 Q28.3 R144.2
TP_LED_B#_DRV#: JTP.3 Q28.6
TP_LED_EN: Q2410.2 UE5.25
TP_LED_G#: Q29.5 R154.2 UE3.11
TP_LED_G#_DRV: Q29.2 Q29.3 R150.2
TP_LED_G#_DRV#: JTP.4 Q29.6
TP_LED_R#: Q34.5 R147.2 UE3.10
TP_LED_R#_DRV: Q34.2 Q34.3 R145.2
TP_LED_R#_DRV#: JTP.5 Q34.6
TRIP_+1VALWP: PR303.2 PU300.2
TRONL_LED_B_DRV#: JTRONL.5 JTRONL.10 UE8.5
TRONL_LED_G_DRV#: JTRONL.4 JTRONL.9 UE8.4
TRONL_LED_R_DRV#: JTRONL.3 JTRONL.8 UE8.3
TRONR_LED_B_DRV#: JTRONR.5 JTRONR.10 UE8.9
TRONR_LED_G_DRV#: JTRONR.4 JTRONR.9 UE8.8
TRONR_LED_R_DRV#: JTRONR.3 JTRONR.8 UE8.6
TS_EN: JEDP.34 UE6.14
TYPEC_DET#: QU1.1 RU26.2 UE10.18
UART_2_CCTS_DRTS: RC65.1 UH1.AN44
UART_2_CRXD_DTXD: JWDB.3 RC62.1 UH1.AR45
UART_2_CTXD_DRXD: JWDB.2 RC63.1 UH1.AR39
UG_3V: PQ100.4 PU100.10
UG_5V: PQ102.4 PU100.16
UG_+1VALWP: PQ300.4 PU300.9
USB2_COMP: RH109.1 UH1.AG3
USB3_A_TRX_DTX_N0: DT5.1 JUSBC1.B10 UT1.A21
USB3_A_TRX_DTX_N1: DT9.1 JUSBC1.A10 UT1.B15
USB3_A_TRX_DTX_P0: DT4.1 JUSBC1.B11 UT1.B21
USB3_A_TRX_DTX_P1: DT8.1 JUSBC1.A11 UT1.A15
USB3_A_TTX_C_DRX_N0: CT42.1 DT3.1 JUSBC1.A3
USB3_A_TTX_C_DRX_N1: CT40.1 DT7.1 JUSBC1.B3
USB3_A_TTX_C_DRX_P0: CT41.1 DT2.1 JUSBC1.A2
USB3_A_TTX_C_DRX_P1: CT39.1 DT6.1 JUSBC1.B2
USB3_A_TTX_DRX_N0: CT42.2 UT1.B19
USB3_A_TTX_DRX_N1: CT40.2 UT1.B17
USB3_A_TTX_DRX_P0: CT41.2 UT1.A19
USB3_A_TTX_DRX_P1: CT39.2 UT1.A17
USB3_CC1: DU20.2 JUSBC2.A5 UU7.11
USB3_CC2: DU20.3 JUSBC2.B5 UU7.13
USB3_CRX_L_DTX_N1: DU2.1 DU2.9 JUSB1.5 LU5.2
USB3_CRX_L_DTX_N2: DU12.4 DU12.7 JUSBC2.B10 LU8.2
USB3_CRX_L_DTX_N5: DU13.1 DU13.9 JUSBC2.A10 LU11.3
USB3_CRX_L_DTX_P1: DU2.2 DU2.8 JUSB1.6 LU5.3
USB3_CRX_L_DTX_P2: DU12.5 DU12.6 JUSBC2.B11 LU8.3
USB3_CRX_L_DTX_P5: DU13.2 DU13.8 JUSBC2.A11 LU11.2
USB3_CTX_C_DRX_N1: CU13.1 LU4.1
USB3_CTX_C_DRX_N2: CU30.1 LU7.1
USB3_CTX_C_DRX_N5: CU38.1 LU10.4
USB3_CTX_C_DRX_P1: CU12.1 LU4.4
USB3_CTX_C_DRX_P2: CU31.1 LU7.4
USB3_CTX_C_DRX_P5: CU39.1 LU10.1
USB3_CTX_C_L_DRX_N1: DU2.4 DU2.7 JUSB1.8 LU4.2
USB3_CTX_C_L_DRX_N2: DU12.1 DU12.9 JUSBC2.A3 LU7.2
USB3_CTX_C_L_DRX_N5: DU13.4 DU13.7 JUSBC2.B3 LU10.3
USB3_CTX_C_L_DRX_P1: DU2.5 DU2.6 JUSB1.9 LU4.3
USB3_CTX_C_L_DRX_P2: DU12.2 DU12.8 JUSBC2.A2 LU7.3
USB3_CTX_C_L_DRX_P5: DU13.5 DU13.6 JUSBC2.B2 LU10.2
USB3_RUF1: DU21.2 JUSBC2.A8
USB3_RUF2: DU21.3 JUSBC2.B8
USB3RN1: LU5.1 UH1.B7
USB3RN2: LU8.1 UH1.C8
USB3RN3: CI38.1 UH1.B10
USB3RN3_C: CI38.2 JCDRA.36
USB3RN4: JIO.26 UH1.E11
USB3RN5: LU11.4 UH1.G13
USB3RP1: LU5.4 UH1.A7
USB3RP2: LU8.4 UH1.B8
USB3RP3: CI39.1 UH1.A9
USB3RP3_C: CI39.2 JCDRA.37
USB3RP4: JIO.27 UH1.G11
USB3RP5: LU11.1 UH1.H13
USB3TN1: CU13.2 UH1.C11
USB3TN2: CU30.2 UH1.B12
USB3TN3: JCDRA.42 UH1.C13
USB3TN4: JIO.29 UH1.A14
USB3TN5: CU38.2 UH1.B14
USB3TP1: CU12.2 UH1.B11
USB3TP2: CU31.2 UH1.A12
USB3TP3: JCDRA.43 UH1.D13
USB3TP4: JIO.30 UH1.B13
USB3TP5: CU39.2 UH1.C14
USB20_CAM_N7_R: DV4.3 JEDP.19 LV2.2
USB20_CAM_P7_R: DV4.2 JEDP.20 LV2.3
USB20_N1: UH1.AF5 UU1.2
USB20_N1_CONN: DU1.2 JUSB1.2 LU3.2
USB20_N2: JIO.23 UH1.AD5
USB20_N3: LM1.1 UH1.AG8
USB20_N3_CONN: JCDRA.40 LM1.2
USB20_N4: UE1.5 UH1.AE1
USB20_N5: JWLAN.5 UH1.AC2
USB20_N6: DV2.3 JEDP.17 UH1.AF2
USB20_N7: LV2.1 UH1.AB3
USB20_N8: LU9.4 UH1.AL8
USB20_N8_CONN: DU11.3 JUSBC2.A7 JUSBC2.B7 LU9.3
USB20_N9: LE3.1 RE647.1 UH1.AA1
USB20_N9_L: DV14.2 JTOBII.3 LE3.2 RE647.2
USB20_P1: UH1.AG7 UU1.3
USB20_P1_CONN: DU1.3 JUSB1.3 LU3.3
USB20_P2: JIO.24 UH1.AD7
USB20_P3: LM1.4 UH1.AG10
USB20_P3_CONN: JCDRA.39 LM1.3
USB20_P4: UE1.4 UH1.AE2
USB20_P5: JWLAN.3 UH1.AC3
USB20_P6: DV2.2 JEDP.18 UH1.AF3
USB20_P7: LV2.4 UH1.AB2
USB20_P8: LU9.1 UH1.AL7
USB20_P8_CONN: DU11.2 JUSBC2.A6 JUSBC2.B6 LU9.2
USB20_P9: LE3.4 RE648.1 UH1.AA2
USB20_P9_L: DV14.3 JTOBII.4 LE3.3 RE648.2
USB_OC0#: RPH6.4 UH1.AD43 UU1.13
USB_OC1#: CU17.1 RPH6.3 UH1.AD42 UU3.3
USB_OC2#: RPH6.1 UH1.AD39
USB_OC3#: RPH6.2 UH1.AC44
USB_PWR_EN: CU16.1 RE645.2 UE5.117 UU3.4
USBC_PWR_EN: CU35.1 RE649.2 UE10.5 UU7.6
USBCHG_DET#: CU27.2 CU28.1 DU6.2 JUSB1.10 RU4.2
USBCHG_DET_D: PD100.3 RU6.1 UU5.4
USBCHG_DET_EC#: CU29.1 DU6.1 RU6.2 UE5.75
VCIN0_PH1: PH1.1 PR24.1 PR25.1 UE5.109
VCIN1_AC_IN: CE40.2 DH1.1 PR714.2 PR715.1 PR731.1 PU700.5 QE3.5 UE5.110
VCIN1_ADP_PROCHOT: PC13.2 PR23.1 PR26.2 UE5.102
VCIN_ BATT_TEMP: CE35.2 PC14.1 PD3.2 PR16.1 PR22.2 PR727.1 UE5.63
VCOUT0_MAIN_PWR_ON#: PR114.1 UE5.104
VCOUT1_PROCHOT#: RE84.2 RE85.2 UE5.103
VD33STB: RA25.2 UA1.10
VGA_EN: RM14.2 RM87.1 UM8.26
VGA_SMB_CK2: QG6.4 RG17.1 UG9.BJ8
VGA_SMB_DA2: QG6.1 RG18.1 UG9.BH8
VL: PC111.1 PU100.13
VR_HOT#: PC501.1 PR504.1 RE78.1
VR_PWRGD: PR520.1 UE5.101
VR_SVID_ALERT#: PR509.2 RH152.2 RH153.1
VR_SVID_CLK: CPU1.BH32 PR507.1
VR_SVID_DATA: CPU1.BH29 PR511.2 RH151.2
VROM_SEL: RH588.2 RH589.2 UG16.7 UG16.10 UH1.BC27
VSB_N_001: PC10.2 PQ3.3 PR12.2 PR13.2
VSB_N_002: PC12.1 PQ4.2 PR17.1
VSB_N_003: PQ4.1 PR13.1
VSENSEN_L: RA61.2 RA79.1 UA4.27
VSENSEN_R: RA65.2 RA82.1 UA4.30
VTTREF_1.2V: PC210.1 PU201.4
WAKE#: RH4.2 RH453.1 UH1.BC13
WAKE_PCH#: RH545.1 UH1.BD11
WL_OFF#: RH520.2 RN15.2 UH1.AU44
WL_OFF#_R: CN9.1 JWLAN.48 RN5.2 RN15.1
WOOFER_SEL: JIO.21 UE10.7
XCLK_BIASREF: RH71.2 UH1.E1
XDP_BPM#0: CPU1.BR27 T112.1(TP-1)
XDP_BPM#1: CPU1.BT27 T113.1(TP-1)
XDP_HOOK0: JPCMC.27 RC355.1
XDP_ITP_PMODE: JPCMC.26 RC353.2 UH1.AT2
XDP_PRDY#: CPU1.BP27 JPCMC.34 UH1.AT4
XDP_PREQ#: CPU1.BL30 JPCMC.33 RH156.2 UH1.AT3
XDP_SPI_IO2: JPCMC.24 RC354.1
XDP_SPI_SI: JPCMC.25 RC9.2 RH1.1
XDP_TCK: JPCMC.31 RC348.1 UH1.AN3
XDP_TDI: CPU1.BL32 JPCMC.29 RH495.2 UH1.AP2
XDP_TDO: CPU1.BT28 JPCMC.35 RH496.2 UH1.AP1
XDP_TMS: CPU1.BP28 JPCMC.30 RH494.2 UH1.AR2
XMP1: PR212.1 UH1.BD22
XMP2: PR214.1 UH1.BE21
XTAL24_IN: CH47.1 RH72.1 UH1.A6 YH2.1
XTAL24_OUT: CH48.1 RH72.2 UH1.A5 YH2.3
XTALIN: CG75.2 RG99.1 UG9.BL6 YG1.1
XTALOUT: CG76.2 RG99.2 UG9.BM6 YG1.3
XTALOUTBUFF_R: RG98.1 UG9.BK6
XTLI: CL8.2 UL1.8 YL1.1
XTLO: CL9.2 UL1.7 YL1.3
N3691692: PC305.1 PR302.2
N3691782: PC309.1 PR305.2
N4123408: PC105.2 PR108.1
N4123550: PC109.1 PR110.2
N4123582: PC110.1 PR111.2
N4124695: PC106.1 PR109.2
N16758539: PC6416.1 PR6400.2 PU6400.18
N16760382: PR6414.2 PR6415.2 PU6400.11
N16761462: PC6437.1 PR6417.1 PR6418.1 PU6400.7
N16767833: PC112.1 PR100.2 PR112.2 PR113.2 PR114.2 PR115.2 PR116.1
N16767857: PD101.1 PR115.1
N16768121: PD100.1 PR113.1
N16788038: PC701.2 PC722.2 PC723.2 PQ700.1 PQ702.4 PQ708.4 PR705.1 PR725.2 PR726.2
N16788064: PQ700.2 PR700.2 PR701.1
N16857461: DS1.1 QS3.1
N16910514: PC6439.1 PR6416.2 PR6417.2 PR6426.2
N17186119: PR6421.2 PU6400.10
N17230071: PC6423.2 PR6405.2
N17230179: PC6415.2 PR6407.2
N17235867: PR6412.2 PU6400.5
N17244731: PD1.2 PL2.1 PQ7.1 PR6.2
N17244796: PR6418.2 PR6423.1
N17249165: PC6434.1 PR6415.1 PR6422.2
N17249236: PC6434.2 PR6414.1
N17431129: CE36.1 RE89.1
N17434554: RE74.2 UE5.107
N18168284: PC207.2 PR204.2 PU201.12
N18249914: CH3.1 RH6.2 UH1.V28
N18250394: CH4.1 RH7.2 UH1.BA15
N18456729: PR722.1 PU700.20
N18456733: PR723.1 PU700.19
N18456739: PQ705.3 PR709.1 PR711.1 PU700.21
N18456772: PC711.2 PR707.2 PU700.28
N18456789: PD700.1 PR707.1
N18456799: PR724.2 PU700.10
N18456859: PC702.2 PR708.1
N18456884: PC718.2 PR717.1 PU700.7
N18456888: PC720.2 PU700.8
N18456944: PQ705.1 PR710.2
N18456952: PR720.2 PU700.11
N18456954: PR721.2 PU700.12
N18468008: RH9.1 RH656.2 RH657.2 UH1.BD7
N18650921: RV634.2 UV21.59
N18651247: RV635.2 UV21.58
N18786622: CPU1.BT2 T44.1(TP-1)
N18786625: CPU1.BR1 T43.1(TP-1)
N18786626: CPU1.E3 T41.1(TP-1)
N18786627: CPU1.BJ33 T82.1(TP-1)
N18786629: CPU1.B2 T85.1(TP-1)
N18786630: CPU1.BR2 T88.1(TP-1)
N18786631: CPU1.BJ34 T81.1(TP-1)
N18786633: CPU1.C1 T89.1(TP-1)
N18786635: CPU1.BJ16 T73.1(TP-1)
N18786636: CPU1.BK16 T74.1(TP-1)
N18786637: CPU1.BK24 T75.1(TP-1)
N18786638: CPU1.BJ24 T76.1(TP-1)
N18786639: CPU1.BM33 T66.1(TP-1)
N18786640: CPU1.BJ14 T68.1(TP-1)
N18786641: CPU1.BJ13 T69.1(TP-1)
N18786642: CPU1.BL33 T67.1(TP-1)
N18786644: CPU1.J23 RH192.2
N18786646: CPU1.H23 RH167.2
N19499560: CA51.2 UA2.B3
N19499567: RA46.2 UA2.A1
N19499569: RA47.2 UA2.A3
N19500898: RA39.2 UA3.A3
N19500900: RA38.2 UA3.A1
N19500925: CA44.2 UA3.B3
N19501351: CA18.1 RA10.2
N19501355: CA11.1 RA2.2
N19501476: CA21.1 UA1.27
N19501478: CA21.2 UA1.28
N19501482: CA20.1 UA1.25
N19501484: CA20.2 UA1.26
N19501519: CA23.1 CA85.1 UA1.18
N19501610: RA18.2 UA1.16
N19501675: CA3.1 CA4.1 RA68.1 UA1.46
N19501723: CA7.1 CA8.1 RA69.1 UA1.51
N19501777: CA26.1 CA27.1 UA1.43
N19501783: CA33.1 UA1.41
N19501785: CA30.1 CA31.1 UA1.21
N19501806: CA32.1 UA1.44
N19501856: CA25.1 UA1.29
N19501872: CA24.1 UA1.31
N19501885: CA19.2 UA1.23
N19501890: CA19.1 RA15.2 RA16.1
N19529476: CA74.1 UA4.23
N19529515: CA66.2 UA4.40
N19529521: CA71.2 RA51.2 UA4.3
N19529522: RA51.1 RA52.1 UA4.6
N19529526: CA67.2 UA4.2
N19529527: CA68.2 UA4.50
N19529528: CA69.2 UA4.49
N19529529: CA70.2 UA4.41
N19529531: RA62.2 UA4.5
N19616464: CG230.1 CG231.1 CG232.1 LG4.2 UG9.BC12
N19616930: CG233.1 CG234.1 CG235.1 CG236.1 CG237.1 CG238.1 CG239.1 LG3.2 UG9.AF11 UG9.BB24 UG9.BD12 UG9.U42
N19618056: RG101.1 UG9.BJ6
N19842722: RG130.1 UG5.J13
N19842724: RG126.1 UG5.J1
N19842731: RG128.1 UG5.J10
N19847413: RG120.1 UG4.J13
N19847417: RG116.1 UG4.J1
N19847426: RG118.1 UG4.J10
N19849394: RG119.1 UG3.J13
N19849396: RG115.1 UG3.J1
N19849403: RG117.1 UG3.J10
N19854250: RG109.1 UG2.J13
N19854254: RG105.1 UG2.J1
N19854263: RG107.1 UG2.J10
N19855299: QG2.1 RG111.1
N19856231: RG108.1 UG1.J13
N19856233: RG104.1 UG1.J1
N19856240: RG106.1 UG1.J10
N19942790: CU27.1 DU8.2 RU5.2 UU5.2
N19950372: RU3.2 UU1.16
N19950378: RU2.2 UU1.15
N19950402: RU7.2 UU1.8
N19950406: RU1.2 UU1.4
N20474318: CA90.2 RA76.1
N20474320: CA89.2 RA75.1
N20474322: CA88.2 RA74.1
N20474324: CA87.2 RA73.1
N20758419: RH580.1 UH1.AD10
N20758429: RH581.1 UH1.AG2
N20762834: RH89.2 UH1.BC17
N20904379: RT22.1 UT4.A6 UT4.A7 UT4.A8 UT4.B7
N20905578: CT104.1 UT4.H7
N20905857: RT83.2 UT4.F1
N20960158: QE53.5 RE527.1 RE528.2
N20960615: QE54.2 RE449.2 RE511.1
N20960628: QE39.5 RE455.2 RE456.1
N20960654: QE29.5 RE396.2 RE397.1
N20960689: QE29.2 RE399.2 RE401.1
N20960760: QE39.2 RE453.1 RE454.2
N20960779: QE49.5 RE512.1 RE513.2
N20960882: QE49.2 QE49.3 RE511.2
N20960884: QE40.2 RE458.1 RE460.2
N20960892: QE40.5 RE461.2 RE462.1
N20960976: QE41.2 RE465.1 RE467.2
N20960982: QE41.5 RE466.2 RE468.1
N20960988: QE54.5 RE514.1 RE517.2
N20961029: QE50.5 RE515.1 RE516.2
N20961045: QE50.2 QE50.3 RE514.2
N20961145: QE42.2 RE472.1 RE474.2
N20961166: QE42.5 RE471.2 RE473.1
N20961197: QE43.2 RE479.1 RE480.2
N20961228: QE43.5 RE476.2 RE478.1
N20961244: QE55.2 RE518.1 RE521.2
N20961277: QE51.5 RE519.1 RE520.2
N20961293: QE51.2 QE51.3 RE518.2
N20961336: QE55.5 RE522.1 RE525.2
N20961369: QE52.5 RE523.1 RE524.2
N20961391: QE52.2 QE52.3 RE522.2
N20961418: QE44.2 RE485.1 RE486.2
N20961454: QE44.5 RE482.2 RE484.1
N20961510: QE45.2 RE491.1 RE492.2
N20961531: QE45.5 RE488.2 RE490.1
N20961580: QE46.2 RE496.1 RE498.2
N20961592: QE46.5 RE495.2 RE497.1
N20961638: QE56.2 RE526.1 RE529.2
N20961685: QE53.2 QE53.3 RE526.2
N20961740: QE47.2 RE501.1 RE503.2
N20961750: QE47.5 RE502.2 RE504.1
N20961813: QE48.2 RE508.1 RE510.2
N20961825: QE48.5 RE507.2 RE509.1
N20971521: JLAN.9 RL8.1
N20971565: RL5.1 UL2.3
N20971567: CL31.1 JLAN.12 LL1.2
N20972379: RL2.2 UL1.5
N20972746: QL3.1 RL13.2 RL14.2
N20986399: RE161.1 UE12.3
N20995131: RE25.2 UE3.24
N20995135: RE31.1 UE3.30
N20999302: RM72.1 UM8.27
N20999314: RM61.2 UM8.52
N20999316: RM64.1 RM66.1 UM8.48
N21000707: RM21.2 RM96.2 UM4.1
N21000709: CM99.1 RM28.1 RM29.1
N21000711: CM98.1 RM27.1 RM38.1
N21000719: CM16.1 CM17.1 RM18.2 UM4.20
N21000750: RM25.2 UM4.18
N21000786: RM28.2 UM4.13
N21000788: RM27.2 UM4.14
N21000830: QM1.2 QM2.6 RM92.2
N21000850: QM2.3 QM3.2 RM94.2
N21000877: RM20.2 UM4.4
N21002214: RE14.2 UE2.3
N21002223: CE20.1 RE11.1 UE2.6
N21002224: RE9.1 UE2.5
N21002246: RE13.2 UE2.7
N21002311: RE651.1 UE1.20
N21002312: CE9.1 UE1.19
N21002317: CE18.1 UE1.11
N21002319: CE17.1 UE1.12
N21002321: CE16.1 UE1.13
N21002324: CE15.1 UE1.14
N21002326: CE14.1 UE1.15
N21002328: CE13.1 UE1.16
N21002352: RE10.1 UE2.2
N21002366: DE1.2 RE8.2 UE1.23
N21002397: RE20.1 UE9.3
N21003330: R181.2 U2407.7
N21003701: DF1.1 JFAN1.3 RF3.1
N21003743: DF2.1 JFAN2.3 RF6.1
N21014812: C3.1 UZ21.6
N21181966: CPU1.H13 RH154.2
N21181987: CPU1.BH31 RH153.2
N21182006: CPU1.BR33 RH519.2
N21182008: CPU1.BR30 RH158.2
N21182026: CPU1.BP31 RH155.2
N21185219: RV45.1 UV17.3
N21185406: CV374.1 RV13.2
N21238299: RE166.2 UE8.24
N21238303: RE167.1 UE8.30
N22226841: QV97.5 UX1.4
N22294463: RG157.1 UG7.J13
N22294465: RG158.1 UG7.J1
N22294469: RG159.1 UG7.J10
N22295107: RG162.1 UG8.J13
N22295109: RG161.1 UG8.J1
N22295113: RG163.1 UG8.J10
N24365027: CE63.2 RE530.2 UE10.3
N24371838: JHDMI.13 RV655.2
N24377091: QV97.2 UX2.4
N24377100: QX3.2 RX6.1
N24405043: CV438.1 UV21.47
N24405047: RV24.1 UV21.34
N24405061: QV95.1 RV25.1 RV26.2 UV21.50
N24405079: CV439.1 RV26.1
N24654525: C2522.1 J6.2 U18.1
N24654698: R367.1 U18.3
N25131299: QV2.1 RV12.2
N25288706: RG7.1 RG537.1 RG562.1 UG10.4
N25289505: RG26.1 UG9.BK23
N25289690: QG500.5 RG507.1 RG508.1 RG519.1
N25567095: DV13.1 RV653.2
N25567097: DV12.1 RV649.2
N25732286: CG64.1 UG12.12
N25732288: CG65.1 UG12.10
N25769611: QE57.5 RE637.2 RE638.1
N25769633: QE57.3 RE636.2
N25769981: QE57.6 RE639.2
N25769983: QE57.2 RE640.2 RE641.1
N25774735: QG502.6 RG516.2 UG22.2
N25802636: RG65.2 UG11.5
N25802642: QG5.3 RG63.2 RG529.2 UG11.8
N25805684: RG19.1 UG9.BG8
N25805686: RG20.1 UG9.BF8
N25867602: QE13.6 RE160.2
N25867965: QE21.6 RE155.2
N25868866: QE22.6 RE157.2
N26196167: RE646.2 UE5.2
N26590619: RU15.1 UU7.1
N26590621: RU16.1 UU7.20
N26590623: RU17.1 UU7.16
N26590625: RU20.1 UU7.19
N26590627: RU19.1 UU7.18
N26590629: RU18.1 UU7.17
N26590633: CU33.1 CU34.1 CU42.1 CU44.1 RU12.2 RU21.1 RU23.1 UU7.2 UU7.3 UU7.4 UU7.5
N26590645: RU14.1 UU7.9
N26590649: RU23.2 UU7.8
N26590685: RU14.2 UU7.10
N26590716: RU21.2 UU7.7
N27238854: RV671.1 UV3.9
N27238870: RV672.1 UV3.12
N27472757: QG510.2 RG1.1
N28080092: CG313.1 RG102.2 RG523.2
N28084182: CG314.1 RG103.2 RG524.2
N28087019: CG315.1 RG113.2 RG525.2
N28087890: CG316.1 RG114.2 RG526.2
N28090623: CG317.1 RG124.2 RG527.2
N28092415: CG318.1 RG125.2 RG528.2
N28094238: CG387.1 RG160.2 RG531.2
N28096445: CG388.1 RG164.2 RG532.2
N28329347: QG8.1 RG156.1
N28330529: QG4.1 RG133.1
N28331699: QG3.1 RG122.1
N29076894: QG500.6 RG530.2 RG540.2
N29125650: RG529.1 UG11.9
N29389682: RE32.2 UE4.24
N29389707: RE37.1 UE4.30
N29418337: PC508.2 PR525.1
N29418339: PR522.1 PR525.2 PR531.1 PU500.5
N29418355: PC533.2 PR546.2
N29418359: PR546.1 PR549.1 PR550.2 PU500.17
N29418369: PC514.1 PR532.2
N29418371: PC5011.2 PH504.2 PR545.1 PR547.2
N29418373: PR532.1 PR533.1 PR536.1 PU500.30
N29418377: PR545.2 PU500.15
N29418393: PC5010.2 PH500.2 PR513.2 PR514.1
N29418395: PR514.2 PU500.3
N29418397: PC505.2 PR521.2 PU500.4
N29418405: PR527.1 PU500.36
N29418417: PC509.2 PR524.1 PU500.33
N29418423: PC520.2 PR537.1 PU500.29
N29418425: PC519.1 PR539.1 PU500.28
N29418433: PR515.2 PR520.2 PU500.47
N29418441: PR518.1 PU500.40
N29418445: PR517.1 PU500.39
N29418451: PR516.1 PU500.38
N29418455: PR519.1 PU500.37
N29418473: PC536.1 PR551.1 PU500.16
N29418487: PC504.1 PR506.1 PU500.41
N29418491: PR523.2 PU500.48
N29419473: PC500.2 PR500.2 PU500.2
N29419486: PC518.2 PR540.2 PU500.8
N29419576: PC506.2 PR521.1
N29419623: PH502.1 PR534.2
N29419647: PC521.1 PR537.2
N29419655: PC522.1 PR536.2
N29419663: PH501.2 PR530.1
N29419667: PH503.2 PR544.1
N29419693: PC518.1 PR538.2
N29419713: PR526.2 PU500.1
N29419730: PC509.1 PR528.2
N29419832: PC503.1 PR505.2 PU500.42
N29419860: PC535.2 PR548.1 PU500.14
N29419910: PC538.2 PR551.2
N29419918: PC537.1 PR549.2
N29419943: PC532.1 PR541.1 PU500.20
N29419947: PC532.2 PR543.1
N29425467: PL503.2 PR575.1 PR577.2 PR578.1 PU504.11 PU504.12 PU504.13 PU504.14 PU504.15 PU504.16 PU504.17 PU504.18 PU504.19 PU504.20 PU504.21
N29425497: PL502.2 PR565.1 PR567.2 PR568.1 PU503.11 PU503.12 PU503.13 PU503.14 PU503.15 PU503.16 PU503.17 PU503.18 PU503.19 PU503.20 PU503.21
N29425633: PL501.2 PR555.1 PR557.2 PR558.1 PU502.11 PU502.12 PU502.13 PU502.14 PU502.15 PU502.16 PU502.17 PU502.18 PU502.19 PU502.20 PU502.21
N29426641: PR573.2 PU504.1
N29426805: PC548.1 PR555.2
N29426831: PC556.1 PR565.2
N29426855: PC564.1 PR575.2
N29435109: PL508.1 PR5002.1 PR5003.1 PU511.8
N29435333: PL506.2 PR593.1 PR595.2 PR596.1 PU510.11 PU510.12 PU510.13 PU510.14 PU510.15 PU510.16 PU510.17 PU510.18 PU510.19 PU510.20 PU510.21
N29435335: PC587.1 PR5002.2
N29436554: PL505.2 PR584.1 PR586.2 PR587.1 PU507.11 PU507.12 PU507.13 PU507.14 PU507.15 PU507.16 PU507.17 PU507.18 PU507.19 PU507.20 PU507.21
N29436709: PC580.1 PR593.2
N29436789: PC570.1 PR584.2
N29438561: PR512.2 PU500.43
N29438565: PR510.2 PU500.44
N29438567: PR502.2 PR509.1 PR510.1
N29438569: PR501.2 PR507.2 PR508.1
N29438571: PR508.2 PU500.45
N29438583: PR503.2 PR511.1 PR512.1
N29438934: PR504.2 PU500.46
N29599145: PC507.1 PR522.2
N29647096: QU1.2 RU24.2 RU25.1
N29700600: RG535.2 UG24.2 UG24.3
N29702846: LX8.1 RX38.2
N29702855: LX7.1 RX37.2
N29702861: LX6.1 RX36.2
N29702867: LX5.1 RX35.2
N29702873: LX4.1 RX34.2
N29702889: LX3.1 RX33.2
N29702919: LX2.1 RX32.2
N29702925: LX1.1 RX31.2
N30005754: CH70.1 UH1.BA26
N30070819: RG131.1 UG6.J13
N30070822: RG127.1 UG6.J1
N30070830: RG129.1 UG6.J10
N30712936: PR727.2 PU700.15
N30746783: PR210.2 PU201.10
N30816588: RA84.1 RA85.1 UA2.B2
N30963031: QG503.5 QG503.6 RG509.2
N30963037: QG503.3 RG510.2
N30963062: QG504.5 QG504.6 RG511.2
N30963079: QG504.3 RG512.2
N30963101: QG505.5 QG505.6 RG513.2
N30963122: QG505.3 RG514.2
N30964064: QG507.5 QG507.6 RG541.2
N30964087: QG507.3 RG542.2
N31077401: PQ710.3 PR732.2
N31077403: PQ710.5 PQ710.6 PR729.1 PR730.2
N31077444: PC724.1 PQ710.2 PR731.2
N31201664: RG545.1 UG26.4
N31204217: RG533.2 UG23.2 UG23.3
N31214366: QG502.2 RG553.2
N31214429: RG554.1 UG22.4
N31214439: QG502.5 RG554.2
N31227786: QG508.5 QG508.6 RG543.2
N31227804: QG508.3 RG544.2
N31306212: PR5006.2 PU511.1
N31425872: PC541.2 PU502.5
N31425874: PC541.1 PR554.1
N31425876: PR554.2 PU502.7
N31426231: PR552.2 PU502.1
N31426252: PR556.2 PU502.2
N31426527: PC5005.1 PR5028.2 PU502.24
N31427446: PC540.2 PR553.1 PU502.3
N31433757: PC550.1 PR564.1
N31433760: PC550.2 PU503.5
N31433761: PR564.2 PU503.7
N31434994: PR566.2 PU503.2
N31435092: PR563.2 PU503.1
N31436196: PC558.1 PR574.1
N31436215: PC558.2 PU504.5
N31436218: PR574.2 PU504.7
N31436380: PR576.2 PU504.2
N31438582: PC5007.1 PR5030.2 PU504.24
N31438896: PC557.2 PR5020.1 PU504.3
N31439632: PC567.1 PR583.1
N31439637: PC8217.1 PR8208.2 PR8211.1 PR8215.2 PR8218.2 PU8200.7
N31439653: PC567.2 PU507.5
N31439658: PR583.2 PU507.7
N31439736: PR585.2 PU507.2
N31439790: PR590.2 PU507.1
N31442956: PC566.2 PR5022.1 PU507.3
N31442990: PC5008.1 PR5031.2 PU507.24
N31443441: PC549.2 PR5004.1 PU503.3
N31452286: PC574.2 PU510.5
N31452288: PC574.1 PR592.1
N31452290: PR592.2 PU510.7
N31452345: PR591.2 PU510.1
N31452390: PR594.2 PU510.2
N31459506: PC573.2 PR5024.1 PU510.3
N31460044: PC5009.1 PR5032.2 PU510.24
N31470989: PC725.1 PQ703.4 PR733.1
N31483113: PC8222.1 PQ8202.2 PR8214.2
N31483116: PQ8202.3 PR8215.1
N31483118: PQ8202.5 PQ8202.6 PR8220.2
N31487005: PC822.1 PU802.16 PU802.17
N31487055: PC810.2 PC814.2 PJP802.2 PU802.2 PU802.3 PU802.4 PU802.5
N31487101: PR814.1 PR815.2 PU802.13
N31487107: PC823.1 PR816.2
N31487111: PR816.1 PU802.1
N31494164: PC586.1 PR5005.1
N31494196: PC586.2 PU511.4
N31494209: PR5005.2 PU511.5
N31494627: PR5001.1 PU511.12
N31495785: PC588.2 PR5025.1 PU511.2
N31495969: PC5002.2 PR5026.2 PU511.11
N31535656: PR107.1 PU100.19
N31565200: PR599.1 PU502.26
N31565645: PR5011.1 PU503.26
N31565698: PC5006.1 PR5029.2 PU503.24
N31566286: PR5019.1 PU504.26
N31567454: PR5021.1 PU507.26
N31567631: PR5023.1 PU510.26
N31787119: PC6102.1 PR6107.1
N31800685: PQ701.4 PR725.1
N31813250: PQ707.4 PR726.1
N32073814: PC8215.1 PR8208.1 PU8200.8
N32074224: PC8210.1 PR8204.2
N32074541: PC8219.1 PR8210.2
N32209563: PC1305.2 PR1304.2 PR1305.1 PU1300.7
N32209746: PR1300.2 PU1300.1
N32274706: PL6401.1 PQ6402.7 PQ6403.7 PR6424.1 PR6432.2 PR6433.1
N32274716: PQ6402.1 PQ6403.1 PR6431.2 PR6433.2
N32295361: PL6400.1 PQ6400.7 PQ6401.7 PR6409.1 PR6428.2 PR6430.1
N32295402: PQ6400.1 PQ6401.1 PR6429.2 PR6430.2
N32424441: PC800.2 PJ800.2 PU800.2 PU800.3 PU800.4 PU800.5
N32424557: PR812.1 PR813.2 PU800.13
N32424758: PC803.1 PU800.16 PU800.17
N32424883: PC808.1 PR806.2
N32424887: PR806.1 PU800.1
N32425629: PC807.1 PU509.16 PU509.17
N32425635: PC818.2 PR5012.2 PR5015.1 PU509.14
N32425773: PR5012.1 PR5014.2 PR5017.1
N32425904: PR5033.1 PR5034.2 PU509.13
N32426094: PC590.1 PR5007.2 PR5008.1 PU509.11
N32426131: PC593.1 PR5010.2
N32548345: RG1.2 UG29.4
N32794300: PR6202.1 PU6200.2
N32795713: PC6203.1 PR6204.2 PU6200.24
N32805176: PC6015.1 PR6040.2 PR6045.2 PR6063.2
N32805666: PC6001.1 PR6007.2 PU6000.25
N32805668: PR6005.2 PR6007.1
N32805796: PC6005.1 PC6007.1 PR6019.1 PR6022.2
N32805986: PC6017.2 PR6016.1 PR6018.1
N32806265: PC6011.2 PR6022.1 PR6024.1 PU6000.31
N32806285: PC6009.1 PC6010.2 PR6021.1 PR6023.1 PR6024.2 PR6068.1
N32806326: PC6005.2 PR6017.2
N32806527: PR6031.2 PR6038.2
N32806709: PR6015.1 PR6016.2
N32856423: PR6205.2 PU6200.5
N32856454: PC6202.2 PU6200.7
N32856474: PC6202.1 PR6205.1
N32858912: PR6201.1 PU6200.26
N32868428: PR6212.2 PU6201.5
N32868434: PC6215.2 PU6201.7
N32868438: PC6215.1 PR6212.1
N32868572: PC6216.1 PR6211.2 PU6201.24
N32868706: PR6208.1 PU6201.26
N32868738: PR6209.1 PU6201.2
N32872459: PR6114.2 PU6101.5
N32872467: PC6115.2 PU6101.7
N32872469: PC6115.1 PR6114.1
N32872562: PC6116.1 PR6113.2 PU6101.24
N32872704: PR6110.1 PU6101.26
N32872742: PR6111.1 PU6101.2
N32872879: PR6107.2 PU6100.5
N32872885: PC6102.2 PU6100.7
N32873027: PC6103.1 PR6106.2 PU6100.24
N32873161: PR6103.1 PU6100.26
N32873197: PR6104.1 PU6100.2
N32889750: PR6053.2 PR6061.1
N32890192: PC6016.2 PR6063.1 PU6000.2
N32892915: PC6426.2 PR6411.1
N32894520: PR6419.2 PR6420.1 PU6400.9
N33144860: PC6011.1 PR6068.2
N33334796: PQ8203.5 PQ8203.6 PR6069.2
N33344185: PR205.1 PR207.1 PR213.1 PR215.1 PU201.6
N33410668: PC218.1 PQ202.5 PR214.2
N33410683: PQ202.3 PR215.2
N33410698: PC217.1 PQ202.2 PR212.2
N33410700: PQ202.6 PR213.2
N33549118: RG564.1 UG9.BE5
N40259586: RT108.1 RT109.2 UT4.D6
N41521526: CE51.1 QE2.2 RE85.1
N46084233: QX2.2 RX2.1
N72585933: PC211.1 PR202.2
N121507165: CPU1.BR25 RH57.2
N121507167: CPU1.BP25 RH58.2
N121507169: CPU1.BT29 RH166.2
N124752685: CH101.2 RH211.1
N124753277: CH100.2 RH212.1
N125073340: CPU1.A33 T1.1(TP-1)
N198830997: RV23.2 UV21.48
N210149060: C2506.1 U17.12
N210149650: C2507.1 U17.10
N212152397: JRTC1.1 PR2.2
N213961754: PC14.2 PQ8.2 PR28.2
N321758540: T65.1(TP-1) UT4.C2
N321758730: T62.1(TP-1) UT4.F4
N321759750: T71.1(TP-1) UT4.H6
N321761570: T70.1(TP-1) UT4.D7
N321762300: T120.1(TP-1) UT4.G11
N321762480: T64.1(TP-1) UT4.B2
N321762710: T63.1(TP-1) UT4.G4
N321763770: T114.1(TP-1) UT4.D10
N321764100: T121.1(TP-1) UT4.E10
N321764180: T122.1(TP-1) UT4.G10

Pads without a net: CPU1 A27 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AF29 AF30 AF31 AF32 AF33 AF34 AG13 AG14 AG31 AG32 AG33 AG34 AG35 AG36 AH13 AH14 AH29 AH30 AH31 AH32 AH35 AH36 AJ8 AJ10 AJ11 AJ13 AJ14 AK3 AL1 AL2 AL3 AM10 AM11 AT3 AT5 AT7 AT11 AT13 AU13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B27 B30 B33 B34 B36 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ17 BJ19 BJ20 BJ21 BJ23 BJ26 BJ27 BJ28 BJ35 BJ36 BK17 BK19 BK20 BK21 BK23 BK26 BK27 BK28 BL14 BL15 BL16 BL17 BL18 BL19 BL20 BL21 BL22 BL23 BL24 BL25 BL26 BL27 BL28 BL31 BL34 BM14 BM15 BM16 BM17 BM22 BM24 BM30 BM31 BN1 BN15 BN16 BN17 BN33 BN35 BP1 BP13 BP15 BP16 BP17 BR15 BR16 BR17 BR31 BR35 BT15 BT16 BT17 BT30 C30 C33 C34 C38 D1 D34 E1 E2 E30 E33 F30 F33 G3 G13 H24 J3 J24 N29 R14; FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; JDIMM1 87 88 91 92 95 97 100 101 104 105 134 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 134 162 165; JHDD 7 8 10 11 14 17; JHDMI 14; JIO 2 9; JKB2 1 2; JKBBL 17 18 19 20; JSSD1 5 6 7 8 10 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JSSD2 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JSSD3 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67; JTP 8 9 10; JWLAN 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 24 26 28 34 36 38 40 47 50 51 52 53 54 56 57 58 59 60 62 63 65; PD1 3; PD3 3; PU502 6 22 25 27; PU503 6 22 25 27; PU504 6 22 25 27; PU507 6 22 25 27; PU509 10 12; PU510 6 22 25 27; PU511 9; PU700 13 14; PU800 10 12; PU802 10 12; PU1300 5; PU6000 4 5 6 7 13 14 15; PU6100 6 22 25 27; PU6101 6 22 25 27; PU6200 6 22 25 27; PU6201 6 22 25 27; PU8200 6; QE56 3 4 5; U2407 8 11; UA1 4 8 47 48 49 50; UA4 13 31 32 35 36; UC1 1; UE3 12 13 19 20 21 22 28 29; UE4 12 13 19 20 21 22 28 29; UE5 37; UE6 13 23; UE8 12 13 22 28 29; UE10 13 21; UG1 A5 A10 U5 U10; UG2 A5 A10 U5 U10; UG3 A5 A10 U5 U10; UG4 A5 A10 U5 U10; UG5 A5 A10 U5 U10; UG6 A5 A10 U5 U10; UG7 A5 A10 U5 U10; UG8 A5 A10 U5 U10; UG9 A9 A17 A42 AA44 AC7 AC8 AC9 AD3 AD45 AD46 AF49 AG8 AG9 AG52 AM1 AM2 AM3 AM5 AM6 AM7 AM8 AN1 AN2 AN3 AN6 AN7 AN9 AN44 AR1 AR2 AR3 AR5 AR6 AR7 AR8 AR50 AT1 AT2 AT3 AT6 AT7 AT9 AT44 AT45 AV1 AV2 AV3 AV5 AV6 AV7 AV8 AW1 AW2 AW3 AW6 AW7 AW9 AW47 AW48 B50 BA1 BA2 BA3 BA5 BA6 BA7 BA8 BA9 BB2 BB3 BB6 BB7 BB8 BD4 BD14 BE7 BE12 BE23 BE35 BE38 BF12 BF21 BF23 BF24 BF33 BF35 BF36 BF38 BF39 BG1 BG4 BG6 BG11 BG12 BG21 BG23 BG24 BG33 BG35 BG36 BG38 BG39 BG41 BH6 BH11 BH12 BH23 BH35 BH38 BH41 BJ1 BJ2 BJ9 BJ11 BK11 BK12 BK14 BK18 BK20 BK21 BK36 BK38 BK39 BK41 BK42 BK44 BL11 BL12 BL14 BL18 BL20 BL21 BL36 BL38 BL39 BL41 BL42 BM8 BM9 BM11 BM12 BM20 BM21 BM35 BM36 BM38 BM39 BM41 BM42 C24 C35 D17 D41 E29 F9 F29 F41 G9 G14 G35 G41 H6 H7 H14 H24 H35 J3 J14 J23 J24 J35 J41 J46 J47 M7 M8 M44 M45 P9 P45 U1 V4 V44 V45 Y50; UG11 10 13 16 17; UH1 A16 A21 A39 AA44 AA45 AB13 AB33 AB35 AB36 AB39 AB43 AB44 AC43 AD2 AD3 AD38 AE17 AE44 AE45 AF17 AF41 AG14 AG15 AG39 AG44 AH43 AH44 AJ7 AJ8 AJ11 AJ13 AJ33 AJ35 AJ38 AJ42 AK44 AL27 AL39 AL42 AM43 AM44 AN17 AN24 AN29 AN36 AN42 AR15 AR17 AR19 AR22 AR27 AR29 AR38 AT27 AT31 AT42 AT43 AV2 AV3 AV4 AV13 AV15 AV19 AW2 AW17 AW31 AW33 AW35 B15 B16 B19 B20 B21 B23 B24 B39 BA4 BA33 BA35 BA40 BA41 BB17 BB31 BB33 BB36 BB38 BB41 BC8 BC15 BC18 BC22 BC23 BC26 BC32 BC33 BC35 BC36 BC38 BD1 BD14 BD17 BD18 BD21 BD23 BD24 BD27 BD33 BD34 BD35 BD36 BD38 BD39 BE2 BE5 BE6 BE34 BE39 C15 C19 C20 C23 C24 E17 E20 E41 F41 G15 G17 G19 H15 K13 K15 K17 K22 K24 L17 L22 L24 M44 M45 N2 N3 N29 N31 N42 N43 N44 P1 P2 P3 P24 P27 P29 P31 P44 R2 R3 R4 R11 R13 R24 R27 R36 R39 R41 R42 R43 R44 T44 T45 U2 U3 U13 U35 U36 U39 U41 U42 U43 V1 V2 V44 W2 W3 W7 W10 W11 W13 W39 W43 W44 Y5 Y41 Y43; UL1 24 25 26 28 40; UM4 7 8; UM8 10 11 12 13 15 16 17 18 21 22 23 28 29 30 31 32 33 34 35; US1 2 3; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 J1 J2 L1 L2 N1 N2 R1 R2 V18 W16 W19 Y16 Y19; UT4 A9 B9; UU1 9; UU5 1; UV3 11 14; UV21 22 23 24 25; UV22 12 13 14

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 1045 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 11715 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 97 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 127 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V_B+: length 28.8
  IN3 w0.254: v2(97.42,42.64) 98.18,42.64 101.1,39.72 101.1,29.98 100.85,29.72 91.4,29.72 89.92,31.2 v2(89.92,32.8)
  BOTTOM w0.254: PR206.1 97.37,42.69 v2(97.42,42.64)
  vias: v1(87.77,33.92)
1.8VS_PGOOD: length 1.9
  BOTTOM w0.254: PU802.9 229.17,38.23 228.55,37.6 PR820.1
1V8_AON_EN: length 365
  TOP w0.102: v2(314.61,57.4) 314.66,57.44 UE10.22 ; v2(196.88,115.16) 196.92,115.16 v1(197.58,114.5) 197.98,114.1 197.98,113.67 197.45,113.15 196.1,113.15 195.18,112.23 193.95,112.23 193.82,112.36 190.74,112.36 190.64,112.26 190.64,111.22 190.89,110.97 QG503.2 191.52,110.97 192.13,110.36 192.22,110.36 193.04,109.54 CG487.1
  TOP w0.254: RG552.1 279.22,147.21 278.8,147.21 278.55,147.47 UG25.4 278.55,148.37 278.29,148.62 v2(277.95,148.62)
  IN2 w0.102: v2(196.88,115.16) 196.86,115.18 196.86,116.15 194.85,118.17 194.85,118.7 194.66,118.89 191.44,118.89 191.14,119.19 191.14,119.97 194.12,122.95 195.79,122.95 196.56,122.18 197.64,122.18 198.55,123.09 198.55,126.5 199.08,127.03 204.57,127.03 206.37,128.82 206.37,139.34 211.74,144.71 211.74,150.54 210.82,151.47 210.82,152.46 211.58,153.22 214.56,153.22 215.4,154.06 224.1,154.06 224.67,154.63 231.76,154.63 232.39,155.25 237.31,155.25 238.63,153.93 243,153.93 243.94,154.87 270.88,154.87 274.49,151.26 275.59,151.26 277.19,149.67 277.19,149.37 277.93,148.62 v2(277.95,148.62)
  IN3 w0.102: v2(314.61,57.4) 314.16,56.94 314.16,53.03 312.84,51.71 312.84,49.22 310.27,46.65 310.27,39.72 v2(309.63,39.08)
  IN4 w0.102: v2(309.63,39.08) 309.38,38.83 302.27,38.83 301.06,37.62 299.54,37.62 299,37.08 292.31,37.08 290.3,39.08 281.01,39.08 279.42,37.5 278.58,37.5 277.03,35.94 273.41,35.94 266.38,42.97 260.11,42.97 259.54,43.54 248.64,43.54 247.3,42.2 239.72,42.2 238.56,43.35 234.45,43.35 233.01,41.92 229,41.92 228.86,41.78 225.66,41.78 223.15,44.28 217.5,44.28 216.98,43.76 215.2,43.76 212.65,46.3 211.47,46.3 209.04,48.73 209.04,50.48 205.48,54.04 205.48,62.17 198.91,68.74 191.9,68.74 190.82,69.82 190.82,73.99 190.39,74.42 190.39,79.32 191.32,80.25 191.32,94.44 190.84,94.92 190.84,101.33 192.52,103 192.52,103.64 193.44,104.57 193.44,107.56 195.42,109.54 195.42,112.24 195.99,112.81 197.24,112.81 197.99,113.56 197.99,114.27 197.1,115.16 v2(196.88,115.16)
  BOTTOM w0.102: v2(196.88,115.16) 196.6,115.16 196.1,114.65 RG70.2 195.92,114.27 196.11,114.08 196.11,113.39 196.26,113.24 UG12.3
1V8_ENP:
  vias: v1(227.06,38.73)
1V8_MAIN_EN: length 238.7
  TOP w0.102: v2(197.53,113.82) 197.08,113.37 196,113.37 195.08,112.46 194.05,112.46 193.85,112.65 189.93,112.65 189.31,112.03 187.76,112.03 186.93,111.2 v1(186.93,107.98) 186.93,105.47 188.03,104.36 189.24,104.36 189.54,104.67 QG504.2
  TOP w0.254: RG549.1 280.07,162.78 280.07,162.08 v2(280.24,161.91) ; DG7.2 DG3.2 281.02,170.15 v2(281.02,170.52) ; v2(277.06,165.83) 277.67,165.22 DG6.1 277.43,164.85 RG550.1 ; UG26.2 v2(277.72,152.74)
  IN1 w0.254: v2(277.06,165.83) 277.06,166.99 280.63,170.56 280.99,170.56 v2(281.02,170.52) 281.02,169.41 282.98,167.46 282.98,163.35 282.63,163.01 280.49,163.01 280.24,162.76 v2(280.24,161.91)
  IN2 w0.102: v2(194.88,103.4) 193.13,105.15 193.13,107.89 192.48,108.54 192.48,111.35 193.44,112.31 196.27,112.31 197.53,113.57 v2(197.53,113.82) 197.53,113.93 196.39,115.08 196.39,116.31 194.72,117.98 193.11,117.98 192.42,118.66 191.35,118.66 190.91,119.1 190.91,120.06 194.03,123.18 196,123.18 196.69,122.49 197.62,122.49 198.23,123.1 198.23,126.5 198.98,127.25 204.31,127.25 206.04,128.98 206.04,139.33 211.4,144.69 211.4,150.57 210.59,151.37 210.59,152.55 211.48,153.45 214.46,153.45 215.31,154.29 224,154.29 224.69,154.97 226.89,154.97 227.75,155.82 231.45,155.82 231.51,155.76 238.32,155.76 239.89,154.18 242.93,154.18 243.85,155.1 270.97,155.1 274.58,151.49 276.47,151.49 v2(277.72,152.74)
  IN2 w0.254: v2(280.24,161.91) 280.24,161.42 280.27,161.39 280.27,153.73 280.02,153.47 278.45,153.47 v2(277.72,152.74)
  BOTTOM w0.102: UG12.5 197.06,113.35 v2(197.53,113.82) 197.54,113.81 198.38,113.81 198.48,113.71 RG71.2 ; UG9.BE1 218.74,111.78 218.22,111.78 217.45,112.55 214.31,112.55 213.19,111.43 213.19,109.62 214.35,108.46 214.35,105.32 212.57,103.54 206.01,103.54 205.98,103.51 205.64,103.51 205.62,103.54 205.37,103.54 205.35,103.51 205.01,103.51 204.98,103.54 198.37,103.54 197.93,103.11 195.17,103.11 v2(194.88,103.4)
1V8_MAIN_NVVDD2_EN: length 9.4
  TOP w0.102: UG28.2 v1(280.94,156.77)
  TOP w0.254: v2(279.68,161.18) 277.95,162.91 CG482.1 277.67,163.16 DG6.2 276.87,163.69 RG550.2 ; v2(280.94,159.19) UG28.2
  IN1 w0.254: v2(279.68,161.18) 280.94,159.92 v2(280.94,159.19)
3/5V_B+: length 3.5
  IN1 w0.508: v2(54.49,43.22) 54.49,40.85 v2(54.38,40.74)
  BOTTOM w0.203: v2(54.49,43.22) 54.49,43.41 54.26,43.63 PU100.12
  vias: v1(54.4,38.44) v2(50.85,39.57) v2(51.43,40.15) v2(51.43,39.57) v2(52.02,40.74) v2(52.02,40.15) v2(52.02,39.57) v2(52.6,41.32) v2(52.6,40.74) v2(52.6,40.15) v2(52.6,39.57) v2(53.18,41.32) v2(53.18,40.74) v2(53.18,40.15) v2(53.18,39.57) v2(53.77,41.32) v2(53.77,40.74) v2(53.77,40.15)
3V3_SYS_EN: length 299.9
  TOP w0.102: v2(279.62,155.89) 279.32,155.58 RG545.2
  TOP w0.254: UE10.20 v2(314.44,58.44)
  TOP w0.406: v2(193.18,103.41) 193.18,103.54 193.54,103.91 RG515.2 193.54,104.36 193.23,104.67 QG505.2
  IN3 w0.102: v2(299.91,59.34) 299.88,59.34 299.47,59.74 299.47,70.12 292.41,77.18 292.41,78.86 291.58,79.7 291.58,86.31 289.31,90.97 288.67,92.36 288.39,93.32 287.9,94.82 287.35,96.66 287.07,97.73 286.57,99.77 286.37,100.77 285.79,104 285.67,104.94 285.56,106.21 285.45,107.75 285.44,109.09 285.45,109.88 285.45,139.32 283.82,140.95 280.46,140.95 278.96,142.45 278.96,143.63 277.87,144.73 277.87,146.69 275.45,149.11 275.45,152.53 278.8,155.89 v2(279.62,155.89)
  IN6 w0.254: v2(229.65,50.67) 229.86,50.45 232.22,50.45 233.53,49.14 240.43,49.14 241,49.71 249.04,49.71 249.96,48.8 259.22,48.8 261.3,50.88 271.45,50.88 273.56,48.77 276.83,48.77 277.68,47.92 293.41,47.92 296.32,50.84 296.32,56.31 299.35,59.34 v2(299.91,59.34) 300.38,59.34 300.71,59.01 313.87,59.01 v2(314.44,58.44)
  BOTTOM w0.254: v2(229.65,50.67) 229.65,50.59 228.62,49.56 222.54,49.56 220.76,51.34 214.15,51.34 213.44,52.05 213.44,56.58 212.81,57.21 211.82,57.21 211.54,57.49 211.54,58.53 v1(210.26,59.8) 204.03,66.04 192.83,66.04 189.77,69.1 189.77,82.16 190.4,82.8 190.4,100.47 193.18,103.24 v2(193.18,103.41) 193.34,103.57 UG14.4 193.21,104.44 192.96,104.44 CG240.1
3V_EN: length 8.3
  TOP w0.254: PR100.1 59.65,49.12 59.4,49.37 58.11,49.37 v1(57.45,48.71) 56.97,48.23 56.97,46.52 v2(56.95,46.49)
  BOTTOM w0.203: PU100.6 55.72,46.48 55.87,46.63 55.87,46.71 56.14,46.98 56.52,46.98 56.95,46.55 v2(56.95,46.49)
3V_F383_ON: length 233.2
  TOP w0.102: RE83.1 v1(309.11,25.2)
  TOP w0.203: RE83.1 308.39,23.24 v2(308.39,22.63) 308.39,22.38 308.23,22.21 UE5.128
  IN2 w0.254: v2(308.39,22.63) 307.6,21.84 303.77,21.84 301.87,19.94 299.02,19.94 297.99,18.91 289.14,18.91 280.69,27.36 278.58,27.36 278.16,27.78 275.85,27.78 274.96,28.67 269.93,28.67 268.96,29.65 249.52,29.65 248.18,30.98 248.18,35.01 246.62,36.57 240.46,36.57 239.23,37.8 231.55,37.8 231.02,37.28 230.31,37.28 230.03,37.56 223.86,37.56 221.01,40.41 215.08,40.41 213.9,39.24 210.67,39.24 210.33,38.91 197.64,38.91 197.18,39.36 196.13,39.36 195.56,38.79 193.01,38.79 192.03,37.81 192.03,34.83 191.08,33.88 182.27,33.88 180.53,32.14 116.26,32.14 113.81,29.69 101.69,29.69 v2(101.18,29.18)
  BOTTOM w0.254: UE9.4 100.81,29.55 v2(101.18,29.18)
3VS: length 1.2
  BOTTOM w0.102: v1(70.53,10.13) 69.96,10.7 69.96,11.08
3VS_GATE: length 2.9
  BOTTOM w0.203: U17.5 65.09,15.75 65.39,16.05 C258.1 R174.2
5V_EN: length 12.9
  TOP w0.254: PR112.1 60.57,49.46 v1(60.27,49.75) 56.65,49.75 55,48.1 52.78,48.1 v2(51.51,46.83)
  BOTTOM w0.203: v2(51.51,46.83) 51.86,46.48 PU100.20
5VCC: length 9.3
  TOP w0.254: v2(275.34,132.11) 276.23,133 v1(276.23,133.66) PC6014.1
  BOTTOM w0.203: PU6000.12 276.81,134.08 PR6035.2 276.48,132.73 PR6032.1 PR6070.1 v2(275.34,132.11)
5VS:
  vias: v1(61.82,13.89)
5VS_GATE: length 2.2
  BOTTOM w0.203: U17.3 64.29,15.67 63.48,16.48 R182.2
+0.6VS: length 102.7
  IN2 w1.524: 93.54,52.43 93.56,52.41 94.16,52.41 104.68,62.94 106.78,62.94 109.63,60.09 179.23,60.09 181.43,57.89 181.43,53.31 179.78,51.66 178.38,51.66
  vias: v2(91.7,52.1) v2(91.7,51.47) v2(92.4,52.1) v2(178.32,50.4) v2(178.32,49.75) v2(179.33,41.58) v2(179.28,41) v4(181.35,38.04)
+0.6VSP: length 0.7
  BOTTOM w0.203: 90.53,45.85 v1(89.8,45.85)
+0.9V_CIO:
  vias: v2(179.35,163.16) v2(180.65,163.81)
+0.9V_DP:
  vias: v1(174.06,154.1) v2(174.57,154.15) v2(175.21,154.15) v2(176.03,154.15) v2(178.7,165.11) v2(178.7,164.46) v2(180.65,165.11) v2(180.65,162.51) v2(181.3,162.51)
+0.9V_LVR_OUT: length 1.8
  BOTTOM w0.203: CT81.1 183.75,168.8 184.24,169.28 184.24,169.75 v1(184.51,170.03)
  vias: v2(180.65,166.41) v2(180.65,165.76) v2(183.24,166.41)
+0.9V_PCIE: length 0.6
  BOTTOM w0.203: v2(187.83,156.77) 187.83,156.19 v1(187.82,156.19)
  vias: v2(181.96,165.1) v2(182.6,165.1) v2(183.27,165.1) v2(183.9,165.1) v2(187.83,157.35)
+0.9V_SVR:
  vias: v1(170,170.96) v2(170.44,172.43) v2(170.44,171.85) v2(170.44,171.27) v2(170.44,170.68) v2(180,165.76) v2(180.66,167.7) v2(181.3,168.36) v2(181.3,167.7) v2(181.96,167.7)
+0.9V_USB: length 1.7
  BOTTOM w0.203: v2(182.6,163.16) 183.17,162.59 CT77.1 ; v2(187.18,157.35) 186.62,157.91 v1(186.57,157.91)
  vias: v2(187.18,156.77)
+1.0VS_VGA_PGOOD: length 89.3
  TOP w0.254: v2(312.35,59.73) 312.15,59.93 UG27.2 ; v2(240.92,38.36) 240.92,38.75 PR821.1 241.26,39.4 241.51,39.66 244.91,39.66 248.01,42.75 v2(248.01,46.82)
  IN3 w0.254: v2(312.35,59.73) 312.13,59.73 310.87,58.46 310.87,58.3 310.32,57.75 308.53,57.75 308.24,57.46 301.39,57.46 298.78,54.84 298.78,52.43 293.52,47.18 272.84,47.18 271.13,45.47 256.03,45.47 254.2,47.3 248.26,47.3 248.01,47.05 v2(248.01,46.82)
  BOTTOM w0.102: v2(240.92,38.36) 240.92,37.92 v1(241.05,37.79)
  BOTTOM w0.254: v2(240.92,38.36) 240.92,38.63 241.37,39.08 PU800.9
+1.0VS_VGAP:
  vias: v1(236.06,43.12)
+1.2V_DDR: length 109.8
  BOTTOM w0.203: CPU1.AJ12 151.87,100.75 v2(151.58,100.46) 151.21,100.1 CPU1.AL11 ; CPU1.L6 166.56,96.84 166.76,97.03 167.2,97.03 CPU1.K6 ; v2(159.81,100.46) 159.52,100.75 CPU1.Y12 ; v2(154.32,99.25) CPU1.AG9
  BOTTOM w0.254: CPU1.L12 166.87,100.95 167.3,100.95 CPU1.K12 167.81,100.44 v2(167.91,100.44) ; CPU1.AY6 143.99,96.84 v2(144.33,96.5) 144.67,96.84 CPU1.AW6 ; v2(154.38,96.5) 154.07,96.19 CPU1.AG5 ; v2(154.38,96.5) 154.49,96.5 CPU1.AF6 ; v2(154.38,96.5) 154.69,96.19 CPU1.AF5 ; v2(146.84,96.47) 146.92,96.47 CPU1.AR6 CPU1.AP6 148.38,97.1 CPU1.AP7 ; CPU1.AT12 146.68,100.75 v2(147.01,100.42) 147.33,100.75 CPU1.AR12 ; CPU1.AA6 159.02,96.76 v2(159.42,96.36) 159.85,96.8 CPU1.W6 ; CPU1.AE12 155.58,100.75 v2(155.29,101.04) ; v2(161.93,96.51) 162.25,96.84 CPU1.T6 ; CPU1.K6 CPU1.J6 168.3,96.84 v2(168.64,96.5) 168.32,96.19 CPU1.J5
  BOTTOM w0.305: JDIMM1.117 140.69,61.36 140.09,61.97 v2(139.88,61.97) ; v2(130.34,48.43) 130.19,48.28 JDIMM2.75 ; JDIMM1.160 153.44,50.96 152.39,49.91 v2(152.21,49.91) ; JDIMM1.124 142.44,50.75 v2(142.13,50.44) ; JDIMM2.117 140.69,48.09 v2(140.32,48.46) ; JDIMM1.148 150.44,50.71 v2(150.19,50.45) ; v2(142.25,37.69) 142.44,37.89 JDIMM2.124 ; JDIMM1.54 124.94,50.7 v2(124.73,50.48) ; v2(167.53,49.79) 167.97,49.79 168.44,50.26 JDIMM1.220 ; v2(157.81,41.18) 157.95,41.04 157.95,39 JDIMM2.178 ; v2(114.38,40.26) 114.44,40.2 JDIMM2.12 ; v2(139.44,37.69) JDIMM2.112 ; JDIMM2.111 139.2,47.2 139.2,48.53 139.73,49.06 v2(140.32,49.06) ; v2(168.55,37.71) 168.44,37.81 JDIMM2.220 ; v2(125.1,40.35) 124.94,40.2 JDIMM2.54 ; v2(135.96,49.84) 135.77,49.84 135.44,50.17 JDIMM1.96 ; JDIMM2.135 145.2,48.36 145.41,48.58 v2(145.62,48.58) ; v2(158.07,53.37) 157.94,53.24 JDIMM1.178 ; JDIMM2.129 143.69,48.28 142.86,49.12 v2(142.12,49.12) ; JDIMM1.129 143.69,61.01 143.72,61.01 144.1,61.39 v2(144.48,61.39) 144.55,61.33 144.93,61.33 145.19,61.06 JDIMM1.135 ; JDIMM1.241 173.69,61.07 173.31,61.46 v2(173.07,61.46) ; v2(142.14,61.36) 142.19,61.3 JDIMM1.123 ; v2(119.69,48.45) JDIMM2.33 ; v2(149.93,37.71) 150.1,37.71 150.44,38.05 JDIMM2.148 ; JDIMM2.159 153.2,48.23 153.51,48.55 v2(153.77,48.55) 154.2,48.12 JDIMM2.163 ; JDIMM2.160 153.44,38.09 153.09,37.73 v2(151.64,37.73) 151.94,38.03 JDIMM2.154 ; JDIMM2.241 173.69,48.14 v2(173.31,48.53) ; JDIMM2.141 146.69,45.94 v2(146.76,45.88) ; JDIMM1.33 119.69,61.07 v2(119.53,61.24) ; JDIMM1.130 143.94,50.56 144.59,49.91 v2(145.62,49.91) 145.62,50.76 145.44,50.93 JDIMM1.136 ; JDIMM1.75 130.19,61.16 v2(130.04,61.31) ; v2(164,49.17) 163.19,48.37 JDIMM2.199 ; JDIMM2.136 145.44,38.13 145.75,37.82 v2(145.75,37.71) ; JDIMM1.12 114.44,50.73 v2(114.66,50.52) ; JDIMM1.199 163.19,61.52 163.81,62.14 v2(164.54,62.14) ; v2(140.32,50.39) 140.76,50.39 140.94,50.58 JDIMM1.118 ; v2(144.48,62.33) 145.58,62.33 146.69,61.22 JDIMM1.141 ; JDIMM2.130 143.95,39 143.95,38.02 v2(144.26,37.71) ; JDIMM2.96 135.44,40.11 v2(135.26,40.29) ; JDIMM1.154 151.94,50.78 v2(152.22,50.51) ; v2(146.63,50.48) 146.94,50.8 JDIMM1.142 ; JDIMM2.118 140.94,38.1 v2(140.53,37.69) ; CPU1.T6 CPU1.R6 ; JDIMM2.142 146.95,39 146.95,37.82 v2(147.06,37.71) ; JDIMM2.123 142.19,48.42 v2(142.13,48.49) ; JDIMM2.147 150.2,48.56 v2(150.17,48.58) 151.26,48.58 151.69,48.14 JDIMM2.153 ; JDIMM1.112 139.44,50.3 140.02,49.72 v2(140.32,49.72)
  vias: v2(98.81,34.2) v2(98.8,33.53) v2(98.8,32.9) v2(98.8,32.26) v2(98.8,31.63) v2(99.37,33.85) v2(99.37,33.22) v2(99.37,32.58) v2(99.37,31.95) v2(99.39,31.34) v2(100.01,33.85) v2(100.01,33.22) v2(100.01,32.58) v2(100.01,31.95) v2(100.01,31.31) v2(108.71,39.31) v2(108.71,38.68) v2(108.71,38.04) v2(108.71,37.41) v2(108.71,36.77) v2(109.28,39.63) v2(109.28,38.99) v2(109.28,38.36) v2(109.28,37.72) v2(109.28,37.09) v2(109.85,39.31) v2(109.85,38.68) v2(109.85,38.04) v2(109.85,37.41) v2(109.85,36.77) v2(110.42,39.63) v2(110.42,38.99) v2(110.42,38.36) v2(110.42,37.72) v2(110.42,37.09) v2(119.79,45.7) v2(126.29,75.89) v2(127.9,37.56) v2(128.65,96.49) v2(128.85,97.06) v2(129.1,83.41) v2(132.03,40.51) v2(136.66,40.5) v2(139.88,62.61) v2(139.88,61.34) v2(142.14,62.63) v2(142.14,61.99) v2(148.41,37.93) v2(150.82,61.26) v2(153.29,61.35) v2(155.65,50.26) v2(167.26,37.69) v2(167.31,87.2) v2(171.97,45.75) v4(100.88,41)
