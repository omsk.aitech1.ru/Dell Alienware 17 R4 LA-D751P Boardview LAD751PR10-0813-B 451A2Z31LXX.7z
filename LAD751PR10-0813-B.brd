# Allegro board LAD751PR10-0813-B.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_1.8V_DVDD_IO on BOTTOM (solid shape): 33.33,27.36 33.33,26.51 33.57,26.27 33.57,25.9 34.12,25.36 34.12,21.47 34.1,21.45 33.34,21.45 33.21,21.57 33.21,26.28 33.1,26.4 33.1,27.36 33.15,27.41 33.28,27.41
+3.3V_F383 on TOP (solid shape): 326.72,48.48 326.72,46.9 326.59,46.77 323.1,46.77 322.91,46.96 322.91,48.55 323.03,48.67 326.53,48.67
+3.3V_F383 on TOP (solid shape): 318.85,9.99 318.85,8.41 319.92,7.34 319.92,6.91 319.78,6.76 316.61,6.76 316.48,6.89 316.48,7.27 317.14,7.93 317.14,8.02 317.53,8.41 317.53,9.93 317.72,10.12 318.72,10.12
+3.3V_F383 on TOP (solid shape): 188,26.81 188.29,26.67 188.57,26.81 188.89,26.81 189.15,26.66 189.43,26.76 189.49,26.79 189.56,26.77 189.66,26.66 190.11,26.66 190.23,26.55 190.97,25.81 190.97,25.3 191.34,24.93 191.34,24.48 191.25,24.39 189.41,24.39 189.16,24.64 189.16,25.34 189.15,25.35 188.61,25.89 187.78,25.89 187.7,25.98 186.71,25.98 186.16,25.42 186.16,24.94 185.87,24.65 184.89,24.65 184.81,24.73 184.81,24.75 184.77,24.89 184.66,25 184.64,25.01 184.64,26.56 184.89,26.81
+3.3V_F383 on BOTTOM (solid shape): 166.9,26.96 166.9,25.67 167.18,25.39 167.18,22.06 167.09,21.97 166.22,21.97 166.08,22.11 166.08,25.73 166.3,25.94 166.3,26.93 166.46,27.09 166.76,27.09
+3.3V_F383 on BOTTOM (solid shape): 104.02,27.6 104.02,23.21 103.82,23.01 103.39,23.01 103.03,23.36 103.03,24.62 102.83,24.82 102.83,25.83 102.65,26 102.13,26 101.89,26.24 101.89,27.36 102.35,27.82 102.35,28.47 102.52,28.65 102.98,28.65
+3.3V_F383 on BOTTOM (solid shape): outline of 315 points within 313.71,7.09 318.92,32.4
+3.3V_F383 on IN1 (solid shape): 309.34,10.58 313.42,10.58 315.52,8.48 321.46,8.48 322.1,9.13 323.07,9.13 323.25,8.95 323.25,7.89 322.41,7.06 314.56,7.06 313.72,7.9 316.01,7.9 316.01,7.84 316.02,7.79 316.03,7.74 316.06,7.69 316.09,7.65 316.12,7.61 316.17,7.58 316.21,7.55 316.26,7.53 316.31,7.52 316.37,7.51 316.42,7.52 316.47,7.53 316.52,7.55 316.57,7.58 316.61,7.61 316.64,7.65 316.67,7.69 316.7,7.74 316.71,7.79 316.72,7.84 316.72,7.9 316.71,7.95 316.7,8 316.67,8.05 316.64,8.09 316.61,8.13 316.57,8.17 316.52,8.19 316.47,8.21 316.42,8.22 316.37,8.23 316.31,8.22 316.26,8.21 316.21,8.19 316.17,8.17 316.12,8.13 316.09,8.09 316.06,8.05 316.03,8 316.02,7.95 316.01,7.9 313.72,7.9 312.61,9.01 308.83,9.01 307.39,10.45 302.37,10.45 301.87,10.95 301.87,11.59 302.03,11.75 308.17,11.75
+3.3V_F383 on IN1 (solid shape): 224.26,160.5 224.34,160.45 224.35,160.36 224.49,159.96 224.92,159.98 224.98,160 225.05,159.98 225.1,159.95 225.15,159.92 225.18,159.91 225.18,153.83 224.68,153.33 223.64,153.33 223.5,153.47 223.5,153.91 223.21,154.21 223.21,156.39 223.26,156.47 223.35,156.48 223.82,156.85 223.29,157.12 223.26,157.12 223.23,157.13 223.21,157.16 223.21,157.21 223.71,157.71 223.71,157.72 223.88,157.89 223.88,159.49 223.71,159.67 223.71,160.47 223.73,160.5
+3.3V_F383 on IN2 (solid shape): 105.16,18.74 105.16,17.94 105.08,17.86 102.9,17.86 102.75,18 102.75,18.62 103.01,18.87 105.04,18.87
+3.3V_F383 on IN2 (solid shape): 168.3,22.84 168.3,21.98 168.24,21.91 164.84,21.91 164.78,21.97 164.78,22.9 164.82,22.95 168.2,22.95
+3.3V_F383 on IN2 (solid shape): 225.48,153.76 225.48,152.6 225.36,152.48 223.91,152.48 223.65,152.74 223.65,153.68 223.86,153.88 225.36,153.88
+3.3V_F383 on IN2 (solid shape): outline of 927 points within 185.17,18.83 195.03,26.48
+3.3V_F383 on IN2 (solid shape): outline of 2903 points within 290.14,28.86 326.21,48.8
+3.3V_F383 on IN4 (solid shape): 187.98,13.62 187.98,12.21 187.78,12.01 186.94,12.01 186.83,12.12 186.83,13.67 186.93,13.77 187.83,13.77
+3.3V_F383 on IN4 (solid shape): 222.17,11.58 222.17,10.36 222.04,10.23 220.25,10.23 220.18,10.31 220.18,11.56 220.35,11.74 222,11.74
+3.3V_F383 on IN4 (solid shape): 243.81,12.25 243.81,11.32 243.71,11.22 241.85,11.22 241.69,11.39 241.69,12.16 241.97,12.44 243.62,12.44
+3.3V_F383 on IN4 (solid shape): 102.65,27.55 102.69,27.52 102.72,27.49 103.55,26.66 103.55,25.37 101.8,23.62 101.8,21.08 104.17,18.71 104.17,18.26 104.05,18.14 103.07,18.14 100.78,20.42 100.78,24.04 102.54,25.79 102.54,26.21 101.82,26.92 101.82,27.09 102.4,27.66 102.54,27.66
+3.3V_F383 on IN4 (solid shape): outline of 226 points within 266.72,10.51 303.09,15.25
+3.3V_F383 on IN6 (solid shape): outline of 228 points within 184.98,13 190.05,26.12
+3.3V_FLASH on TOP (solid shape): 195.35,163.23 196.05,163.23 196.25,163.03 196.25,163.02 196.32,162.9 196.43,162.83 196.44,162.83 196.64,162.63 196.65,162.61 196.72,162.44 196.86,162.33 196.91,162.28 196.92,162.21 196.91,162.1 196.95,162 196.95,161.91 196.88,161.85 196.63,161.68 196.59,161.39 196.59,161.31 196.54,161.26 196.37,161.11 196.33,160.88 196.31,160.8 196.24,160.76 196.06,160.12 196.63,160.46 196.65,160.54 196.72,160.58 196.98,160.74 197.02,161.05 197.03,161.12 197.08,161.17 197.28,161.41 197.21,161.72 197.2,161.81 197.26,161.88 197.29,161.89 197.35,161.92 197.69,161.58 197.69,160.62 197.87,160.43 197.87,160.18 197.73,160.03 197.55,160.03 196.98,159.47 194.91,159.47 194.7,159.67 194.7,162.85 195.08,163.23 195.35,163.23
+3.3V_TBT_SX on BOTTOM (solid shape): 177.75,169.51 177.75,168.94 177.55,168.75 176.73,168.75 176.48,169.01 176.48,169.54 176.64,169.7 177.55,169.7
+3.3V_TBT_SX on IN6 (solid shape): outline of 1480 points within 169.55,160.43 179.84,169.2
+3V3_SYS on BOTTOM (solid shape): 196.43,117.46 196.58,117.46 197.06,116.98 197.06,116.6 197.18,116.48 197.18,116.11 197.16,116.1 196.71,116.1 196.54,115.93 196.54,115.43 196.34,115.23 195.63,115.23 195.54,115.32 195.54,117.5 195.66,117.61 196.28,117.61
+3V3_SYS on IN4 (solid shape): outline of 100 points within 196.5,116.07 199.02,117.61
+3V_PCH on TOP (solid shape): outline of 907 points within 209.56,36.54 226.13,45.18
+3V_PCH on BOTTOM (solid shape): 217.49,39.81 217.49,38.97 217.44,38.92 217.44,37.99 217.2,37.74 216.75,37.74 216.56,37.93 216.3,37.93 216.24,38 216.24,38.63 216.37,38.76 216.62,38.76 216.75,38.89 216.75,39.83 216.83,39.91 217.38,39.91
+3V_PCH on BOTTOM (solid shape): 229.52,15.46 229.61,15.41 229.61,15.31 229.58,15.21 229.57,15.1 229.57,13.91 229.67,13.91 229.71,13.88 229.7,13.83 229.62,13.75 226.7,13.75 226.64,13.81 226.64,14.39 226.74,14.39 226.86,14.51 228.04,14.51 228.43,14.9 228.43,15.26 228.44,15.29 228.61,15.46
+3V_PCH on BOTTOM (solid shape): 210.4,20.26 210.4,20.15 210.44,20.11 210.44,19.79 210.39,19.71 210.3,19.7 210.04,19.68 209.88,19.48 209.87,19.44 209.19,19.44 209.14,19.46 209.09,19.46 209.04,19.46 209,19.46 208.95,19.44 208.56,19.44 208.38,19.61 208.38,19.71 208.7,20.02 208.7,20.03 208.99,20.32 209.43,20.32 209.51,20.24 209.55,20.24 209.56,20.23 209.67,20.21 209.77,20.23 209.78,20.24 209.8,20.24 209.95,20.38 210.28,20.38
+3V_PCH on BOTTOM (solid shape): 216.77,19.67 216.77,18.62 216.64,18.5 216.34,18.5 216.28,18.53 216.25,18.57 216.24,18.6 216.23,18.64 216.24,18.68 216.24,18.71 216.24,18.85 216.07,19.03 216.03,19.03 216.03,19.04 215.75,19.04 215.75,19.03 215.69,19.03 215.6,18.95 215.6,17.93 215.69,17.85 215.69,17.11 215.52,16.95 215.05,16.95 214.87,17.13 214.84,17.41 214.6,17.56 214.4,17.76 214.4,17.81 214.52,17.93 215.03,17.93 215.16,18.06 215.16,19.01 215.53,19.38 215.53,19.74 215.63,19.84 216.6,19.84
+3V_PCH on IN2 (solid shape): outline of 3758 points within 195.58,11.45 229.59,26.19
+3V_PCH on IN3 (solid shape): outline of 4031 points within 210.91,21.43 225.05,40.12
+3VALW on TOP (solid shape): 235.52,33.5 235.52,32.73 235.45,32.67 234.44,32.67 234.37,32.73 234.37,33.3 234.76,33.69 235.33,33.69
+3VALW on TOP (solid shape): 235.52,30.26 235.52,29.5 235.45,29.43 234.49,29.43 234.45,29.47 234.45,30.27 234.63,30.44 235.33,30.44
+3VALW on TOP (solid shape): 235.52,27.02 235.52,26.26 235.45,26.19 234.44,26.19 234.37,26.26 234.37,27.08 234.5,27.2 235.33,27.2
+3VALW on TOP (solid shape): 298.46,5.3 298.46,4.63 298.41,4.58 297.07,4.58 296.96,4.7 296.96,5.26 297.11,5.42 298.34,5.42
+3VALW on TOP (solid shape): 306.49,8.99 306.49,6.61 306.37,6.48 305.75,6.48 305.65,6.58 305.65,7.06 305.43,7.29 305.43,9.01 305.5,9.09 306.4,9.09
+3VALW on TOP (solid shape): 297.4,26.18 297.4,25.27 297.3,25.17 297.3,23 297.19,22.9 297.09,22.9 296.98,23 296.98,24.69 296.93,24.75 296.9,24.78 296.87,24.8 296.71,24.96 296.71,26.17 296.81,26.27 297.3,26.27
+3VALW on TOP (solid shape): 303.38,26.14 303.38,25.59 302.48,24.7 302.48,23.71 302.47,23.7 302.47,23.01 302.4,22.94 302.28,22.94 302.21,23 302.21,24.96 302.69,25.44 302.69,25.91 302.69,26 302.66,26.09 302.65,26.12 302.72,26.19 303.33,26.19
+3VALW on TOP (solid shape): 290.28,25.93 290.28,24.39 290.49,24.19 290.49,22.86 290.71,22.64 292.1,22.64 292.41,22.32 292.41,22.13 292.33,22.05 290.25,22.05 289.69,22.61 289.68,22.61 288.87,22.61 288.87,22.61 288.62,22.61 288.51,22.72 288.48,22.95 288.36,23.14 288.36,25.95 288.73,26.31 289.89,26.31
+3VALW on TOP (solid shape): 49.35,23.97 49.35,20.99 48.9,20.54 47.75,20.54 47.75,20.54 46.55,20.54 46.55,21.06 45.85,21.06 45.85,20.54 45.35,20.54 45.35,21.06 44.65,21.06 44.65,20.54 41.28,20.54 41.28,21.06 40.58,21.06 40.58,20.54 40.08,20.54 40.08,21.06 39.38,21.06 39.38,20.54 38.78,20.54 38.55,20.78 38.55,22.46 38.55,22.47 38.55,23.21 38.81,23.46 41.98,23.46 42.68,24.16 49.16,24.16
+3VALW on TOP (solid shape): 311.77,24.25 311.86,24.2 311.95,24.18 311.97,24.18 312.11,24.04 312.11,22.69 311.08,21.67 311.08,20.38 310.95,20.24 310.83,20.24 310.79,20.28 310.27,20.28 310.25,20.31 310.25,21.26 310.09,21.42 308.89,21.42 308.8,21.32 308.72,21.32 308.72,21.25 308.38,20.9 306.25,20.9 306.25,21.09 306.35,21.18 308.1,21.18 308.33,21.41 308.33,21.92 308.85,22.45 308.85,22.46 308.92,22.53 310.07,22.53 310.2,22.66 310.24,22.66 310.46,22.89 310.46,22.93 310.64,23.1 310.64,24.13 310.76,24.25
+3VALW on TOP (solid shape): 223.96,45.04 224.16,45.04 224.16,44.61 224.38,44.39 224.38,43.84 224.6,43.63 225.12,43.63 225.18,43.7 225.19,43.7 225.35,43.8 225.44,43.95 225.45,43.96 225.7,44.22 226.56,44.22 226.86,43.92 226.87,43.9 226.87,43.32 226.86,43.31 226.82,43.16 226.85,43 226.86,42.97 225.46,41.57 223.32,41.57 223.19,41.7 223.19,43.8 222.92,44.07 221.4,44.07 221.33,44.13 221.33,45.51 221.46,45.63 223.96,45.63
+3VALW on TOP (solid shape): outline of 81 points within 313.32,54.13 316.07,56.99
+3VALW on BOTTOM (solid shape): 229.59,23.78 229.59,23.02 229.52,22.96 228.51,22.96 228.44,23.02 228.44,23.84 228.57,23.97 229.4,23.97
+3VALW on BOTTOM (solid shape): 235.52,33.5 235.52,32.73 235.45,32.67 234.44,32.67 234.37,32.73 234.37,33.22 234.84,33.69 235.33,33.69
+3VALW on BOTTOM (solid shape): 235.52,23.78 235.52,23.02 235.45,22.96 234.44,22.96 234.37,23.02 234.37,23.84 234.5,23.97 235.33,23.97
+3VALW on BOTTOM (solid shape): 229.59,27.02 229.59,26.26 229.52,26.19 228.51,26.19 228.44,26.26 228.44,27.08 228.57,27.2 229.4,27.2
+3VALW on BOTTOM (solid shape): 235.52,30.26 235.52,29.5 235.45,29.43 234.44,29.43 234.37,29.5 234.37,30.32 234.5,30.44 235.33,30.44
+3VALW on BOTTOM (solid shape): 235.52,27.02 235.52,26.26 235.45,26.19 234.44,26.19 234.37,26.26 234.37,27.08 234.5,27.2 235.33,27.2
+3VALW on BOTTOM (solid shape): 229.59,33.69 229.59,32.73 229.52,32.67 228.51,32.67 228.44,32.73 228.44,33.7 228.59,33.85 229.43,33.85
+3VALW on BOTTOM (solid shape): 270.47,172.4 270.47,171.71 270.66,171.52 271.35,171.52 271.4,171.48 271.4,169.41 271.3,169.31 269.76,169.31 269.55,169.52 269.55,172.36 269.64,172.44 270.43,172.44
+3VALW on BOTTOM (solid shape): 177.12,173.09 177.12,172.43 176.9,172.21 175.56,172.21 175.49,172.28 175.49,172.71 175.5,172.72 175.39,172.82 175.31,172.82 175.3,172.84 174.61,172.84 174.47,172.98 174.47,173.39 174.52,173.45 176.76,173.45
+3VALW on BOTTOM (solid shape): 228.84,30.44 228.99,30.41 229.14,30.44 229.4,30.44 229.59,30.26 229.59,29.5 229.52,29.43 228.51,29.43 228.44,29.5 228.44,30.32 228.57,30.44
+3VALW on BOTTOM (solid shape): 162.57,174.97 162.57,174.29 162.45,174.17 161.28,174.17 160.2,173.09 159.91,173.09 159.82,173.1 159.73,173.09 158.54,173.09 158.36,173.27 158.36,174.05 158.47,174.16 159.24,174.16 159.5,173.9 160.21,173.9 160.64,174.33 160.64,174.88 160.79,175.04 162.51,175.04
+3VALW on BOTTOM (solid shape): 227.56,43.89 227.56,43.21 227.62,43.15 227.62,41.84 227.92,41.54 228.47,41.54 228.53,41.47 228.53,41.26 228.51,41.23 227.28,41.23 226.74,41.76 225.81,41.76 225.51,41.46 225.51,41.04 225.41,40.94 224.91,40.94 224.86,40.99 224.86,41.57 224.94,41.65 225.09,41.65 225.58,42.14 225.58,42.92 225.52,42.97 225.52,43.9 225.62,44 227.45,44
+3VALW on BOTTOM (solid shape): 68.45,18.51 68.45,17.91 68.56,17.8 68.56,15.16 68.12,14.71 65.45,14.71 65.39,14.78 65.39,15.6 65.86,16.07 65.86,17.14 65.98,17.27 66.26,17.27 66.47,17.47 66.47,17.77 67.41,18.71 68.25,18.71
+3VALW on BOTTOM (solid shape): 270.9,24.56 270.9,23.99 270.72,23.81 270.65,23.8 270.6,23.79 270.22,23.79 270.22,23.79 269.92,23.79 269.91,23.79 269.64,23.79 269.63,23.79 269.34,23.79 269.13,23.58 269.13,23.28 269.18,23.23 269.18,22.73 269.38,22.53 269.38,22.19 269.33,22.13 268.82,22.13 268.26,21.57 268.26,21.43 267.54,20.71 266.77,20.71 266.28,20.22 266.28,20.21 266.17,20.14 266.1,20.04 266.1,20.03 266.05,19.98 265.52,19.98 265.39,19.86 265.39,18.68 265.37,18.67 263.8,18.67 263.78,18.69 263.78,22.33 264.03,22.59 264.04,22.59 264.11,22.66 264.84,22.66 265.53,23.35 266.8,23.35 267.43,23.98 267.55,23.98 267.55,24.1 268.2,24.75 270.7,24.75
+3VALW on BOTTOM (solid shape): outline of 654 points within 308.02,7.97 312.38,25.75
+3VALW on IN1 (solid shape): outline of 98 points within 63.23,12.74 69.58,18.68
+3VALW on IN1 (solid shape): outline of 463 points within 288.95,22.24 311.95,27.5
+3VALW on IN1 (solid shape): outline of 1301 points within 221.24,29.27 240.07,44.94
+3VALW on IN2 (solid shape): outline of 1703 points within 228.51,18.16 244.38,34.72
+3VALW on IN6 (solid shape): 274.09,167.8 277.97,167.8 278.8,168.62 280.32,168.62 280.78,168.16 280.78,167.49 280.59,167.3 280.14,167.3 279.84,167.46 279.55,167.3 279.53,167.3 279.02,166.78 273.42,166.78 272.7,167.5 272.73,167.67 272.68,167.83 272.47,168.11 272.12,168.08 270.65,169.55 270.65,170.18 270.95,170.48 271.42,170.48
+3VALW on IN5: outline of 111 points within 44.01,12.86 334.15,173.51 ; 1 cut-out
+3VALW_PD on TOP (solid shape): 197.38,164.7 197.38,163.88 197.3,163.8 196.59,163.8 196.15,163.35 195.4,163.35 195.31,163.45 195.31,164.72 195.31,164.73 195.31,164.81 195.37,164.87 197.21,164.87
+3VALWP on TOP (solid shape): 39.98,20.41 40.68,20.41 40.68,20.42 41.18,20.42 41.18,20.41 41.96,20.41 41.96,20.42 43.97,20.42 43.97,20.41 44.75,20.41 44.75,20.42 45.25,20.42 45.25,20.41 45.95,20.41 45.95,20.42 46.45,20.42 46.45,20.41 47.23,20.41 47.23,20.42 47.7,20.42 48.14,19.97 48.14,17.11 47.76,16.73 43.76,16.73 42.36,18.13 38.87,18.13 38.68,18.32 38.68,18.7 38.72,18.78 38.8,18.8 39.18,18.97 39.13,19.39 39.1,19.46 39.13,19.53 39.18,19.95 38.8,20.13 38.72,20.15 38.68,20.23 38.68,20.29 38.8,20.41 39.48,20.41 39.48,20.42 39.98,20.42
+3VALWP on BOTTOM (solid shape): 43.63,24.04 43.63,23.76 43.63,23.75 43.61,23.63 43.63,23.5 43.63,23.5 43.63,21.88 44.4,21.11 51.44,21.11 51.63,20.92 51.63,17.18 51.44,16.99 41.46,16.99 41.09,17.36 41.09,18.07 39.89,19.27 39.89,24.1 40.33,24.54 43.13,24.54
+3VLP on TOP (solid shape): 306.39,15.58 307.94,15.58 307.96,15.59 308.55,15.59 308.8,15.34 309.31,15.34 309.5,15.15 309.5,14.76 309.37,14.63 308.73,14.63 308.1,15.26 308.09,15.26 306.35,15.26 306.27,15.34 306.27,15.5 306.36,15.59
+3VS on TOP (solid shape): 300.33,5.81 300.33,5.23 299.67,4.57 298.76,4.57 298.69,4.64 298.69,5.29 298.82,5.42 299.39,5.42 299.91,5.94 300.2,5.94
+3VS on TOP (solid shape): 177.7,64.37 177.7,61.17 177.54,61.01 176.94,61.01 176.68,61.26 176.68,62.21 176.35,62.55 176.35,64.42 176.56,64.63 177.45,64.63
+3VS on TOP (solid shape): 276.78,148.53 277.36,148.53 277.52,148.38 277.52,147.23 277.41,147.12 276.57,147.12 276.16,147.53 275.55,147.53 275.11,147.97 274.81,147.97 274.7,148.08 274.7,148.69 275,148.99 276.32,148.99
+3VS on TOP (solid shape): 304.94,41.75 304.94,39.53 304.83,39.43 303.69,39.43 303.35,39.08 300.49,39.08 300.3,39.28 300.3,41.1 300.41,41.22 302.03,41.22 302.53,41.72 302.53,42.18 302.67,42.32 304.36,42.32
+3VS on TOP (solid shape): 244.44,164.85 244.44,162.41 243.46,161.43 241.12,161.43 240.38,160.68 240.2,160.68 239.62,161.26 239.62,161.5 240.66,162.54 243.08,162.54 243.41,162.88 243.41,164.08 243.41,164.09 243.41,164.83 243.5,164.92 244.38,164.92
+3VS on TOP (solid shape): 187.73,67.26 187.73,65.64 187.57,65.48 187.49,65.48 187.4,65.47 186.35,65.47 186.27,65.55 186.27,66.28 186.36,66.36 186.45,66.36 186.61,66.53 186.61,67.38 186.75,67.51 187.48,67.51
+3VS on TOP (solid shape): 314.77,42.78 314.77,42.41 314.91,42.27 318.73,42.27 318.86,42.13 318.86,40.44 318.1,39.68 318.1,39.35 317.93,39.17 316.68,39.17 316.2,39.66 315.3,39.66 315.2,39.55 315.2,39.12 315.07,38.99 314.52,38.99 314.41,39.11 314.41,40.18 313.82,40.77 313.82,42.77 313.86,42.81 314.74,42.81
+3VS on TOP (solid shape): outline of 1774 points within 194.72,10.45 210.13,25.5
+3VS on BOTTOM (solid shape): 319.17,41.72 319.17,40.14 318.06,39.03 316.66,39.03 316.56,39.13 316.56,40.1 316.62,40.16 317.69,40.16 317.89,40.36 317.89,41.8 318.05,41.96 318.92,41.96
+3VS on BOTTOM (solid shape): 301.23,41.83 301.23,40.3 301.44,40.09 302.87,40.09 303.03,39.93 303.03,39.03 302.96,38.96 300.61,38.96 300.27,39.29 300.27,41.76 300.4,41.89 301.16,41.89
+3VS on BOTTOM (solid shape): 173.26,164.96 173.26,163.19 173.11,163.04 172.6,163.04 172.06,163.58 171.96,163.76 171.78,163.86 171.65,163.99 171.65,165.01 171.77,165.13 173.1,165.13
+3VS on BOTTOM (solid shape): 165.4,166.06 165.6,166.06 165.72,165.94 165.72,165.11 165.47,164.86 164.57,164.86 164.32,164.61 164.32,164.59 164.22,164.49 164.22,163.57 164.07,163.42 162.09,163.42 162.05,163.46 162.05,164.12 161.92,164.25 161.29,164.25 161.22,164.32 161.22,165.46 161.53,165.77 163.32,165.77 163.61,166.06 164.79,166.06 164.86,166.13 165.33,166.13
+3VS on BOTTOM (solid shape): 73.02,18.48 73.02,12.68 72.47,12.13 72.47,10.31 72.25,10.08 72.19,10.08 72.19,10.08 71.04,10.08 70.44,10.68 70.44,13.52 69.89,13.52 69.89,13.81 70.44,13.81 70.44,14.32 69.89,14.32 69.89,14.61 70.44,14.61 70.44,15.39 70.13,15.7 70.13,18.49 70.33,18.69 72.81,18.69
+3VS on BOTTOM (solid shape): 195.62,106.45 195.62,105.15 196.29,104.48 196.78,104.48 196.88,104.38 196.88,103.84 196.82,103.78 196.27,103.78 195.92,104.08 195.57,103.78 194.68,103.78 194.46,104 194.46,104.54 194.26,104.73 193.15,104.73 193.11,104.78 193.11,106.5 193.15,106.55 195.52,106.55
+3VS on BOTTOM (solid shape): outline of 97 points within 220.73,23.25 223.14,28.12
+3VS on BOTTOM (solid shape): outline of 211 points within 117.31,9.27 126.08,23.68
+3VS on IN4 (solid shape): outline of 1395 points within 175.62,33.22 180.37,62.53
+3VS on IN6 (solid shape): 208.48,33.12 208.48,32.16 207.94,31.62 207.94,25.46 207.04,24.56 206.5,24.84 206.78,24.3 206.57,24.1 205.3,24.1 205.05,24.35 205.05,25.31 205.24,25.5 206.19,25.5 207.08,26.38 207.08,31.95 207.33,32.2 207.33,33.24 207.59,33.5 208.1,33.5
+3VS on IN6 (solid shape): 184.21,68.04 184.28,68.01 184.31,67.94 184.66,67.61 185.02,67.94 185.05,68.01 185.12,68.04 185.28,68.04 185.35,68.01 185.38,67.94 185.74,67.59 186.09,67.94 186.13,68.01 186.2,68.04 189.29,68.04 189.81,67.52 189.81,65.9 189.73,65.82 183.19,65.82 182.97,65.9 182.75,65.82 182.58,65.82 182.19,66.22 182.19,67.69 182.31,67.81 182.36,67.76 182.36,67.73 182.79,67.33 183,67.88 182.99,67.98 183.08,68.04
+3VS on IN5: outline of 99 points within 47.25,16.8 327.29,166.15 ; 6 cut-outs
+3VS_DP on TOP (solid shape): 242.3,164.76 242.3,163.25 242.2,163.15 239.77,163.15 239.65,163.27 239.65,164.3 239.72,164.37 240.65,164.37 241.12,164.84 242.23,164.84
+3VS_DP on BOTTOM (solid shape): 237.98,171.58 237.98,170.34 239.85,168.47 239.85,164.62 240.1,164.37 240.99,164.37 241.12,164.24 241.12,163.37 240.86,163.11 239.01,163.11 238.46,163.67 238.46,168.13 237.77,168.82 237.77,169.5 237.72,169.56 237.73,169.57 237.73,170.92 237.54,171.11 237.54,171.56 237.66,171.67 237.88,171.67
+3VS_SSD on TOP (solid shape): 278.65,23.27 278.65,20.1 278.33,19.78 276.36,19.78 276.01,20.13 276.01,23.43 276.3,23.72 278.2,23.72
+3VS_SSD on TOP (solid shape): 334.23,31.95 334.23,28.49 333.99,28.26 332.67,28.26 332.51,28.42 332.51,29.4 332.01,29.9 331.44,29.9 331.26,30.08 331.26,31.62 331.81,32.16 334.02,32.16
+3VS_SSD on TOP (solid shape): outline of 92 points within 235.7,4.32 263.03,14.94
+3VS_SSD on BOTTOM (solid shape): 334.89,30.61 334.89,28.49 334.57,28.17 332.75,28.17 332.49,28.42 332.49,30.79 332.75,31.04 334.46,31.04
+3VS_SSD on BOTTOM (solid shape): 234.12,6.78 234.19,6.78 234.2,6.77 234.78,6.6 235.36,6.78 236.86,6.78 237.02,6.62 237.02,6.3 236.93,6.22 236.93,4.68 236.79,4.54 232.29,4.54 231.64,5.19 231.64,7.44 231.69,7.49 233.41,7.49
+3VS_SSD on BOTTOM (solid shape): outline of 128 points within 332.37,43.72 336.43,48.8
+3VS_SSD on BOTTOM (solid shape): outline of 186 points within 276.68,5.84 284.48,24.42
+3VS_SSD on BOTTOM (solid shape): outline of 475 points within 249.63,4.29 263.51,21.05
+3VS_SSD on IN1 (solid shape): outline of 572 points within 260.56,14.41 278.9,21.98
+3VS_SSD on IN2 (solid shape): 334.44,29.26 334.44,25.66 334.24,25.46 332.85,25.46 332.33,25.97 332.33,29.26 332.63,29.56 334.14,29.56
+3VS_SSD on IN2 (solid shape): outline of 1768 points within 280.15,4.31 326.36,8.98
+3VS_SSD on IN3 (solid shape): outline of 185 points within 332.02,27.34 335.51,45.85
+3VS_TBT on TOP (solid shape): 178.19,174.85 178.19,173.51 177.94,173.26 177.94,172.77 177.17,172.01 177.17,171.56 177.03,171.42 177.03,171.41 176.48,170.85 176.48,170.47 176.94,170 176.94,169.54 176.96,169.51 176.96,169.29 176.9,169.23 176.79,169.23 176.66,169.35 176.66,169.53 176.53,169.66 176.34,169.66 176.28,169.72 176.28,169.99 175.96,170.32 175.96,170.98 175.96,171.1 176.17,171.31 176.17,172.3 176.41,172.54 176.41,174.86 176.6,175.05 177.99,175.05
+3VS_TBT on BOTTOM (solid shape): 177.88,174.23 177.88,173.13 177.7,172.96 177.44,172.96 177.13,173.27 177.13,173.63 176.95,173.82 175.79,173.82 175.68,173.93 175.68,174.86 175.81,174.99 177.12,174.99
+3VS_TBT on IN2 (solid shape): outline of 978 points within 171.65,155.48 182.31,169.95
+3VS_TBT on IN6 (solid shape): outline of 1079 points within 176.22,162.66 182.29,174.09
+5V_HDD on TOP (solid shape): 130.25,11.51 130.25,10.22 129.73,10.22 129.73,9.46 130.25,9.46 130.25,9.02 129.73,9.02 129.73,8.26 130.25,8.26 130.25,7.77 130.22,7.74 128.6,7.74 128.43,7.9 128.43,9.05 127.67,9.81 125.26,9.81 125.19,9.88 125.19,11.61 125.46,11.88 129.88,11.88
+5V_HDD on BOTTOM (solid shape): 128.95,11.52 128.95,9.27 128.67,8.98 126.54,8.98 126.29,9.23 126.29,11.45 126.61,11.77 128.7,11.77
+5V_PVDD on TOP (solid shape): 27.81,42.01 27.88,41.98 27.91,41.91 27.95,41.78 28.04,41.67 28.07,41.59 28.04,41.52 28.27,40.89 28.5,41.52 28.46,41.59 28.5,41.67 28.58,41.78 28.62,41.91 28.65,41.98 28.72,42.01 29.88,42.01 30.18,41.83 30.49,42.01 30.69,42.01 30.69,42 33.08,42 33.94,41.15 33.94,39.41 34.49,38.86 34.76,38.86 34.95,38.67 34.95,37.89 34.93,37.87 33.98,37.87 33.91,37.8 33.91,37.68 33.77,37.53 32.88,37.53 32.87,37.55 32.84,37.63 32.87,37.7 33.01,38.08 32.72,38.37 32.68,38.38 32.68,39.65 32.61,39.72 31.47,39.72 30.96,39.21 29.75,39.21 29.68,39.28 29.69,39.38 29.65,39.86 29.16,39.85 26.87,39.85 26.74,39.97 26.75,40 26.75,40.19 26.68,40.35 26.68,41.75 26.93,42.01
+5V_TOBII on TOP (solid shape): 155.58,166.28 155.58,165.2 156.16,164.62 156.16,163.02 154.14,161.01 147.9,161.01 147.23,161.67 147.23,163.37 147.7,163.84 148.22,163.84 148.75,163.3 148.75,162.77 149.55,161.98 149.55,161.97 150.45,161.97 150.5,162.02 151.62,162.02 151.76,162.16 152.81,162.16 152.82,162.15 153.14,162.15 153.15,162.16 153.19,162.16 154.77,163.75 155.09,163.75 155.38,164.04 155.48,164.42 155.19,164.68 155.17,164.68 155.14,164.72 155.14,166.34 155.2,166.4 155.46,166.4
+5V_USB_PWR1 on TOP (solid shape): 21.83,47.9 21.83,47.3 21.8,47.28 21.8,46.94 21.65,46.8 21.65,46.72 21.64,46.7 21.64,46.62 21.65,46.61 21.65,45.88 21.7,45.82 21.7,45.6 21.64,45.54 21.51,45.54 21.13,45.92 20.27,45.92 20.24,45.94 20.21,45.95 20.05,46.11 20.05,46.13 18.68,46.13 18.17,46.64 18.17,47.53 18.42,47.78 18.46,47.78 18.69,48.01 21.71,48.01
+5V_USB_PWR1 on BOTTOM (solid shape): 21.22,47.59 21.22,44.77 20.87,44.42 20.87,41.88 20.62,41.62 18.79,41.62 17.98,40.82 16.19,40.82 15.94,41.07 15.94,42.89 18.1,45.06 18.1,47.03 18.11,47.07 18.1,47.12 18.1,47.4 18.11,47.4 18.11,47.66 18.18,47.73 21.08,47.73
+5V_USB_PWR2 on TOP (solid shape): 327.41,11.76 327.41,10.75 327.24,10.59 326.35,10.59 326.24,10.7 325.07,10.7 324.95,10.82 324.95,11.92 325.04,12.02 327.15,12.02
+5V_USB_PWR2 on TOP (solid shape): 320.99,21.95 320.99,21.2 321.17,21.03 322.31,21.03 322.63,20.71 322.63,20.31 322.47,20.16 322.41,20.16 322.39,20.14 322.39,20.12 322.25,19.98 322.08,19.82 322.08,19.44 321.94,19.3 321.58,19.3 321.43,19.15 319.68,19.15 319.47,19.35 319.47,21.95 319.62,22.1 320.84,22.1
+5V_USB_PWR2 on IN1 (solid shape): outline of 1102 points within 319.45,9.47 327.73,22.17
+5V_USBC_VBUS on BOTTOM (solid shape): 15.06,54.52 15.06,53.47 15.26,53.27 16.66,53.27 16.79,53.14 16.79,52.63 16.66,52.5 14.94,52.5 14.67,52.24 14.67,51.4 14.48,51.21 11.06,51.21 10.74,51.53 10.74,54.71 10.93,54.9 14.68,54.9
+5V_USBC_VBUS on BOTTOM (solid shape): 11.03,58.36 11.79,58.36 12.2,57.94 12.2,57.06 12.07,56.93 11.69,56.93 11.57,57.06 11.57,57.18 11.38,57.37 10.8,57.37 10.39,57.79 8.64,57.79 7.85,58.58 7.85,58.86 8.07,59.09 10.3,59.09
+5V_USBC_VBUS on BOTTOM (solid shape): 11.44,63.28 11.44,62.01 11.25,61.82 10.04,61.82 9.8,61.92 9.55,61.83 9.53,61.82 9.09,61.37 8.07,61.37 8.01,61.44 8.01,61.94 8.72,62.65 8.97,62.91 9,62.91 9.28,63.01 9.38,63.29 9.38,63.31 9.53,63.47 11.25,63.47
+5V_USBC_VBUS on IN2 (solid shape): outline of 430 points within 6.41,52.8 13.03,62.26
+5VALW on TOP (solid shape): 223.15,167.38 223.15,165.35 222.71,164.91 221.35,164.91 221.24,165.03 221.24,167.32 221.49,167.58 222.94,167.58
+5VALW on TOP (solid shape): 224.86,27.53 224.86,26.83 224.74,26.7 224.1,26.7 223.66,26.26 223.47,26.26 223.34,26.38 223.34,27.53 223.47,27.65 224.74,27.65
+5VALW on TOP (solid shape): 318.91,22.96 318.91,20.9 318.77,20.76 317.98,20.76 317.8,20.94 317.19,20.94 317.12,21.01 317.12,22.71 317.43,23.03 318.83,23.03
+5VALW on TOP (solid shape): 322.86,8.13 323.45,8.13 323.71,7.88 323.71,7.05 323.39,6.74 320.53,6.74 320.28,6.99 320.28,7.37 319.14,8.51 319.14,10.13 319.28,10.27 320.72,10.27
+5VALW on TOP (solid shape): 21.7,43.57 21.7,43.34 21.65,43.29 21.65,42.5 21.62,42.47 21.62,40.18 21.45,40.01 20.3,40.01 20.05,40.27 20.05,42.17 21.51,43.63 21.64,43.63
+5VALW on TOP (solid shape): 46.74,46.2 46.74,44.05 46.59,43.9 45.92,43.9 45.92,44.45 45.22,44.45 45.22,43.9 44.72,43.9 44.72,44.45 44.02,44.45 44.02,43.9 43.34,43.9 43.15,43.71 43.15,43.56 42.91,43.31 39.44,43.31 39.44,43.83 38.74,43.83 38.74,43.31 38.24,43.31 38.24,43.83 37.54,43.83 37.54,43.31 36.98,43.31 36.97,43.33 36.97,47.15 37.57,47.75 45.19,47.75
+5VALW on TOP (solid shape): outline of 2101 points within 142.31,150.57 210.01,165.96
+5VALW on BOTTOM (solid shape): 25.39,49.58 25.39,48.08 25.19,47.89 23.4,47.89 23.4,47.89 23.17,47.89 23.17,49.32 23.23,49.37 24.06,49.37 24.52,49.83 25.13,49.83
+5VALW on BOTTOM (solid shape): 62.96,17.79 62.96,16.68 63.99,15.65 63.99,14.78 63.93,14.71 60.54,14.71 59.4,15.86 59.4,17.47 59.54,17.62 60.19,17.62 60.36,17.44 60.36,16.92 60.58,16.69 60.9,16.69 61.39,17.19 61.64,17.19 61.79,17.34 61.79,17.84 61.9,17.94 62.81,17.94
+5VALW on BOTTOM (solid shape): 205.62,161.58 205.62,159.61 205.81,159.42 207.78,159.42 207.91,159.29 207.91,159.28 208.31,158.88 208.3,158.85 208.27,158.76 208.26,158.67 208.26,158.49 208.38,158.17 208.69,158.01 208.7,158.01 208.7,154.39 208.52,154.21 206.97,154.21 205.47,155.72 205.47,156.08 205.39,156.15 205.39,156.17 205.37,156.24 205.33,156.32 205.1,156.47 204.83,156.4 203.67,156.4 203.5,156.57 203.5,159.19 203.14,159.55 203.14,159.57 203.07,159.68 202.97,159.76 202.94,159.77 202.94,161.6 203.02,161.69 203.22,161.69 203.44,161.47 203.45,161.47 203.6,161.32 203.6,161.31 203.65,161.26 204.1,161.26 204.34,161.5 204.34,161.74 204.4,161.8 205.39,161.8
+5VALW on BOTTOM (solid shape): outline of 405 points within 100.62,46.76 109.15,66.87
+5VALW on IN1 (solid shape): outline of 620 points within 312.7,8.73 321.62,23.11
+5VALW on IN1 (solid shape): outline of 3874 points within 147.08,154.31 210.09,183.36
+5VALW on IN2 (solid shape): outline of 163 points within 20.33,39.85 25.79,49.69
+5VALW on IN2 (solid shape): outline of 4720 points within 142.44,153.07 208.83,182.92
+5VALW on IN3 (solid shape): outline of 1667 points within 116.19,145.71 146.07,165.96
+5VALW on IN4 (solid shape): outline of 3432 points within 39.05,43.63 149.76,179.98
+5VALW on IN6 (solid shape): outline of 421 points within 223.21,20.71 228.22,32.6
+5VALW on IN5: 156.47,166.47 156.47,165.63 150.51,159.68 146.85,159.68 132.94,145.77 113.61,145.77 113.59,145.79 113.59,162.93 121.94,162.93 122.6,162.27 123.3,161.8 124.13,161.63 140.12,161.63 141.65,162.27 142.29,163.8 142.29,173.52 142.34,173.57 146.86,173.57 147,173.72 147,173.75 147.01,173.76 147.01,180.42 147.02,180.43 173.38,180.43 173.42,180.39 173.42,174.05 173.4,174.03 156.62,174.03 156.47,173.88 156.47,166.98 156.47,166.47
+5VALW on IN5: outline of 125 points within 16.01,1.17 334.15,68.1
+5VALWP on TOP (solid shape): 44.59,43.78 45.34,43.78 45.34,44.32 45.79,44.32 45.79,43.78 46.45,43.78 46.49,43.74 46.49,42.45 46.31,42.27 44.24,42.27 43.17,41.2 43.17,40.5 42.9,40.23 37.85,40.23 36.97,41.12 36.97,43.15 37,43.18 37.64,43.18 37.67,43.19 37.67,43.71 38.11,43.71 38.11,43.19 38.14,43.18 38.84,43.18 38.87,43.19 38.87,43.71 39.31,43.71 39.31,43.19 39.34,43.18 40.12,43.18 40.12,43.19 42.96,43.19 43.07,43.3 43.12,43.34 43.17,43.39 43.29,43.51 43.29,43.6 43.47,43.78 44.14,43.78 44.14,44.32 44.59,44.32
+5VALWP on BOTTOM (solid shape): outline of 508 points within 36.39,38.32 47.48,46.45
+5VS on TOP (solid shape): 94.85,9.28 94.85,7.21 94.4,6.75 90.61,6.75 90.27,7.09 90.27,9.52 90.66,9.91 94.22,9.91
+5VS on TOP (solid shape): 108.09,21.18 108.09,20.03 107.9,19.84 106.82,19.84 105.8,20.86 105.8,21.94 105.99,22.13 107.13,22.13
+5VS on TOP (solid shape): 108.12,63.72 108.12,60.67 107.88,60.43 107.35,60.43 105.94,59.02 104.94,59.02 104.81,59.15 104.81,59.77 104.95,59.91 105.23,59.91 105.46,60.14 105.46,60.24 105.46,60.24 105.47,60.35 105.46,60.45 105.46,60.46 105.46,61.4 106.35,62.29 106.35,64.05 106.56,64.27 106.58,64.27 106.66,64.28 106.74,64.31 107.54,64.31
+5VS on TOP (solid shape): 290.76,78.26 290.94,78.21 291.13,78.26 291.41,78.26 292.01,77.67 292.01,76.31 292.12,76.2 292.12,76.19 292.18,76.11 292.26,76.06 292.26,76.05 293.18,75.14 293.18,74.2 293.02,74.05 291.54,74.05 290.67,73.18 289.78,73.18 289.47,73.5 289.47,74.3 290.29,75.13 290.29,77.98 290.57,78.26
+5VS on TOP (solid shape): 194.62,17.4 194.62,14.21 194.59,14.18 194.59,12.96 194.56,12.95 194.28,12.61 194.56,12.26 194.59,12.25 194.59,11.57 194.48,11.46 194.19,11.46 193.7,10.98 193.23,10.98 192.99,10.74 192.36,10.74 192.19,10.9 192.19,11.72 193.02,12.55 193.02,17.34 193.15,17.47 194.55,17.47
+5VS on TOP (solid shape): outline of 679 points within 129.85,4.32 162.39,10.82
+5VS on BOTTOM (solid shape): 44.65,49.37 44.65,47.21 44.59,47.15 42.74,47.15 42.36,47.53 42.36,49.88 42.55,50.07 43.95,50.07
+5VS on BOTTOM (solid shape): 226,170.04 226,168.55 225.62,168.16 224.67,168.16 224.33,168.5 224.33,170 224.43,170.1 225.94,170.1
+5VS on BOTTOM (solid shape): 35.76,51.33 35.76,48.36 35.31,47.91 33.35,47.91 33.09,48.17 33.09,49.85 33.32,50.07 33.99,50.07 34.19,50.27 34.19,51.36 34.39,51.56 35.53,51.56
+5VS on BOTTOM (solid shape): 163.3,10.16 163.3,7.16 162.73,6.59 162.73,4.61 162.6,4.49 162.16,4.49 161.97,4.68 161.97,6.62 162.19,6.85 162.19,8.66 162.03,8.82 158.59,8.82 158.12,8.35 155.96,8.35 155.84,8.48 155.84,10.13 156.22,10.51 162.95,10.51
+5VS on BOTTOM (solid shape): 58.48,12.74 58.5,12.74 58.5,12.73 59,12.73 59,12.74 59.02,12.74 59.02,13.26 59.26,13.26 59.28,13.25 59.28,12.74 59.3,12.74 59.3,12.73 59.72,12.73 61.06,11.4 62.38,11.4 62.59,11.19 62.59,9.18 62.28,8.86 60.62,8.86 60.57,8.86 57.98,8.86 57.58,9.26 57.58,11.09 56.93,11.74 56.93,12.59 57.07,12.73 58.2,12.73 58.2,12.74 58.22,12.74 58.22,13.26 58.48,13.26
+5VS on BOTTOM (solid shape): outline of 124 points within 274.48,20.63 285.12,32.64
+5VS on IN1 (solid shape): 224.71,152.15 224.71,151.21 224.48,150.98 223.53,150.98 222.65,151.86 222.65,152.55 222.86,152.75 224.11,152.75
+5VS on IN1 (solid shape): 292.99,76.03 292.99,75.11 292.44,74.57 291.54,74.57 291.11,75 291.11,76.16 291.26,76.31 292.71,76.31
+5VS on IN1 (solid shape): 225.68,169.09 225.68,168.18 225.62,168.13 223.87,168.13 223.61,168.4 223.61,169.09 223.83,169.32 225.45,169.32
+5VS on IN1 (solid shape): 300.1,63.25 300.76,61.64 302.37,60.98 305.67,60.98 305.75,60.93 305.76,60.84 306.09,60.34 306.42,60.84 306.43,60.93 306.51,60.98 308.24,60.98 308.24,59.92 308.07,59.76 305.53,59.76 305.31,59.98 305.27,59.98 305.26,59.99 304.97,60.12 304.7,59.98 302.18,59.98 301.91,60.1 301.63,59.98 301.43,59.98 301.13,60.15 300.82,59.98 300.11,59.98 299.01,61.08 298.98,61.15 299,61.22 299.07,61.53 298.87,61.77 298.84,61.78 298.84,63.41 298.97,63.53 300.1,63.53
+5VS on IN1 (solid shape): outline of 683 points within 58.81,6.26 94.37,11.53
+5VS on IN3 (solid shape): 284.57,22.79 284.57,19.27 284.37,19.07 283.09,19.07 282.96,19.2 282.96,22.97 283.09,23.11 284.25,23.11
+5VS on IN3 (solid shape): 283.9,7.31 283.9,5.26 283.63,4.99 281.9,4.99 281.69,5.2 281.69,5.95 281.73,6 281.76,6.07 282.23,6.54 282.23,6.67 282.22,6.69 282.22,7.18 282.55,7.51 283.7,7.51
+5VS on IN4 (solid shape): 109.04,61.06 109.04,59.34 108.66,58.96 106.12,58.96 105.8,59.28 105.8,61.25 105.93,61.37 108.72,61.37
+5VS on IN4 (solid shape): outline of 85 points within 106.75,20.8 109.36,26.38
+5VS on IN4 (solid shape): outline of 3359 points within 34.11,6.12 96.74,52.1
+5VS on IN5: 97.63,4.17 96.94,5.59 95.47,6.17 90.69,6.17 90.69,9.13 93.21,11.65 104.3,11.65 108.17,7.78 163.31,7.78 169.21,13.68 182.72,13.68 188.63,7.78 250.11,7.78 259.19,16.86 265.14,16.86 274.22,7.78 332.79,7.78 334.65,9.64 334.65,45.22 332.35,47.53 322.12,47.53 312.98,56.67 307.2,56.67 307.09,56.78 307.09,61.08 321.25,61.08 321.25,52.8 321.89,51.27 323.42,50.63 337.25,50.63 337.25,4.17 ; 1 cut-out
+5VS_TP_LED on BOTTOM (solid shape): 197.41,11.53 197.41,10.2 197.31,10 197.34,9.78 197.35,9.75 197.08,9.48 196.42,9.48 196.17,9.74 196.17,11.7 196.26,11.79 197.15,11.79
+AVDDL on TOP (solid shape): 272.98,165.82 272.98,165.16 272.83,165 272.2,165 272.2,165 272.07,165 272.01,164.94 272.01,164.28 271.94,164.22 269.45,164.22 269.43,164.23 269.43,164.97 269.51,165.1 269.53,165.25 269.77,165.49 270.47,165.49 270.9,165.91 272.89,165.91
+AVDDL on IN2 (solid shape): outline of 345 points within 270.23,156.79 276.56,165.47
+PVDD on TOP (solid shape): 31.55,6.65 31.55,5.67 31.06,5.18 30.81,5.18 30.68,5.3 30.68,5.62 31.19,6.13 31.19,6.57 31.33,6.71 31.49,6.71
+PVDD on TOP (solid shape): 39.82,7.21 39.82,6.76 39.76,6.7 38.43,6.7 38.17,6.95 37.28,6.95 37.16,7.08 37.16,7.27 37.22,7.33 39.7,7.33
+PVDD on TOP (solid shape): 36.84,6.64 36.84,6.06 36.9,6 37.22,6 38.05,5.18 38.24,5.18 38.3,5.11 38.3,4.79 38.24,4.73 38.05,4.73 37.09,5.68 36.71,5.68 36.54,5.86 36.54,6.65 36.6,6.71 36.76,6.71
+PVDD on TOP (solid shape): 30.95,7.26 30.95,6.97 30.81,6.83 30.62,6.83 30.11,6.32 30.11,5.62 29.6,5.11 29.6,4.03 29.35,3.78 28.46,3.78 28.33,3.91 28.33,4.29 28.77,4.73 28.77,5.37 28.96,5.56 28.96,6.26 29.03,6.32 29.61,6.32 29.8,6.51 29.8,7.02 30.12,7.33 30.88,7.33
+PVDD on BOTTOM (solid shape): 28.84,10.57 28.84,9.68 28.46,9.31 28.46,8.8 28.77,8.48 28.77,7.27 29.16,6.89 30.11,6.89 30.36,6.64 30.96,6.64 31.53,6.06 33.09,6.06 33.41,6.38 36.21,6.38 36.39,6.2 36.39,6.19 37.41,6.19 37.79,6.57 37.79,7.11 37.92,7.24 38.52,7.24 38.68,7.08 38.68,6.32 38.55,6.19 38.55,5.56 38.37,5.37 37.72,5.37 37.46,5.63 36.73,5.63 35.88,5.63 35.41,5.16 35.41,5.08 35.12,4.79 34.81,4.79 34.62,4.99 34.62,5.18 34.81,5.37 35.06,5.37 35.12,5.43 35.12,5.56 35.06,5.62 34.55,5.62 34.24,5.3 33.41,5.3 33.28,5.18 33.28,4.86 33.16,4.73 32.9,4.73 32.77,4.86 32.77,5.24 32.58,5.43 31.38,5.43 31.31,5.37 31.31,5.18 31.19,5.05 30.68,5.05 30.55,5.18 30.55,5.81 30.49,5.87 30.11,5.87 29.98,5.75 29.98,4.41 29.35,3.78 28.39,3.78 28.01,4.16 28.01,7.78 27.76,8.03 27.76,9.43 28.08,9.75 28.08,10.64 28.11,10.67 28.74,10.67
+V18R on TOP (solid shape): 309.42,20.31 309.09,20.31 308.93,20.47 306.3,20.47 306.23,20.54 306.23,20.66 306.35,20.78 308.78,20.78 309.04,21.04 309.42,21.04
+VCC_CORE on TOP (solid shape): outline of 1637 points within 153.81,100.61 179.7,132.43
+VCC_CORE on BOTTOM (solid shape): outline of 1587 points within 154.45,113.5 179.99,137.37
+VCC_CORE on IN1 (solid shape): outline of 3584 points within 154.18,100.88 179.9,132.56
+VCC_CORE on IN2 (solid shape): outline of 3041 points within 153.7,100.91 168.25,124.43
+VCC_CORE on IN3 (solid shape): outline of 2462 points within 154.59,101.21 167.5,123.77
+VCC_CORE on IN4 (solid shape): outline of 2468 points within 154.59,101.18 167.5,123.77
+VCC_CORE on IN6 (solid shape): outline of 2402 points within 153.65,103.65 166.14,124.23
+VCC_CORE on IN5: 167.18,101.29 153.73,101.35 153.73,121.07 156.28,123.62 156.28,133.45 179.16,133.45 179.84,132.77 179.84,125.11 178.57,123.83 165.82,123.83 164.78,122.79 164.78,115.67 164.73,115.62 164.73,110.48 166.3,108.9 166.3,103.09 167.46,101.93 167.46,101.36 167.39,101.29
+VCCGT on TOP (solid shape): outline of 3103 points within 132.06,101.33 153.56,135.03
+VCCGT on BOTTOM (solid shape): outline of 395 points within 138.8,101.16 151.91,102.96
+VCCGT on BOTTOM (solid shape): outline of 2104 points within 131.8,113.09 155.2,135.8
+VCCGT on IN1 (solid shape): outline of 4972 points within 132.18,101.49 153.36,135.1
+VCCGT on IN2 (solid shape): outline of 4255 points within 133.1,101.38 154.43,124.44
+VCCGT on IN3 (solid shape): outline of 3789 points within 132.98,101.51 152.98,124.75
+VCCGT on IN4 (solid shape): outline of 4609 points within 132.6,101.31 153.04,124.37
+VCCGT on IN6 (solid shape): outline of 3534 points within 132.91,103.75 153.29,124.23
+VCCGT on IN5: 137.66,101.35 137.66,114.41 132.9,119.17 132.9,129.19 140.02,136.31 140.32,136.62 154.91,136.62 155.77,135.75 155.77,123.84 153.22,121.28 153.22,101.35
+VCCIO on TOP (solid shape): 168.3,110.34 168.4,110.29 168.42,110.18 168.44,109.97 168.57,109.81 168.63,109.7 168.58,109.59 168.45,109.19 168.83,109 168.87,109 169.14,108.73 169.12,108.69 169.09,108.46 169.21,108.27 169.21,107.93 169.65,107.5 169.65,107.4 169.6,107.3 169.49,107.28 169.08,106.96 169.49,106.64 169.6,106.62 169.65,106.52 169.65,105.83 169.6,105.73 169.49,105.71 169.16,105.61 169.1,105.28 169.1,104.5 168.84,104.24 167.32,104.24 167.04,104.52 167.04,105.3 167.08,105.39 167.18,105.42 167.33,105.44 167.46,105.53 167.7,105.77 168.6,105.77 168.6,106.61 167.51,106.61 167.51,106.58 167.26,106.33 167.12,106.3 167.04,106.42 167.04,110.12 167.26,110.34
+VCCIO on BOTTOM (solid shape): 122.72,100.9 123.48,100.9 123.48,101.45 123.92,101.45 123.92,100.9 124.68,100.9 124.68,101.45 125.99,101.45 126.39,101.05 126.39,99.88 125.46,98.95 122.6,98.95 121.94,99.61 121.94,101.31 122.09,101.45 122.72,101.45
+VCCIO on BOTTOM (solid shape): outline of 142 points within 166.23,103.19 169.7,113.13
+VCCIO on IN2 (solid shape): outline of 13581 points within 123.34,83.44 171.61,101.63
+VCCIO on IN3 (solid shape): outline of 5884 points within 153.27,87 171.28,112.74
+VCCIO on IN5: 130.54,88.36 123.39,95.51 123.39,98.73 125.5,100.84 153.48,100.84 167.18,100.78 167.6,100.78 167.97,101.15 167.97,102.14 166.81,103.3 166.81,109.12 165.24,110.69 165.24,114.9 165.55,114.59 167.75,114.59 168.46,115.29 168.46,116.68 169.2,117.42 175.78,117.42 175.78,93.36 170.78,88.36
+VCCIOP on BOTTOM (solid shape): 127.57,108.42 127.57,107 126.96,106.4 125.6,106.4 125.24,106.03 125.24,104.13 125.13,104.02 125.13,103.7 125.24,103.58 125.24,101.6 124.51,101.6 124.51,101.04 124.09,101.04 124.09,101.6 123.32,101.6 123.32,101.04 122.88,101.04 122.88,101.6 122.15,101.6 122.15,106.83 123.98,108.65 127.34,108.65
+VCCSA on TOP (solid shape): outline of 1168 points within 164.35,108.07 184.1,129.52
+VCCSA on BOTTOM (solid shape): 186.39,132.67 186.79,132.67 186.93,132.52 186.93,129.36 185.88,128.31 185.87,128.31 185.03,127.46 185,127.46 184.6,127.07 180.45,127.07 180.22,127.3 180.22,131.42 185.83,131.42 185.83,131.36 185.85,131.31 185.87,131.26 185.89,131.22 185.93,131.17 185.96,131.14 186.01,131.11 186.06,131.08 186.11,131.07 186.16,131.06 186.21,131.06 186.27,131.07 186.32,131.08 186.37,131.11 186.41,131.14 186.45,131.17 186.48,131.22 186.51,131.26 186.53,131.31 186.54,131.36 186.54,131.42 186.54,131.47 186.53,131.52 186.51,131.57 186.48,131.62 186.45,131.66 186.41,131.7 186.37,131.73 186.32,131.75 186.27,131.76 186.21,131.77 186.16,131.77 186.11,131.76 186.06,131.75 186.01,131.73 185.96,131.7 185.93,131.66 185.89,131.62 185.87,131.57 185.85,131.52 185.83,131.47 185.83,131.42 180.22,131.42 180.22,131.8 180.66,132.24 184.41,132.24 184.85,132.68 186.38,132.68
+VCCSA on BOTTOM (solid shape): outline of 414 points within 165.1,113.4 168.02,122.98
+VCCSA on IN1 (solid shape): outline of 936 points within 165.45,115.1 186.74,129.54
+VCCSA on IN2 (solid shape): outline of 1018 points within 165.63,114.87 174.96,123.26
+VCCSA on IN5: 165.76,115.09 165.29,115.57 165.29,122.58 166.03,123.32 178.78,123.32 180.35,124.89 180.35,132.62 185.96,132.62 187.65,130.93 187.65,123.25 182.33,117.93 168.99,117.93 167.95,116.89 167.95,115.5 167.54,115.09
+VCCST on TOP (solid shape): 177.06,91.57 177.06,88.33 178.69,86.71 178.69,81.9 178.82,81.76 178.82,81.06 178.63,80.87 176.41,80.87 175,82.28 175,84.61 172.67,86.94 172.67,92.55 172.68,92.55 172.68,92.6 173.06,92.98 175.65,92.98
+VCCST on TOP (solid shape): 169.74,115.11 169.74,114.59 169.62,114.47 168.96,114.47 168.85,114.36 168.82,114.36 168.57,114.27 168.47,114.01 168.47,113.99 168.28,113.79 168.28,112.14 168.15,112.01 167.66,112.01 167.62,112.06 167.62,112.69 167.43,112.88 167.07,112.88 166.96,112.99 166.96,113.79 167.24,114.07 167.63,114.07 167.8,114.24 167.8,114.75 167.91,114.86 168.27,114.86 168.57,115.16 169.69,115.16
+VCCST on IN2 (solid shape): outline of 4874 points within 167.91,90.34 176.59,117.13
+VCCSTG on TOP (solid shape): 178.89,98.52 178.89,97.7 178.82,97.63 176.48,97.63 176.35,97.76 176.35,98.46 176.54,98.65 178.76,98.65
+VCCSTG on TOP (solid shape): 182.87,84.44 182.87,83.62 182.87,83.47 182.3,82.9 182.06,82.9 181.87,82.71 181.87,81.82 182.03,81.67 182.97,81.67 183.13,81.5 183.13,81.1 182.94,80.9 180.53,80.9 180.39,81.05 180.39,84.38 180.64,84.64 182.67,84.64
+VCCSTG on BOTTOM (solid shape): 128.4,114.23 129.22,114.23 129.29,114.16 129.29,112.64 129.22,112.57 127.39,112.57 127.25,112.71 127.25,114.14 127.34,114.23 128.4,114.23
+VCCSTG on IN1 (solid shape): outline of 1612 points within 167.52,97.24 180.41,116.43
+VDD_TOUCH on TOP (solid shape): 168.29,181.99 168.29,181.41 167.79,180.91 167.79,179.76 167.73,179.69 167.53,179.69 167.48,179.74 167.48,182.02 167.67,182.21 168.07,182.21
+VDD_TOUCH on BOTTOM (solid shape): 167.47,172.23 167.47,171.98 167.72,171.72 167.98,171.72 168.02,171.68 168.02,170.81 167.86,170.65 166.75,170.65 166.7,170.69 166.7,172.21 166.75,172.26 167.45,172.26
+VDD_TOUCH on IN6 (solid shape): outline of 264 points within 165.36,170.49 168.78,182.33
+VDDCT_L on TOP (solid shape): 257.01,157.87 257.01,156.42 257.19,156.24 258.64,156.24 258.83,156.05 258.83,155.16 258.52,154.85 255.34,154.85 254.64,155.54 251.6,155.54 250.9,154.85 247.21,154.85 246.71,155.35 246.71,156.12 246.83,156.24 248.17,156.24 248.37,156.44 248.37,157.74 248.48,157.85 249.33,157.85 249.49,157.69 249.49,156.33 249.58,156.24 256.17,156.24 256.29,156.36 256.29,157.89 256.39,157.98 256.9,157.98
+VDDCT_L on BOTTOM (solid shape): 250.1,157.15 250.1,154.69 249.75,154.34 247.84,154.34 247.71,154.48 247.71,156.95 248.58,157.82 249.43,157.82
+VDDCT_L on BOTTOM (solid shape): 257.14,157.5 257.56,157.5 257.78,157.28 257.78,154.74 257.44,154.4 255.75,154.4 255.52,154.63 255.52,156.99 256.41,157.87 256.76,157.87
GND on TOP (solid shape): 141.24,104.11 141.24,102.77 141.18,102.71 140.29,102.71 140.22,102.77 140.22,104.17 140.29,104.23 141.11,104.23
GND on TOP (solid shape): 143.65,104.11 143.65,102.77 143.62,102.74 142.67,102.74 142.64,102.77 142.64,104.17 142.7,104.23 143.53,104.23
GND on TOP (solid shape): 146.26,104.11 146.26,102.77 146.19,102.71 145.3,102.71 145.24,102.77 145.24,104.11 145.37,104.23 146.13,104.23
GND on TOP (solid shape): 148.67,104.11 148.67,102.77 148.61,102.71 147.72,102.71 147.65,102.77 147.65,104.17 147.78,104.3 148.48,104.3
GND on TOP (solid shape): 151.08,104.17 151.08,102.77 151.02,102.71 150.13,102.71 150.07,102.77 150.07,104.17 150.19,104.3 150.96,104.3
GND on TOP (solid shape): 154.07,75.34 154.07,72.61 153.81,72.36 150.77,72.36 150.51,72.61 150.51,75.4 150.83,75.72 153.69,75.72
GND on TOP (solid shape): 171.24,79.94 171.24,77.05 170.91,76.72 169.55,76.72 169.4,76.86 169.4,79.94 169.47,80.01 171.18,80.01
GND on TOP (solid shape): 175.79,144.76 175.79,143.4 175.62,143.23 174.95,143.23 174.57,143.61 174.57,145.01 174.63,145.07 175.48,145.07
GND on TOP (solid shape): 209.77,166.86 209.77,164.62 209.63,164.48 208.72,164.48 208.56,164.65 208.56,166.76 208.76,166.96 209.66,166.96
GND on TOP (solid shape): 209.78,169.93 209.78,168.39 209.71,168.32 207.34,168.32 207.19,168.47 207.19,169.86 207.34,170 209.7,170
GND on TOP (solid shape): 238.31,136.41 238.31,132.51 238.16,132.37 236.14,132.37 235.96,132.55 235.96,136.54 236.09,136.67 238.04,136.67
GND on TOP (solid shape): 238.89,169.63 238.89,167.84 238.84,167.79 237.14,167.79 237,167.92 237,169.32 237.41,169.73 238.79,169.73
GND on TOP (solid shape): 277.84,140.54 277.84,136.56 277.53,136.25 273.71,136.25 273.45,136.51 273.45,140.69 273.71,140.94 277.43,140.94
GND on TOP (solid shape): 294.61,63.65 294.61,61.49 294.43,61.31 292.15,61.31 292.07,61.39 292.07,64.15 292.25,64.33 293.92,64.33
GND on TOP (solid shape): 335.8,32.04 335.8,29.5 335.67,29.37 334.46,29.37 334.4,29.43 334.4,32.04 334.53,32.16 335.67,32.16
GND on TOP (solid shape): 45.35,42.07 45.35,40.6 45.15,40.41 43.58,40.41 43.38,40.61 43.38,41.13 44.36,42.12 45.3,42.12
GND on TOP (solid shape): 82.5,20.48 82.5,19.02 82.37,18.89 80.52,18.89 80.4,19.01 80.4,20.42 80.65,20.67 82.3,20.67
GND on TOP (solid shape): 146.72,126.87 146.72,124.29 145.18,122.75 142.77,122.75 142.49,123.03 142.49,123.71 143.7,124.92 143.7,126.95 143.91,127.16 146.43,127.16
GND on TOP (solid shape): 150.38,79.94 150.38,76.52 150.31,76.46 149.25,76.46 149.15,76.56 149.15,79.77 149.35,79.97 150.34,79.97
GND on TOP (solid shape): 152.35,79.83 152.35,76.55 152.29,76.48 150.87,76.48 150.58,76.78 150.58,79.78 150.77,79.98 152.21,79.98
GND on TOP (solid shape): 188.73,127.73 188.73,123.87 188.45,123.59 184.82,123.59 184.55,123.86 184.55,127.73 184.91,128.1 188.37,128.1
GND on TOP (solid shape): 220.96,103.82 220.96,102.91 220.84,102.79 218.42,102.79 218.36,102.85 218.36,103.35 219,103.99 220.79,103.99
GND on TOP (solid shape): 221.52,170.57 221.52,169.89 221.28,169.65 221.28,167.86 221.16,167.74 220.09,167.74 219.98,167.86 219.98,170.07 220.63,170.72 221.37,170.72
GND on TOP (solid shape): 229.29,136.43 229.29,132.64 228.96,132.31 226.82,132.31 226.66,132.47 226.66,136.48 226.87,136.69 229.03,136.69
GND on TOP (solid shape): 256.18,5.2 256.18,4.54 255.95,4.31 249.8,4.31 249.69,4.41 249.69,5.3 249.82,5.43 255.95,5.43
GND on TOP (solid shape): 292.52,45.43 292.52,43.37 292.3,43.15 292.3,37.5 291.92,37.12 290.78,37.12 290.33,37.56 290.33,45.63 290.58,45.88 292.08,45.88
GND on TOP (solid shape): 220.95,107.2 220.95,105.28 220.75,105.07 218.88,105.07 218.47,105.48 218.47,107.39 218.72,107.64 220.51,107.64
GND on TOP (solid shape): 284.96,64.61 284.96,61.53 284.76,61.32 282.44,61.32 282.01,61.75 282.01,64.61 282.27,64.87 284.7,64.87
GND on TOP (solid shape): 8.14,64.99 8.14,64.29 7.82,63.98 7.06,63.98 6.49,63.41 6.49,63.15 6.36,63.02 5.79,63.02 5.6,63.21 5.6,64.68 6.1,65.18 7.95,65.18
GND on TOP (solid shape): 171.59,75.72 171.59,72.93 171.28,72.61 168.18,72.61 168.04,72.76 168.04,75.72 168.29,75.98 171.34,75.98
GND on TOP (solid shape): 176.03,64.33 176.03,62.58 176.41,62.2 176.41,61.31 176.09,60.99 174.95,60.99 174.7,61.25 174.7,64.32 174.84,64.45 175.91,64.45
GND on TOP (solid shape): 179.21,40.16 179.21,39.53 179.46,39.28 179.46,35.91 179.27,35.72 177.94,35.72 177.68,35.97 177.68,36.93 178.19,37.43 178.19,40.04 178.44,40.29 179.08,40.29
GND on TOP (solid shape): 222.45,134.84 222.45,134.02 222.2,133.77 220.67,133.77 220.31,133.41 220.31,132.3 219.96,131.94 218.16,131.94 217.73,132.38 217.73,134.82 218,135.1 222.2,135.1
GND on TOP (solid shape): 200.43,183.6 200.75,183.45 201.1,183.4 205.22,183.4 205.22,176.7 199.22,176.7 199.22,183.6
GND on TOP (solid shape): 178.67,127.38 178.7,127.35 178.72,127.33 179.5,126.55 179.51,126.54 179.51,124.15 179.13,123.78 175.69,123.78 175.2,124.27 175.2,128.7 175.6,129.09 176.96,129.09
GND on TOP (solid shape): 192.23,30.17 192.23,25.42 192.07,25.26 191.28,25.26 191.1,25.43 191.1,26.25 190.68,26.68 190.28,26.68 190.17,26.79 189.72,26.79 189.57,26.94 189.57,29.98 189.82,30.23 192.17,30.23
GND on TOP (solid shape): 313.32,43.39 313.32,40.07 313.15,39.91 312.47,39.91 312.15,40.23 311.67,40.23 311.44,40.46 311.44,41.24 311.29,41.39 311.29,43.34 311.54,43.59 313.11,43.59
GND on TOP (solid shape): 274.76,163.92 274.76,158.51 274.5,158.25 270.74,158.25 270.73,158.26 269.66,158.26 269.34,158.58 269.34,163.84 269.53,164.04 274.65,164.04
GND on TOP (solid shape): 188.86,159.02 190.06,159.02 190.45,158.62 190.45,156.91 190.14,156.59 188.67,156.59 188.18,157.08 188.18,157.38 188.18,159.23 188.28,159.33 188.56,159.33
GND on TOP (solid shape): 146.93,132.88 146.92,132.86 146.92,132.76 146.94,132.66 146.95,132.65 146.95,129.19 146.67,128.91 144.24,128.91 143.91,129.24 143.91,131.8 144.22,132.11 144.66,132.11 145.59,133.04 146.77,133.04
