# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_D58: length 39.3
  IN1 w0.102: v2(249.47,103.45) 249.65,103.45 249.8,103.3 249.8,103.3 250.02,103.08 250.02,103.08 250.2,102.9 251.93,102.9 251.99,102.84 253.52,102.84 253.89,103.21
  IN1 w0.13: v2(282.55,113.76) 282.15,113.36 282.15,112.63 280.87,111.35 277.01,111.35 275.86,110.2 264.93,110.2 257.95,103.22 253.9,103.22 253.89,103.21
  BOTTOM w0.102: UG2.T4 v2(282.55,113.76) ; v2(249.47,103.45) UG9.AN45
FBA_D59: length 41.5
  IN1 w0.102: 249.79,106.57 249.79,105.12 249.85,105.05 249.85,103.77 v2(250.17,103.45)
  IN1 w0.13: v2(281.75,116.16) 281.35,116.56 277.51,116.56 276.55,115.6 276.55,114.35 276.28,114.08 275.66,114.08 274.92,113.34 263.31,113.34 257.72,107.75 257.08,107.75 255.8,106.47 252.86,106.47 252.56,106.77 249.98,106.77 249.79,106.57
  BOTTOM w0.102: UG2.T2 v2(281.75,116.16) ; v2(250.17,103.45) UG9.AN46
FBA_D60: length 32.9
  IN1 w0.13: v2(279.35,114.56) 278.95,114.16 278.95,113.55 278.76,113.36 278.35,113.36 277.44,112.45 276.36,112.45 275.36,111.45 264.12,111.45 257.77,105.1 255.58,105.1 254.77,104.29 253.68,104.29 253.53,104.44 252.77,104.44 252.58,104.25 v2(252.17,104.25)
  BOTTOM w0.102: v2(252.17,104.25) UG9.AR48 ; UG2.N4 v2(279.35,114.56)
FBA_D61: length 37.1
  IN1 w0.102: v2(250.87,103.45) 250.99,103.45 251.34,103.09 252,103.09 252.02,103.08 253.08,103.08 253.42,103.42
  IN1 w0.13: 253.42,103.42 253.68,103.42 254.04,103.79 257.48,103.79 264.53,110.84 275.82,110.84 276.93,111.95 278.91,111.95 280.08,113.12 280.08,113.75 279.75,114.08 279.75,114.96 v2(279.35,115.36)
  BOTTOM w0.102: v2(279.35,115.36) 279.56,115.58 UG2.N2 ; v2(250.87,103.45) UG9.AN47
FBA_D62: length 32
  IN1 w0.13: v2(251.47,104.25) 252,104.78 253.92,104.78 254.82,105.68 256.45,105.68 256.99,106.22 257.93,106.22 263.76,112.06 275.17,112.06 276.06,112.95 276.94,112.95 277.75,113.76 v2(278.55,113.76)
  BOTTOM w0.102: UG2.M4 278.79,114 v2(278.55,113.76) ; v2(251.47,104.25) UG9.AR47
FBA_D63: length 34.5
  IN1 w0.13: v2(250.77,104.25) 250.77,104.7 251.2,105.13 253.71,105.13 254.66,106.08 256.14,106.08 256.89,106.83 257.67,106.83 263.56,112.72 275,112.72 275.77,113.5 276.73,113.5 277.34,114.11 277.34,114.96 v2(278.55,116.16)
  BOTTOM w0.102: UG2.M2 v2(278.55,116.16) ; UG9.AR46 v2(250.77,104.25)
FBA_DBI0: length 23.7
  IN2 w0.117: v2(251.47,91.65) 251.47,91.7 251.75,91.98 254.15,91.98 254.53,91.6 263.33,91.6 266.97,87.96 271.75,87.96 v2(272.15,88.36)
  BOTTOM w0.102: UG9.U47 v2(251.47,91.65) ; UG1.P2 272.15,88.36 v2(272.15,88.36)
FBA_DBI1: length 23.4
  IN2 w0.117: v2(272.15,97.16) 271.76,96.77 271.76,95.27 271.64,95.16 259.34,95.16 258.26,94.08 254.83,94.08 254.32,93.56 v2(253.06,93.56)
  BOTTOM w0.102: v2(253.06,93.56) 252.9,93.72 252.44,93.72 252.11,94.05 UG9.Y48 ; UG1.P13 v2(272.15,97.16)
FBA_DBI2: length 37.7
  IN2 w0.117: v2(280.95,96.36) 281.35,96.76 281.95,96.76 282.15,96.96 282.15,98.38 282.16,98.39 282.16,98.73 282.15,98.75 282.15,99.21 279.73,101.63 256.42,101.63 253.63,98.84 251.88,98.84 v2(251.47,99.25)
  BOTTOM w0.102: UG1.D13 v2(280.95,96.36) ; UG9.AG47 v2(251.47,99.25)
FBA_DBI3: length 40.6
  IN2 w0.117: v2(252.97,95.75) 256.89,95.75 258.81,97.67 267.7,97.67 268.38,98.35 274.72,98.35 274.95,98.12 274.95,97.8 275.19,97.56 275.51,97.56 275.75,97.32 275.75,97 275.99,96.76 276.31,96.76 276.56,96.51 276.56,95.27 276.93,94.9 276.93,92.98 278.95,90.96 278.95,89.79 279.18,89.56 281.13,89.56 281.35,89.34 281.35,88.13 281.17,87.96 280.54,87.96 v2(280.15,87.56)
  BOTTOM w0.102: v2(280.15,87.56) 280.37,87.78 UG1.D2 ; UG9.AC48 252.11,96.15 252.44,95.82 252.9,95.82 v2(252.97,95.75)
FBA_DBI4: length 23.7
  IN2 w0.117: v2(254.27,109.15) 253.95,109.47 253.95,109.59 253.95,111.09 257.8,114.94 267.99,114.94 269.36,116.32 269.36,116.32 269.59,116.55 269.59,116.55 269.6,116.55 271.76,116.55 v2(272.15,116.16)
  BOTTOM w0.102: UG2.D2 v2(272.15,116.16) ; UG9.BB51 v2(254.27,109.15)
FBA_DBI5: length 26.9
  IN2 w0.117: v2(272.15,106.56) 271.75,106.96 271.75,109.46 271.26,109.95 268.43,109.95 267.76,109.28 258.96,109.28 257.94,110.3 257.34,110.3 v2(256.94,110.7)
  BOTTOM w0.102: v2(256.94,110.7) 256.55,110.31 256.55,108.73 256.22,108.4 256.22,107.25 255.06,106.09 254.33,106.09 254.12,106.3 253.62,106.3 UG9.AV50 ; UG2.D13 272.55,106.96 v2(272.15,106.56)
FBA_DBI6: length 33.3
  IN2 w0.117: v2(280.95,106.56) 281.35,106.16 281.35,104.81 279.71,103.17 276.13,103.17 276.12,103.16 262.5,103.16 262.48,103.17 254.09,103.17 v2(252.97,102.05)
  BOTTOM w0.102: v2(252.97,102.05) 252.92,102.1 252.44,102.1 252.09,102.45 UG9.AM48 ; UG2.P13 v2(280.95,106.56)
FBA_DBI7: length 37.3
  IN2 w0.117: v2(280.15,116.16) 279.75,115.76 278.4,115.76 278.39,115.75 278.39,115.75 278.16,115.52 278.16,115.52 278.14,115.5 278.14,112.1 276.34,110.3 276.34,110.3 276.11,110.07 276.11,110.07 275.75,109.71 275.75,106.29 275.43,105.97 269.23,105.97 268.86,106.34 257.76,106.34 v2(256.95,105.53)
  BOTTOM w0.102: v2(280.15,116.16) 280.4,115.91 280.4,115.91 UG2.P2 ; UG9.AR49 252.92,104.9 254.8,104.9 254.87,104.83 255.38,104.83 256.08,105.53 v2(256.95,105.53)
FBA_EDC0: length 22.4
  IN2 w0.117: v2(271.35,87.56) 270.94,87.15 266.45,87.15 262.54,91.07 254.09,91.07 253.48,90.46 252.56,90.46 v2(252.17,90.85)
  BOTTOM w0.102: UG1.R2 v2(271.35,87.56) ; v2(252.17,90.85) UG9.R48
FBA_EDC1: length 22.2
  IN2 w0.117: v2(252.17,92.96) 252.55,93.34 252.55,93.76 253,94.21 254.02,94.21 254.41,94.6 257.96,94.6 259.34,95.97 268.21,95.97 268.99,96.75 270.96,96.75 v2(271.35,96.36)
  BOTTOM w0.102: v2(252.17,92.96) 252.16,92.95 252.16,92.94 UG9.V48 ; UG1.R13 v2(271.35,96.36)
FBA_EDC2: length 37
  IN2 w0.117: v2(249.37,97.95) 249.74,98.32 250.71,98.32 250.72,98.33 251.03,98.33 251.03,98.32 254.13,98.32 256.75,100.94 279.46,100.94 281.35,99.05 281.35,97.56 v2(281.75,97.16)
  BOTTOM w0.102: UG9.AF44 v2(249.37,97.95) ; UG1.C13 v2(281.75,97.16)
FBA_EDC3: length 38.5
  IN2 w0.117: v2(280.95,88.36) 280.56,88.75 277.5,88.75 277.34,88.92 277.34,89.32 274.96,91.7 274.96,96.2 274.96,96.2 274.96,96.52 274.96,96.53 274.96,97 274.96,97 274.96,97.31 274.71,97.56 268.54,97.56 267.85,96.87 259.15,96.87 257.47,95.19 254.17,95.19 253.69,94.71 252.57,94.71 v2(252.18,95.1)
  BOTTOM w0.102: v2(280.95,88.36) 281.35,87.96 UG1.C2 ; v2(252.18,95.1) 252.18,95.06 UG9.AA48
FBA_EDC4: length 20.7
  IN2 w0.117: v2(271.35,115.36) 270.95,114.96 269.37,114.96 268.68,114.27 258.01,114.27 254.71,110.97 254.71,110.39 v2(254.85,110.25)
  BOTTOM w0.102: v2(271.35,115.36) 271.56,115.57 271.56,115.58 UG2.C2 ; v2(254.85,110.25) 254.8,110.2 254.8,109.79 254.8,109.79 254.8,109.58 UG9.BB52
FBA_EDC5: length 24.3
  IN2 w0.117: v2(271.35,107.36) 270.95,107.76 270.95,109.11 270.94,109.12 270.94,109.12 270.71,109.35 270.71,109.35 270.61,109.44 269.36,109.44 268.52,108.6 258.1,108.6 v2(257.15,109.55)
  BOTTOM w0.102: UG9.AT50 253.42,105.25 253.77,105.6 254.17,105.6 254.22,105.65 255.41,105.65 256.91,107.15 256.91,107.77 257.38,108.24 257.38,109.32 v2(257.15,109.55) ; UG2.C13 271.58,107.13 v2(271.35,107.36)
FBA_EDC6: length 35.4
  IN2 w0.117: v2(281.75,107.36) 282.14,106.97 282.14,104.65 279.95,102.46 255.28,102.46 253.95,101.12 252.46,101.12 v2(252.2,101.39)
  BOTTOM w0.102: UG9.AK48 251.87,101.06 v2(252.2,101.39) ; UG2.R13 v2(281.75,107.36)
FBA_EDC7: length 36.1
  IN2 w0.117: v2(256.37,104.54) 256.77,104.94 258.16,104.94 258.8,105.58 267.84,105.58 268.91,104.51 272.72,104.51 273.03,104.83 275.41,104.83 276.55,105.96 276.55,109.42 276.66,109.52 276.66,109.52 276.89,109.75 276.89,109.75 280.55,113.42 280.55,114.96 v2(280.95,115.36)
  BOTTOM w0.102: v2(280.95,115.36) UG2.R2 ; UG9.AR51 254.19,104.55 254.55,104.19 256.02,104.19 v2(256.37,104.54)
FBA_WCK01: length 26.8
  IN2 w0.089: v2(249.47,91.65) 249.47,91.95 249.83,92.31 254.08,92.31 254.91,93.13 259.35,93.13 259.7,93.48 262.9,93.48 265.69,90.69 271.17,90.69 271.75,90.11 271.75,89.8 272.15,89.39 v2(272.15,89.17)
  BOTTOM w0.102: UG9.U45 249.76,91.96 249.62,91.96 249.47,91.81 v2(249.47,91.65)
  BOTTOM w0.119: UG1.P4 272.16,89.17 v2(272.15,89.17)
FBA_WCK01#: length 26.7
  IN2 w0.089: v2(272.15,89.96) 271.24,90.87 265.77,90.87 262.98,93.66 259.63,93.66 259.28,93.31 254.83,93.31 254.01,92.49 249.76,92.49 249.36,92.09 249.21,92.09 v2(248.77,91.65)
  BOTTOM w0.102: UG9.U44 v2(248.77,91.65)
  BOTTOM w0.119: UG1.P5 v2(272.15,89.96)
FBA_WCK23: length 39
  IN2 w0.089: v2(280.15,89.96) 279.76,90.35 279.76,91 277.95,92.8 277.96,92.81 277.64,93.13 277.64,96.2 275.19,98.65 258.33,98.65 256.29,96.61 249.69,96.61 249.55,96.47 249.55,96.46 249.37,96.28 249.37,96.07 249.36,96.06 249.36,95.96 v2(249.47,95.85)
  BOTTOM w0.102: UG9.AC45 v2(249.47,95.85)
  BOTTOM w0.119: UG1.D4 280.39,89.72 v2(280.15,89.96)
FBA_WCK23#: length 39
  IN2 w0.089: v2(248.77,95.85) 248.96,95.85 249.18,96.07 249.18,96.36 249.42,96.59 249.42,96.59 249.47,96.65 249.47,96.65 249.61,96.79 256.21,96.79 258.25,98.83 275.27,98.83 277.82,96.27 277.82,93.2 279.95,91.07 279.95,90.96 v2(280.15,90.76)
  BOTTOM w0.102: UG9.AC44 v2(248.77,95.85)
  BOTTOM w0.119: v2(280.15,90.76) UG1.D5
FBA_WCK45: length 29.5
  IN2 w0.089: v2(272.95,114.56) 272.95,114.31 273.35,113.92 273.35,113.22 272.62,112.49 272.49,112.49 272.47,112.48 266.39,112.48 266.35,112.43 265.06,111.14 256.54,111.14 255.89,110.5 255.89,107.66 255.23,107 251.54,107 251.06,106.52 251.04,106.52 v2(250.87,106.35)
  BOTTOM w0.102: v2(250.87,106.35) UG9.AV47
  BOTTOM w0.119: v2(272.95,114.56) 272.73,114.34 UG2.D4
FBA_WCK45#: length 29.8
  IN2 w0.089: v2(250.17,106.35) 250.26,106.26 250.42,106.26 250.51,106.35 250.51,106.5 250.72,106.71 250.98,106.71 251.46,107.19 255.17,107.19 255.71,107.74 255.71,110.57 256.47,111.32 264.97,111.32 266.16,112.51 266.18,112.51 266.32,112.66 272.4,112.66 272.41,112.67 272.53,112.67 273.16,113.3 273.16,113.66 273.06,113.76 v2(272.95,113.76)
  BOTTOM w0.102: UG9.AV46 250.47,106.51 250.31,106.35 v2(250.17,106.35)
  BOTTOM w0.119: v2(272.95,113.76) 272.89,113.82 272.57,113.82 272.42,113.67 272.42,113.49 UG2.D5
FBA_WCK67: length 40.7
  IN2 w0.089: v2(249.47,104.25) 249.47,104.32 249.57,104.42 249.64,104.42 249.88,104.66 253.96,104.66 254.8,103.82 275.84,103.82 277.22,105.2 277.22,106.62 277.5,106.9 277.5,109.24 278.4,110.14 279.04,110.14 281.37,112.48 281.37,113.34 v2(280.95,113.76)
  BOTTOM w0.102: UG9.AR45 v2(249.47,104.25)
  BOTTOM w0.119: UG2.P4 280.59,114.16 280.95,113.8 v2(280.95,113.76)
FBA_WCK67#: length 40.8
  IN2 w0.089: v2(248.77,104.25) 248.96,104.25 249.32,104.61 249.58,104.61 249.81,104.84 254.03,104.84 254.87,104 275.77,104 277.05,105.28 277.05,106.69 277.32,106.97 277.32,109.34 278.32,110.33 278.96,110.33 281.18,112.55 281.18,112.82 281.04,112.96 v2(280.95,112.96)
  BOTTOM w0.102: v2(248.77,104.25) 248.77,104.43 248.89,104.55 UG9.AR44
  BOTTOM w0.119: v2(280.95,112.96) 280.84,112.86 280.67,112.86 280.44,113.08 280.44,113.26 UG2.P5
FBB_CLK0: length 40.2
  IN6 w0.102: 247.33,85.31 v2(247.97,85.95)
  IN6 w0.107: v2(259.59,59.31) 259.79,59.11 259.83,59.11 260.04,58.9 260.55,58.9 261.69,60.03 261.69,60.95 262.18,61.44 262.4,61.44 262.5,61.54 262.5,62.03 v2(262.74,62.26) 262.74,61.74 262.85,61.63 263.41,61.63 263.7,61.92 263.7,65.72 247.33,82.09 247.33,85.31
  BOTTOM w0.102: UG9.H42 v2(247.97,85.95)
  BOTTOM w0.119: v2(262.74,62.26) 262.91,62.08 RG113.1 ; v2(259.59,59.31) 259.27,59.31 259.19,59.23 UG3.J12
FBB_CLK0#: length 40
  IN6 w0.102: v2(247.97,85.25) 247.85,85.37 247.67,85.37 247.53,85.23
  IN6 w0.107: 247.53,85.23 247.53,82.17 263.89,65.8 263.89,62 263.9,62 263.9,61.84 263.49,61.43 262.96,61.43 262.74,61.21 v2(262.74,60.96) 262.46,61.24 262.26,61.24 261.88,60.87 261.88,59.95 260.64,58.71 259.96,58.71 259.75,58.91 259.46,58.91 v2(258.79,59.31)
  BOTTOM w0.102: UG9.G42 v2(247.97,85.25)
  BOTTOM w0.119: RG525.1 262.95,61.17 v2(262.74,60.96) ; v2(258.79,59.31) 258.57,59.1 258.57,59.09 UG3.J11
FBB_CLK1: length 39.7
  TOP w0.102: v2(273.45,69.41) 273.78,69.41 273.99,69.2 273.99,68.78 RG114.1
  IN1 w0.102: v2(250.87,83.95) 250.87,83.75 251.15,83.47 251.15,82.89
  IN1 w0.107: 251.15,82.89 251.6,82.44 251.6,81.18 253.05,79.73 260.35,79.73 271.59,68.49 273.7,68.49 274,68.79 274,68.94 273.73,69.21 273.65,69.21 v2(273.45,69.41) 274.1,69.41 274.76,70.07 275.5,70.07 276.53,71.11 276.53,71.96 276.36,72.14 276.36,72.16 v2(276.15,72.36)
  BOTTOM w0.102: v2(250.87,83.95) 251.07,83.95 251.17,84.05 UG9.F47
  BOTTOM w0.119: v2(276.15,72.36) 276.15,72.64 276.27,72.76 276.55,72.76 UG4.J12
FBB_CLK1#: length 39.7
  TOP w0.102: 274.2,69.25 274.37,69.41 v2(274.75,69.41)
  TOP w0.119: RG526.1 274.2,68.87 274.2,69.25
  IN1 w0.102: 250.91,82.86 250.91,83.13 v2(250.75,83.28)
  IN1 w0.107: 250.91,82.86 251.41,82.36 251.41,81.1 252.97,79.53 260.27,79.53 271.51,68.29 273.78,68.29 273.78,68.3 273.84,68.3 274.25,68.71 274.25,69.05 274.61,69.41 v2(274.75,69.41) 274.66,69.5 274.66,69.69 274.84,69.88 275.58,69.88 276.73,71.02 276.73,72.04 276.55,72.22 276.55,72.68 276.15,73.08 v2(276.15,73.16)
  BOTTOM w0.102: v2(250.75,83.28) 250.9,83.28 UG9.E47
  BOTTOM w0.119: UG4.J11 v2(276.15,73.16)
FBB_CMD0: length 30.7
  BOTTOM w0.102: 242.3,76.6 242.42,76.73 242.42,80.95 242.77,81.3 UG9.B35
  BOTTOM w0.185: UG3.G3 251.59,57.71 250.14,57.71 249.99,57.56 249.63,57.56 249.37,57.82 248.87,57.82 247.77,58.91 247.77,66.8 244.81,69.76 243.57,69.76 242.3,71.03 242.3,76.6
FBB_CMD1: length 29.6
  TOP w0.102: RG49.2 251.48,58.4 v2(251.59,58.51)
  BOTTOM w0.102: UG3.J3 251.82,58.74 v2(251.59,58.51) ; UG9.A35 242.77,76.58 242.72,76.53 242.72,73.7 242.84,73.58
  BOTTOM w0.185: v2(251.59,58.51) 250.08,58.51 250.03,58.46 248.99,58.46 248.31,59.13 248.31,67.02 245.04,70.3 243.8,70.3 242.84,71.25 242.84,73.58
FBB_CMD2: length 29.1
  TOP w0.102: RG56.1 250.69,59.4 v2(250.79,59.31)
  BOTTOM w0.102: 243.12,73.41 243.12,82.5 UG9.D35 ; v2(250.79,59.31) 251.02,59.07 UG3.J2
  BOTTOM w0.142: 250.76,59.34 v2(250.79,59.31)
  BOTTOM w0.185: 243.12,73.41 244.55,71.98 244.55,71.55 248.86,67.24 248.93,67.17 248.93,59.66 249.18,59.41 249.75,59.41 249.82,59.34 250.76,59.34
FBB_CMD3: length 25.5
  BOTTOM w0.102: UG9.A36 243.47,73.56
  BOTTOM w0.185: 243.47,73.56 244.93,72.1 244.93,71.94 249.4,67.47 249.51,67.36 249.51,60.6 249.83,60.28 250.01,60.28 250.19,60.11 251.59,60.11 UG3.L3
FBB_CMD4: length 27.3
  BOTTOM w0.102: UG9.B36 243.47,81.25 243.82,80.9 243.82,73.81
  BOTTOM w0.185: 243.82,73.81 250.85,66.78 252.67,66.78 254.01,65.44 254.01,60.13 253.59,59.71 UG3.K5
FBB_CMD5: length 29.5
  BOTTOM w0.102: UG9.C36 243.47,81.91 243.82,81.56 243.82,81.25 244.07,81 244.07,78.41 244.21,78.27 244.21,74.19
  BOTTOM w0.185: 244.21,74.19 251.33,67.07 252.79,67.07 254.3,65.56 254.3,65.32 254.3,59.87 253.74,59.31 253.19,59.31 UG3.K4
FBB_CMD6: length 29
  BOTTOM w0.102: UG9.C38 244.52,81.8 244.52,81.3 244.3,81.08 244.3,78.6 244.63,78.27 244.63,74.53
  BOTTOM w0.185: 244.63,74.53 251.81,67.35 252.91,67.35 254.58,65.68 254.58,65.2 254.58,65.2 254.58,59.56 253.94,58.91 UG3.J5
FBB_CMD7: length 29.6
  BOTTOM w0.102: 244.98,75.12 244.98,78.33 244.52,78.79 244.52,80.95 244.87,81.3 UG9.B38
  BOTTOM w0.185: UG3.J4 253.19,58.51 254.24,58.51 254.87,59.14 254.87,65.08 254.87,65.79 253.02,67.64 252.46,67.64 244.98,75.12
FBB_CMD8: length 28.1
  BOTTOM w0.102: UG9.A38 244.87,78.92 245.35,78.44 245.35,75.52
  BOTTOM w0.185: UG3.H5 254.29,58.11 255.16,58.98 255.16,64.96 255.16,65.91 253.14,67.93 252.94,67.93 245.35,75.52
FBB_CMD9: length 31.8
  BOTTOM w0.102: 245.69,75.97 245.69,78.68 245.22,79.15 245.22,82.5 UG9.D38
  BOTTOM w0.185: UG3.H4 253.19,57.71 254.39,57.71 255.44,58.77 255.44,64.84 255.44,66.39 253.37,68.47 253.19,68.47 245.69,75.97
FBB_CMD10: length 30.6
  BOTTOM w0.102: 246.08,76.11 246.08,78.74 245.57,79.25 UG9.A39
  BOTTOM w0.185: UG3.G12 258.79,57.71 256.64,57.71 255.73,58.62 255.73,64.72 255.73,66.87 253.59,69.01 253.42,69.01 250.76,71.66 250.28,72.14 250.05,72.14 246.08,76.11
FBB_CMD11: length 29.1
  BOTTOM w0.102: UG9.B39 245.57,81.25 245.92,80.9 245.92,79.54 246.38,79.07 246.38,77.2 246.51,77.07 246.51,76.38
  BOTTOM w0.185: UG3.H10 256.74,58.11 256.02,58.83 256.02,64.6 256.02,67.35 253.82,69.55 253.64,69.55 251.04,72.15 250.74,72.15 246.51,76.38
FBB_CMD12: length 30.3
  BOTTOM w0.102: UG9.C39 245.57,82 245.92,81.65 245.92,81.25 246.17,81 246.17,80.06 246.75,79.47 246.75,77.26 246.86,77.15 246.86,76.75
  BOTTOM w0.185: UG3.H11 257.99,58.51 256.84,58.51 256.31,59.04 256.31,64.48 256.31,67.83 254.04,70.09 253.86,70.09 251.53,72.42 251.19,72.42 246.86,76.75
FBB_CMD13: length 30.6
  BOTTOM w0.102: 253.86,72.76 251.56,72.76 247.27,77.05 247.27,77.25 247.02,77.5 247.02,79.69 246.39,80.32 246.39,81.07 246.62,81.3 246.62,81.8 UG9.C41
  BOTTOM w0.185: 253.86,72.76 256.8,69.82 256.8,66.2 256.59,65.99 256.59,64.37 256.59,64.36 256.59,59.7 256.89,59.41 257.24,59.41 257.34,59.31 257.99,59.31 UG3.K11
FBB_CMD14: length 28.6
  BOTTOM w0.102: UG9.B41 246.97,81.3 246.62,80.95 246.62,80.55 247.33,79.84 247.33,77.69 251.9,73.12 254.52,73.12
  BOTTOM w0.185: 254.52,73.12 257.37,70.26 257.37,66.26 256.89,65.77 256.89,60.01 257.19,59.71 UG3.K10
FBB_CMD15: length 29.2
  BOTTOM w0.102: 254.84,73.57 252.15,73.57 251.47,74.24 251.24,74.24 247.57,77.91 247.57,80.15 UG9.A41
  BOTTOM w0.185: UG3.L12 258.79,60.11 257.44,60.11 257.19,60.36 257.19,65.57 257.95,66.33 257.95,70.46 254.84,73.57
FBB_CMD16: length 31.9
  BOTTOM w0.102: 256.74,81.77 254.72,79.75 253.18,79.75 252.77,80.16 252.77,80.4 252.92,80.55 252.92,81.1 UG9.B49
  BOTTOM w0.185: UG4.L3 277.75,80.36 277.75,81.76 277.85,81.86 277.85,82.74 276.68,83.92 268.23,83.92 267.47,83.15 262.26,83.15 260.88,81.77 256.74,81.77
FBB_CMD17: length 33.2
  TOP w0.102: v2(276.95,80.36) 276.55,79.96 276.55,78.53 RG50.2
  BOTTOM w0.102: UG4.J3 v2(276.95,80.36) ; 256.73,81.1 255.1,79.47 252.91,79.47 252.32,80.06 252.32,80.5 UG9.A49
  BOTTOM w0.185: 256.73,81.1 261.04,81.1 262.33,82.39 267.79,82.39 268.83,83.43 276.4,83.43 276.95,82.88 v2(276.95,80.36)
FBB_CMD18: length 32.5
  TOP w0.102: RG55.1 275.73,78.51 275.73,80.74 v2(276.15,81.16)
  BOTTOM w0.102: v2(276.15,81.16) 276.37,80.94 UG4.J2 ; 256.92,80.6 255.46,79.14 252.8,79.14 252.02,79.92 252.02,80.6 UG9.A48
  BOTTOM w0.185: 256.92,80.6 261.23,80.6 262.25,81.61 267.62,81.61 267.97,81.96 268.18,81.96 269.16,82.93 275.63,82.93 276.05,82.51 276.05,82.06 276.15,81.96 v2(276.15,81.16)
FBB_CMD19: length 31.1
  BOTTOM w0.102: 257,80.1 255.77,78.87 252.59,78.87 251.52,79.94 251.52,82.5 UG9.D47
  BOTTOM w0.185: UG4.G3 275.35,80.36 275.35,81.76 274.67,82.44 269.43,82.44 268.23,81.25 267.79,81.25 267.38,80.84 262.36,80.84 261.62,80.1 257,80.1
FBB_CMD20: length 28.1
  BOTTOM w0.102: UG9.A47 251.17,79.77 252.36,78.58 256.07,78.58 256.96,79.47
  BOTTOM w0.185: 256.96,79.47 261.57,79.47 262.16,80.07 268.39,80.07 269.44,79.02 269.44,78.45 269.95,77.95 275.33,77.95 UG4.H5
FBB_CMD21: length 30.4
  BOTTOM w0.102: UG9.B47 251.17,81.3 250.82,80.95 250.82,79.69 252.25,78.26 253.73,78.26 253.86,78.14 256.3,78.14 257.1,78.94
  BOTTOM w0.185: UG4.H4 276.15,78.76 276.15,78.21 275.6,77.66 269.63,77.66 267.99,79.3 262.28,79.3 261.92,78.94 257.1,78.94
FBB_CMD22: length 31.1
  BOTTOM w0.102: 261.87,77.78 253.72,77.78 253.55,77.95 252.18,77.95 250.56,79.56 250.56,81.05 250.82,81.3 250.82,81.8 UG9.C47
  BOTTOM w0.185: 261.87,77.78 262.62,78.53 267.29,78.53 267.47,78.71 268.11,78.71 269.44,77.37 275.96,77.37 276.55,77.96 UG4.J5
FBB_CMD23: length 33.3
  BOTTOM w0.102: 262.2,77.29 253.74,77.29 253.4,77.63 252.08,77.63 250.32,79.39 250.32,80.32 250.32,80.32 250.32,80.98 250.32,81.05 250.12,81.25 250.12,81.65 249.77,82 UG9.C45
  BOTTOM w0.185: UG4.J4 276.95,78.76 276.95,77.51 276.52,77.09 269.28,77.09 268.23,78.14 267.6,78.14 267.22,77.76 262.67,77.76 262.2,77.29
FBB_CMD24: length 32.5
  BOTTOM w0.102: UG9.B45 249.77,81.25 250.12,80.9 250.12,80.4 250.03,80.31 250.03,79.18 251.89,77.31 253.28,77.31 253.69,76.9 262.5,76.9 262.59,76.99 262.82,76.99
  BOTTOM w0.185: 262.82,76.99 267.27,76.99 267.66,77.38 268.42,77.38 269,76.8 277.04,76.8 277.35,77.11 UG4.K5
FBB_CMD25: length 33.5
  BOTTOM w0.102: UG9.A45 249.77,78.99 251.77,76.99 253.07,76.99 253.59,76.48 262.18,76.48
  BOTTOM w0.185: 262.18,76.48 262.44,76.22 267.33,76.22 267.57,76.46 277.1,76.46 277.64,76.99 277.64,77 277.75,77.11 277.75,78.76 UG4.K4
FBB_CMD26: length 37.2
  BOTTOM w0.102: UG9.D44 249.42,82.5 249.42,78.87 251.61,76.68 252.81,76.68 253.49,76 261.82,76
  BOTTOM w0.185: 261.82,76 262.37,75.44 267.51,75.44 268.23,76.17 276.84,76.17 277.75,75.26 277.75,73.16 UG4.L12
FBB_CMD27: length 33.8
  BOTTOM w0.102: UG9.A44 249.07,78.68 251.45,76.3 252.72,76.3 253.47,75.55 260.91,75.55
  BOTTOM w0.185: 260.91,75.55 261.99,74.47 267.17,74.47 268.58,75.88 276.63,75.88 277.35,75.16 UG4.K10
FBB_CMD28: length 36
  BOTTOM w0.102: 259.86,75.22 253.36,75.22 252.57,76.01 251.26,76.01 248.77,78.5 248.77,80.09 248.72,80.14 248.72,80.95 249.07,81.3 UG9.B44
  BOTTOM w0.185: 259.86,75.22 261.45,73.63 267.03,73.63 268.99,75.59 276.47,75.59 276.95,75.11 276.95,73.96 UG4.K11
FBB_CMD29: length 36.6
  BOTTOM w0.102: UG9.C44 248.72,81.8 248.72,81.3 248.52,81.1 248.52,78.35 251.41,75.46 252.44,75.46 253.13,74.77 257.12,74.77
  BOTTOM w0.185: 257.12,74.77 259.03,72.87 266.96,72.87 269.4,75.31 275.8,75.31 276.05,75.06 276.05,74.66 276.15,74.56 276.15,73.96 UG4.H11
FBB_CMD30: length 36.1
  BOTTOM w0.102: 256.42,74.33 252.87,74.33 252.07,75.13 251.29,75.13 248.22,78.21 248.22,80.2 248.27,80.25 248.27,81 248.02,81.25 248.02,81.65 247.67,82 UG9.C42
  BOTTOM w0.185: 256.42,74.33 258.77,71.98 266.71,71.98 269.75,75.02 275.43,75.02 275.75,74.7 UG4.H10
FBB_CMD31: length 38.4
  BOTTOM w0.102: 256,74.01 252.48,74.01 251.74,74.75 251.25,74.75 247.89,78.11 247.89,80.42 248.02,80.55 248.02,80.9 247.67,81.25 UG9.B42
  BOTTOM w0.185: 256,74.01 259.11,70.9 267.41,70.9 268.87,72.36 268.87,73.69 269.91,74.73 275.13,74.73 275.35,74.51 275.35,73.16 UG4.G12
FBB_D0: length 25.8
  IN6 w0.102: v2(240.37,85.35) 241.29,84.43 241.29,82.72 241.28,82.71 241.28,82.39 241.29,82.38 241.29,82.05 242.39,80.96 242.39,80.55 243.98,78.96
  IN6 w0.13: 243.98,78.96 243.98,76.55 253.07,67.46 253.07,66.09 v2(252.83,65.86)
  BOTTOM w0.102: UG3.U4 252.79,65.31 252.79,65.81 v2(252.83,65.86) ; UG9.H32 v2(240.37,85.35)
FBB_D1: length 22.3
  IN6 w0.102: v2(240.62,79.2) 240.78,79.04 240.79,79.04 241.01,78.82 241.01,78.81 241.02,78.8 241.02,75.29 242.49,73.82
  IN6 w0.13: v2(250.79,65.71) 250.67,65.71 249.98,66.4 249.91,66.4 242.49,73.82
  BOTTOM w0.102: UG3.U2 251,65.49 v2(250.79,65.71) ; v2(240.62,79.2) 241.02,79.6 241.02,82.5 UG9.D32
FBB_D2: length 21.3
  IN6 w0.102: 242.71,78.93 241.42,80.21 v2(241.42,80.3)
  IN6 w0.13: v2(252.39,64.91) 252.04,65.26 252.04,66.41 251.98,66.47 251.98,66.47 251.75,66.7 251.26,66.7 242.71,75.26 242.71,78.93
  BOTTOM w0.102: UG9.A33 241.37,80.35 v2(241.42,80.3) ; UG3.T4 252.62,64.68 v2(252.39,64.91)
FBB_D3: length 22.3
  IN6 w0.102: 242.07,78.76 241.55,79.28 241.09,79.28 241.01,79.36 241.01,79.37 240.79,79.59 240.78,79.59 v2(240.62,79.75)
  IN6 w0.13: 242.07,78.76 242.07,75.1 251.19,65.98 251.19,65.31 v2(250.79,64.91)
  BOTTOM w0.102: v2(250.79,64.91) 250.99,64.71 UG3.T2 ; v2(240.62,79.75) 240.24,80.13 240.24,80.45 240.34,80.55 240.34,80.97 240.67,81.3 UG9.B32
FBB_D4: length 30.3
  IN6 w0.102: 240.74,73.82 240.74,73.88 239.65,74.96 239.65,81.02 240.27,81.63 240.27,82.36 v2(240.23,82.4)
  IN6 w0.13: 240.74,73.82 240.74,73.66 246.52,67.87 246.52,64.48 249.69,61.31 251.99,61.31 v2(252.39,61.71)
  BOTTOM w0.102: v2(240.23,82.4) 240.31,82.48 240.31,82.99 240.67,83.35 UG9.E32 ; v2(252.39,61.71) 252.61,61.94 252.61,61.94 UG3.N4
FBB_D5: length 30.1
  IN6 w0.102: 243.28,79.03 241.94,80.36 241.94,80.54 240.93,81.55 240.93,84 v2(240.29,84.64)
  IN6 w0.13: 243.28,79.03 243.28,75.98 252.36,66.9 252.36,65.64 252.79,65.21 252.79,63.04 252.66,62.9 251.18,62.9 v2(250.79,62.51)
  BOTTOM w0.102: v2(240.29,84.64) 240.6,84.95 UG9.G32 ; v2(250.79,62.51) UG3.N2
FBB_D6: length 34.9
  IN6 w0.102: v2(239.57,86.65) 239.03,86.11 239.03,81.73 239.19,81.57 239.19,74.9 240.17,73.92
  IN6 w0.13: 240.17,73.92 240.17,73.44 245.96,67.64 245.96,63.86 249.41,60.41 251.89,60.41 v2(252.39,60.91)
  BOTTOM w0.102: UG3.M4 252.61,61.14 v2(252.39,60.91) ; UG9.J30 v2(239.57,86.65)
FBB_D7: length 28.4
  IN6 w0.102: v2(240.37,83.95) 240.62,83.7 240.62,81.28 240.12,80.78 240.12,74.98 240.61,74.48 240.71,74.48 241.37,73.82
  IN6 w0.13: 241.37,73.82 247.09,68.1 247.09,64.73 249.71,62.11 250.39,62.11 v2(250.79,61.71)
  BOTTOM w0.102: UG9.F32 v2(240.37,83.95) ; v2(250.79,61.71) 251.04,61.46 251.04,61.46 UG3.M2
FBB_D8: length 28.7
  IN1 w0.13: v2(258.79,65.71) 258.69,65.71 257.81,66.59 256.66,66.59 250.79,72.46 250.79,72.91 244.77,78.93 244.77,79.94 242.87,81.84 242.87,85.65 v2(243.17,85.95)
  BOTTOM w0.102: v2(258.79,65.71) 258.58,65.5 258.58,65.5 UG3.U11 ; v2(243.17,85.95) UG9.H36
FBB_D9: length 29.2
  IN1 w0.102: v2(243.77,85.25) 244.06,84.96 245.02,84.96
  IN1 w0.13: 245.02,84.96 245.48,84.5 245.48,82.04 246.33,81.19 246.33,79.78 252.48,73.63 252.48,73.15 256.99,68.64 258.6,68.64 260.7,66.54 260.7,66.02 v2(260.39,65.71)
  BOTTOM w0.102: UG3.U13 260.17,65.49 260.17,65.49 v2(260.39,65.71) ; UG9.G36 v2(243.77,85.25)
FBB_D10: length 30.3
  IN1 w0.13: v2(258.79,64.91) 259.18,65.3 259.18,65.87 259.18,65.88 259.18,65.92 257.63,67.47 256.58,67.47 256,68.05 251.35,72.7 251.35,73.14 245.33,79.16 245.33,79.99 243.26,82.06 243.26,85.39 243.61,85.75 243.61,86.49 v2(243.77,86.65)
  BOTTOM w0.102: UG3.T11 258.57,64.7 v2(258.79,64.91) ; UG9.J36 v2(243.77,86.65)
FBB_D11: length 28.9
  IN1 w0.13: v2(260.39,64.91) 259.98,65.31 259.98,66.51 259.17,67.32 258.92,67.32 258.26,67.98 256.87,67.98 251.91,72.93 251.91,73.37 245.78,79.51 245.78,81.15 245.07,81.86 245.07,83.94 244.82,84.2 244.14,84.2 243.79,84.55 v2(243.77,84.55)
  BOTTOM w0.102: UG3.T13 260.19,64.71 v2(260.39,64.91) ; UG9.F36 v2(243.77,84.55)
FBB_D12: length 31.1
  IN1 w0.102: 241.28,82.05 241.28,83.32 241.53,83.57 241.53,84.41 v2(241.77,84.65)
  IN1 w0.13: v2(258.79,62.51) 258.59,62.51 258.19,62.91 257.74,62.91 256.42,64.23 256.42,65.25 249.67,72 249.67,72.44 243.61,78.5 243.61,79.72 241.28,82.05
  BOTTOM w0.102: UG9.F33 v2(241.77,84.65) ; v2(258.79,62.51) UG3.N11
FBB_D13: length 30.1
  IN1 w0.13: v2(260.39,62.51) 259.99,62.91 258.61,62.91 258.39,63.13 258.39,63.53 258.21,63.71 257.77,63.71 257.04,64.44 257.04,65.42 250.23,72.23 250.23,72.68 244.19,78.72 244.19,79.82 242.48,81.53 242.48,82.25 242.18,82.55 v2(241.67,82.55)
  BOTTOM w0.102: UG9.D33 v2(241.67,82.55) ; v2(260.39,62.51) UG3.N13
FBB_D14: length 34.9
  IN1 w0.102: v2(240.37,86.65) 241.1,85.92 241.1,83.78 240.85,83.53 240.85,81.56
  IN1 w0.13: 240.85,81.56 242.29,80.12 242.29,78.23 248.55,71.98 248.55,71.22 254.91,64.86 254.91,64.16 257.75,61.31 UG3.M11 v2(258.79,61.71)
  BOTTOM w0.102: UG9.J32 v2(240.37,86.65) ; v2(258.79,61.71) UG3.M11
FBB_D15: length 34.1
  IN1 w0.102: v2(241.67,85.25) 241.31,84.89 241.31,83.67 241.07,83.43 241.07,81.84
  IN1 w0.13: v2(260.39,61.71) 259.99,62.11 257.78,62.11 255.56,64.33 255.56,65.31 249.11,71.77 249.11,72.21 242.98,78.34 242.98,79.93 241.07,81.84
  BOTTOM w0.102: v2(260.39,61.71) UG3.M13 ; UG9.G33 v2(241.67,85.25)
FBB_D16: length 49.2
  IN1 w0.13: v2(250.07,83.25) 250.56,82.75 250.56,82.35 250.77,82.15 250.77,80.97 252.71,79.03 253.6,79.03 259.13,73.49 259.15,73.49 259.27,73.37 260.22,73.37 266.62,66.97 266.62,53.82 263.6,50.8 258.65,50.8 257.99,51.46 v2(257.99,52.11)
  BOTTOM w0.102: v2(250.07,83.25) UG9.E45 ; UG3.A11 258.15,52.28 v2(257.99,52.11)
FBB_D17: length 45
  IN1 w0.13: v2(250.07,82.55) 249.92,82.4 249.92,81.15 252.71,78.36 253.37,78.36 258.92,72.81 259.99,72.81 266.06,66.74 266.06,54.26 263.25,51.45 260.25,51.45 v2(259.59,52.11)
  BOTTOM w0.102: UG3.A13 259.81,52.33 259.81,52.33 v2(259.59,52.11) ; UG9.D45 v2(250.07,82.55)
FBB_D18: length 47.5
  IN1 w0.13: v2(257.99,52.91) 258.39,52.51 260.11,52.51 260.55,52.07 262.9,52.07 265.5,54.67 265.5,66.51 259.78,72.23 258.71,72.23 253.34,77.6 252.77,77.6 249.6,80.77 249.6,84.08 v2(250.07,84.55)
  BOTTOM w0.102: v2(257.99,52.91) 258.23,53.15 UG3.B11 ; v2(250.07,84.55) UG9.F45
FBB_D19: length 44.7
  IN1 w0.13: v2(249.69,85.42) 249.71,85.4 249.71,85 249.19,84.48 249.19,80.55 252.59,77.15 253,77.15 258.55,71.6 259.62,71.6 264.84,66.37 264.84,55.92 262.82,53.9 262.82,53.07 262.21,52.46 260.84,52.46 v2(260.39,52.91)
  BOTTOM w0.102: UG9.G45 249.77,85.34 v2(249.69,85.42) ; v2(260.39,52.91) 260.17,53.12 UG3.B13
FBB_D20: length 39.4
  IN1 w0.13: v2(247.97,82.55) 247.78,82.36 247.78,81.82 248.13,81.46 248.13,80.42 258.23,70.33 259.3,70.33 263.72,65.91 263.72,57.17 262.26,55.71 259.19,55.71 v2(258.79,55.31)
  BOTTOM w0.102: UG3.E11 v2(258.79,55.31) ; UG9.D42 v2(247.97,82.55)
FBB_D21: length 39.7
  IN1 w0.13: v2(247.97,83.25) 248.69,82.53 248.69,80.66 258.39,70.96 259.46,70.96 264.28,66.14 264.28,56.69 262.5,54.91 260.79,54.91 v2(260.39,55.31)
  BOTTOM w0.102: UG9.E42 v2(247.97,83.25) ; v2(260.39,55.31) UG3.E13
FBB_D22: length 40.3
  IN1 w0.13: v2(247.97,84.55) 247.39,83.97 247.39,80.25 255.79,71.85 255.79,71.85 257.87,69.77 259.07,69.77 263.16,65.67 263.16,57.82 262.17,56.83 261.84,56.83 261.51,56.51 259.19,56.51 v2(258.79,56.11)
  BOTTOM w0.102: UG9.F42 v2(247.97,84.55) ; UG3.F11 258.56,56.33 v2(258.79,56.11)
FBB_D23: length 41.3
  IN1 w0.13: v2(260.39,56.91) 260.89,57.41 261.8,57.41 262.08,57.69 262.08,59.34 261.95,59.47 260.83,59.47 260.7,59.59 260.7,59.77 260.83,59.9 261.95,59.9 262.08,60.02 262.08,65.96 258.83,69.2 257.23,69.2 253.09,73.34 253.09,73.82 246.8,80.11 246.8,82.51 247.09,82.8 247.09,85.53 v2(246.67,85.95)
  BOTTOM w0.102: v2(260.39,56.91) 260.16,56.68 UG3.F13 ; UG9.H41 v2(246.67,85.95)
FBB_D24: length 44.3
  IN6 w0.102: v2(246.67,83.25) 246.71,83.21 246.71,81.31 248.36,79.66
  IN6 w0.13: v2(252.39,52.91) 253.51,51.79 254.23,51.79 254.36,51.66 254.36,51.59 254.48,51.46 254.66,51.46 254.79,51.59 254.79,51.66 254.91,51.79 255.09,51.79 255.21,51.66 255.21,51.59 255.34,51.46 255.52,51.46 255.64,51.59 255.64,51.66 255.77,51.79 255.91,51.79 256.22,52.1 256.22,56.96 256.92,57.67 257.1,57.67 257.29,57.48 257.47,57.48 257.59,57.61 257.59,57.78 257.41,57.97 257.41,58.15 257.7,58.44 257.89,58.44 258.02,58.57 258.02,58.75 257.89,58.87 257.7,58.87 257.58,59 257.58,59.18 257.7,59.3 257.89,59.3 258.02,59.43 258.02,59.61 257.89,59.73 257.7,59.73 257.58,59.86 257.58,67.89 257.52,67.94 257.52,69.03 248.36,78.2 248.36,79.66
  BOTTOM w0.102: UG9.E41 v2(246.67,83.25) ; UG3.A4 252.63,52.67 252.63,52.67 v2(252.39,52.91)
FBB_D25: length 47.2
  IN6 w0.102: 248.99,79.66 247.09,81.57 247.09,84.01 246.88,84.22 246.41,84.22 246.08,84.55 v2(245.87,84.55)
  IN6 w0.13: 248.99,79.66 248.99,78.36 258.38,68.97 258.38,57.95 257.54,57.11 257.54,54.71 256.67,53.84 256.67,51.12 256.42,50.86 255.89,50.86 255.77,50.74 255.77,50.66 255.64,50.53 255.46,50.53 255.34,50.66 255.34,50.74 255.21,50.86 255.03,50.86 254.91,50.74 254.91,50.66 254.78,50.53 254.6,50.53 254.47,50.66 254.47,50.74 254.35,50.86 252.77,50.86 251.59,52.05 v2(251.59,52.11)
  BOTTOM w0.102: UG9.F39 v2(245.87,84.55) ; v2(251.59,52.11) 251.34,52.36 251.34,52.36 UG3.A2
FBB_D26: length 42.8
  IN6 w0.102: 247.6,79.57 246.5,80.66 246.5,82.62 v2(245.87,83.25)
  IN6 w0.13: v2(253.19,52.91) 253.64,52.46 254.46,52.46 254.58,52.59 254.58,53.2 254.71,53.33 254.89,53.33 255.01,53.2 255.01,52.59 255.14,52.46 255.43,52.46 255.61,52.64 255.61,53.22 255.82,53.43 255.82,53.65 255.61,53.86 255.61,54.07 255.82,54.28 255.82,54.5 255.61,54.71 255.61,54.93 255.82,55.14 255.82,55.36 255.61,55.57 255.61,55.79 255.82,56 255.82,56.22 255.61,56.43 255.61,57.37 255.79,57.54 255.79,57.72 255.43,58.08 255.43,58.26 255.55,58.38 255.73,58.38 256.09,58.03 256.27,58.03 256.41,58.17 256.41,59.14 256.96,59.69 256.96,68.64 247.6,78.01 247.6,79.57
  BOTTOM w0.102: v2(245.87,83.25) UG9.E39 ; UG3.B4 252.95,53.14 v2(253.19,52.91)
FBB_D27: length 43.3
  IN6 w0.102: v2(245.87,82.55) 245.72,82.4 245.72,80.71 246.96,79.47
  IN6 w0.13: v2(251.59,52.91) 251.99,53.31 254.18,53.31 255.06,54.19 254.93,54.31 253.07,54.31 252.94,54.44 252.94,54.62 253.07,54.74 254.93,54.74 255.06,54.87 255.06,55.28 254.93,55.41 254.87,55.41 254.74,55.53 254.74,55.71 254.87,55.84 254.93,55.84 255.06,55.96 255.06,56.14 254.93,56.27 254.87,56.27 254.74,56.39 254.74,56.57 254.87,56.7 254.93,56.7 255.06,56.82 255.06,57 254.93,57.12 254.87,57.12 254.74,57.25 254.74,57.43 254.87,57.55 254.93,57.55 255.06,57.68 255.06,58.29 256.36,59.59 256.36,68.42 246.96,77.82 246.96,79.47
  BOTTOM w0.102: UG9.D39 v2(245.87,82.55) ; UG3.B2 251.36,53.14 v2(251.59,52.91)
FBB_D28: length 37.1
  IN6 w0.102: 246.39,79.34 245.07,80.66 245.07,81.75 245.28,81.96 245.28,83.43 244.89,83.82 244.44,83.82 v2(244.41,83.79)
  IN6 w0.13: v2(252.39,56.11) 252.79,55.71 254.29,55.71 254.45,55.88 254.45,58.57 255.71,59.83 255.71,68.28 246.39,77.6 246.39,79.34
  BOTTOM w0.102: v2(244.41,83.79) UG9.F38 ; UG3.E4 v2(252.39,56.11)
FBB_D29: length 35.1
  IN6 w0.102: v2(244.51,83.23) 244.93,82.81 244.93,82.26 244.46,81.79 244.46,80.57 245.86,79.17
  IN6 w0.13: 245.86,79.17 245.86,77.33 254.98,68.21 254.98,59.77 253.98,58.77 253.98,57.63 253.61,57.26 253.61,56.71 253.41,56.51 251.99,56.51 v2(251.59,56.11)
  BOTTOM w0.102: UG3.E2 251.37,55.89 v2(251.59,56.11) ; UG9.E38 244.83,83.55 v2(244.51,83.23)
FBB_D30: length 31.6
  IN6 w0.102: v2(243.77,82.55) 243.67,82.45 243.67,82.15 243.62,82.1 243.62,81.78 243.67,81.73 243.67,80.6 245.32,78.95
  IN6 w0.13: 245.32,78.95 245.32,76.89 254.32,67.89 254.32,59.94 253.58,59.2 253.58,57.83 253.19,57.44 v2(253.19,56.91)
  BOTTOM w0.102: UG9.D36 v2(243.77,82.55) ; v2(253.19,56.91) UG3.F4
FBB_D31: length 33.3
  IN6 w0.102: v2(243.77,83.25) 243.02,82.5 243.02,80.55 244.77,78.8
  IN6 w0.13: 244.77,78.8 244.77,76.58 253.68,67.67 253.68,60.28 253.04,59.64 253.04,57.74 252.61,57.31 251.99,57.31 v2(251.59,56.91)
  BOTTOM w0.102: UG3.F2 251.38,56.7 v2(251.59,56.91) ; v2(243.77,83.25) UG9.E36
FBB_D32: length 21.2
  IN1 w0.13: v2(256.88,88.46) 257.37,87.97 258.85,87.97 259.31,87.52 261.2,87.52 269.01,79.71 269.6,79.71 v2(269.75,79.56)
  BOTTOM w0.102: UG4.A4 269.99,79.32 v2(269.75,79.56) ; v2(256.88,88.46) 256.27,89.07 254.44,89.07 254.17,88.8 253.77,88.8 253.42,88.45 UG9.M50
FBB_D33: length 22.3
  IN1 w0.13: v2(269.75,81.16) 269.5,81.41 268.89,81.41 261.82,88.49 259.6,88.49 258.66,89.42 253.86,89.42 253.76,89.52 253.21,89.52 253.04,89.35 252.22,89.35 v2(252.12,89.45)
  BOTTOM w0.102: v2(252.12,89.45) 252.12,89.6 UG9.P48 ; UG4.A2 v2(269.75,81.16)
FBB_D34: length 21.6
  IN1 w0.13: v2(270.55,79.56) 270,79.01 268.75,79.01 260.8,86.96 258.52,86.96 258.08,87.4 256.78,87.4 v2(255.74,88.44)
  BOTTOM w0.102: UG9.M51 254.17,88.45 254.56,88.84 255.28,88.84 255.68,88.44 v2(255.74,88.44) ; UG4.B4 v2(270.55,79.56)
FBB_D35: length 22.5
  IN1 w0.13: v2(252.97,88.86) 253.21,88.62 254.24,88.62 254.52,88.9 257.67,88.9 258.07,88.5 258.95,88.5 259.41,88.04 261.47,88.04 268.75,80.76 270.15,80.76 v2(270.55,80.36)
  BOTTOM w0.102: UG4.B2 v2(270.55,80.36) ; UG9.M49 v2(252.97,88.86)
FBB_D36: length 29.9
  IN1 w0.13: v2(251.47,89.55) 251.75,89.83 253.75,89.83 254.86,90.94 259.88,90.94 260.81,90.01 260.81,90 261.24,89.57 262.33,89.57 268.81,83.08 272.52,83.08 273.35,82.25 273.35,79.96 v2(273.75,79.56)
  BOTTOM w0.102: v2(273.75,79.56) 273.75,79.56 UG4.E4 ; UG9.P47 v2(251.47,89.55)
FBB_D37: length 23.4
  IN1 w0.13: v2(256.27,90.55) 256.97,89.85 259.31,89.85 260.23,88.93 262.17,88.93 268.58,82.52 272.22,82.52 272.55,82.19 272.55,81.63 272.95,81.23 v2(272.95,81.16)
  BOTTOM w0.102: UG9.P52 255.57,89.85 v2(256.27,90.55) ; UG4.E2 v2(272.95,81.16)
FBB_D38: length 33.5
  IN1 w0.13: v2(274.55,79.56) 275.05,80.06 275.05,82.11 274.7,82.46 274.7,82.87 272.61,84.96 268.52,84.96 262.72,90.76 261.31,90.76 260.59,91.48 258.7,91.48 258.53,91.65 254.54,91.65 253.35,90.46 250.56,90.46 v2(250.17,90.85)
  BOTTOM w0.102: UG4.F4 274.55,79.56 v2(274.55,79.56) ; UG9.R46 v2(250.17,90.85)
FBB_D39: length 30.4
  IN1 w0.13: v2(250.62,89.45) 251.32,90.15 253.53,90.15 254.71,91.33 258.16,91.33 258.28,91.21 260.21,91.21 261.22,90.2 262.49,90.2 269.02,83.67 272.79,83.67 274.15,82.31 274.15,81.56 v2(273.75,81.16)
  BOTTOM w0.102: v2(250.62,89.45) 250.62,89.7 UG9.P46 ; v2(273.75,81.16) UG4.F2
FBB_D40: length 25.5
  IN6 w0.102: 260.23,83.79 260.23,84.49 259.18,85.53 259.18,86.86 258.49,87.56 256.03,87.56 v2(255.32,86.85)
  IN6 w0.13: 260.23,83.79 263.18,80.84 263.18,79.73 v2(269.75,73.16)
  BOTTOM w0.102: UG9.L50 253.5,87.75 253.85,87.4 254.12,87.4 254.34,87.18 254.99,87.18 v2(255.32,86.85) ; v2(269.75,73.16) 269.95,73.37 269.95,73.37 UG4.A11
FBB_D41: length 25.4
  IN6 w0.102: 258.71,82.84 258.71,84.05 257.64,85.12 256.71,85.12 255.77,86.06 255.77,86.65 v2(255.92,86.8)
  IN6 w0.13: v2(269.75,71.56) 268.65,71.56 261.88,78.33 261.88,79.66 258.71,82.84
  BOTTOM w0.102: UG4.A13 269.96,71.77 v2(269.75,71.56) ; v2(255.92,86.8) 255.92,87.15 255.66,87.41 254.47,87.41 254.13,87.75 UG9.L51
FBB_D42: length 25.4
  IN6 w0.102: 259.79,83.28 259.79,84.32 258.77,85.33 258.77,86.67 258.13,87.31 256.89,87.31 v2(256.48,86.9)
  IN6 w0.13: 259.79,83.28 262.75,80.32 262.75,79.17 269.16,72.76 270.15,72.76 v2(270.55,73.16)
  BOTTOM w0.102: UG4.B11 270.8,73.41 v2(270.55,73.16) ; UG9.L52 255.93,87.75 256.48,87.2 v2(256.48,86.9)
FBB_D43: length 28
  IN6 w0.102: v2(257.71,86.85) 257.62,86.85 257.37,86.6 257.37,85.95 258.52,84.8 258.69,84.8 259.3,84.19 259.3,82.94
  IN6 w0.13: v2(270.55,71.56) 270.15,71.96 269.14,71.96 262.32,78.78 262.32,79.93 259.3,82.94
  BOTTOM w0.102: v2(270.55,71.56) UG4.B13 ; v2(257.71,86.85) 257.71,86.9 256.61,88 254.92,88 254.82,88.1 252.92,88.1 UG9.L49
FBB_D44: length 34.7
  IN6 w0.102: v2(249.35,88.87) 250.13,88.09 254.85,88.09 254.94,88 255.59,88 255.61,88.02 259.05,88.02
  IN6 w0.13: 259.05,88.02 262.77,84.3 262.77,82.86 270.34,75.29 272.37,75.29 273.35,74.31 UG4.E11 v2(272.95,73.16)
  BOTTOM w0.102: v2(249.35,88.87) 249.42,88.8 249.42,88.18 249.52,88.08 250.1,88.08 UG9.M46 ; v2(272.95,73.16) UG4.E11
FBB_D45: length 32.6
  IN6 w0.102: v2(251.47,87.45) 251.76,87.74 253.83,87.74 254.2,87.38 255.29,87.38 255.7,87.79 258.71,87.79 259.79,86.71 259.79,85.53 260.66,84.66 260.66,84.18
  IN6 w0.13: v2(273.75,71.56) 273.35,71.96 272.74,71.96 272.55,72.15 272.55,74.16 272.13,74.58 270.25,74.58 260.66,84.18
  BOTTOM w0.102: UG9.L47 v2(251.47,87.45) ; v2(273.75,71.56) 273.51,71.8 273.51,71.8 UG4.E13
FBB_D46: length 32
  IN6 w0.102: v2(252.14,88.86) 252.55,88.45 253.52,88.45 254,88.93 ; 262.77,85.69 259.85,88.61
  IN6 w0.13: v2(273.75,73.16) UG4.F11 274.15,74.48 272.67,75.96 270.71,75.96 265.63,81.04 265.63,82.84 262.77,85.69 ; 254,88.93 257.27,88.93 257.59,88.61 259.85,88.61
  BOTTOM w0.102: v2(273.75,73.16) UG4.F11 ; v2(252.14,88.86) 252.14,88.72 UG9.M48
FBB_D47: length 36.9
  IN6 w0.102: 252.67,89.5 252.21,89.96 251.32,89.96 251.07,89.71 251.07,88.95 v2(250.87,88.75) ; 262.77,87.03 260.76,89.04
  IN6 w0.13: v2(274.55,71.56) 274.95,71.96 274.95,74.63 272.91,76.67 270.9,76.67 266.45,81.12 266.45,83.34 262.77,87.03 ; 260.76,89.04 257.91,89.04 257.44,89.5 252.67,89.5
  BOTTOM w0.102: UG9.M47 v2(250.87,88.75) ; v2(274.55,71.56) 274.55,71.56 UG4.F13
FBB_D48: length 50.4
  IN6 w0.102: v2(251.57,83.15) 251.17,82.75 251.17,80.91
  IN6 w0.13: v2(283.35,73.16) 283.99,73.16 284.92,72.23 284.92,69.46 282.21,66.75 279.72,66.75 277.81,64.84 268.14,64.84 260.1,72.87 259.22,72.87 251.17,80.91
  BOTTOM w0.102: UG9.D48 v2(251.57,83.15) ; UG4.U11 283.11,73.4 283.11,73.4 v2(283.35,73.16)
FBB_D49: length 40.3
  IN6 w0.102: v2(253.57,81.85) 253.95,81.47 253.95,80.23 255.31,78.87 256.66,78.87
  IN6 w0.13: 256.66,78.87 268.5,67.04 276.2,67.04 277.6,68.43 281.51,68.43 282.95,69.87 282.95,71.16 v2(283.35,71.56)
  BOTTOM w0.102: UG9.C50 v2(253.57,81.85) ; UG4.U13 v2(283.35,71.56)
FBB_D50: length 47.5
  IN6 w0.102: v2(252.17,81.85) 251.79,81.47 251.79,80.84 ; 258.81,73.82 259.06,73.82 259.38,73.5
  IN6 w0.13: v2(282.55,73.16) 282.95,72.76 283.59,72.76 284.36,71.99 284.36,69.7 281.98,67.31 279.49,67.31 277.58,65.4 268.55,65.4 260.44,73.5 259.38,73.5 ; 251.79,80.84 258.81,73.82
  BOTTOM w0.102: UG9.C48 v2(252.17,81.85) ; v2(282.55,73.16) UG4.T11
FBB_D51: length 44
  IN6 w0.102: 259.47,73.82 260.92,73.82 ; v2(252.87,81.85) 252.87,80.17 253.24,79.8 253.49,79.8
  IN6 w0.13: 253.49,79.8 259.47,73.82 ; 260.92,73.82 268.26,66.47 277.4,66.47 278.8,67.87 281.74,67.87 283.8,69.93 283.8,71.76 283.6,71.96 282.95,71.96 v2(282.55,71.56)
  BOTTOM w0.102: UG9.C49 v2(252.87,81.85) ; UG4.T13 v2(282.55,71.56)
FBB_D52: length 40.4
  IN6 w0.102: 266.75,70.41 266.8,70.36 ; v2(252.27,83.25) 252.73,83.71 253.3,83.71 253.57,83.98 254.78,83.98 258.9,79.86
  IN6 w0.13: 258.9,79.86 258.9,78.26 266.75,70.41 ; 266.8,70.36 269,68.16 275.74,68.16 277.13,69.56 279.4,69.56 279.75,69.91 279.75,72.76 v2(280.15,73.16)
  BOTTOM w0.102: UG4.N11 v2(280.15,73.16) ; UG9.E49 v2(252.27,83.25)
FBB_D53: length 41
  IN6 w0.102: v2(253.57,83.25) 254.05,83.73 254.4,83.73 254.68,83.45 254.68,82.03 258.4,78.31
  IN6 w0.13: v2(280.15,71.56) 280.55,71.96 281.15,71.96 281.35,71.76 281.35,69.91 280.43,68.99 277.36,68.99 275.97,67.6 268.73,67.6 258.4,77.93 258.4,78.31
  BOTTOM w0.102: UG4.N13 v2(280.15,71.56) ; UG9.E50 v2(253.57,83.25)
FBB_D54: length 38
  IN6 w0.102: 260.15,80.54 254.93,85.76 252.89,85.76 252.57,85.44 252.57,85.05 v2(252.17,84.65)
  IN6 w0.13: v2(279.35,73.16) 278.95,72.76 278.95,72.16 278.75,71.96 277.81,71.96 276.21,70.36 275.74,69.89 269.49,69.89 260.15,79.23 260.15,80.54
  BOTTOM w0.102: UG4.M11 279.15,73.37 v2(279.35,73.16) ; UG9.F49 v2(252.17,84.65)
FBB_D55: length 38.3
  IN6 w0.102: 267.89,70.36 266.75,71.51 ; 259.36,80.36 256.05,83.67 256.05,84.1 255.45,84.71 254.06,84.71 253.6,84.25 UG9.F48 v2(251.57,84.55)
  IN6 w0.13: 259.36,80.36 259.36,78.9 266.75,71.51 ; v2(278.55,71.56) 278.95,71.16 278.95,70.5 278.56,70.12 276.9,70.12 275.64,68.86 269.39,68.86 267.89,70.36
  BOTTOM w0.102: UG4.M13 v2(278.55,71.56) ; v2(251.57,84.55) UG9.F48
FBB_D56: length 38
  IN1 w0.13: v2(252.97,84.65) 253.81,83.81 254.37,83.81 255.18,83 255.81,83 258.07,80.74 261.47,80.74 267.44,74.77 274.73,74.77 275.05,74.45 277.32,74.45 278.26,75.39 280.9,75.39 282.96,77.45 282.96,78.35 v2(282.55,78.76)
  BOTTOM w0.102: UG9.F50 252.97,84.55 v2(252.97,84.65) ; UG4.U4 v2(282.55,78.76)
FBB_D57: length 38.8
  IN1 w0.13: v2(282.55,80.36) 282.55,80.17 283.71,79.01 283.71,77.33 281.35,74.97 281.35,74.61 281.34,74.61 281.34,74.6 281.11,74.37 278.1,74.37 277.3,73.57 269.43,73.57 269.05,73.95 267.47,73.95 261.12,80.3 257.86,80.3 v2(255.77,82.39)
  BOTTOM w0.102: UG9.D52 254.72,82.9 255.27,82.9 255.77,82.4 v2(255.77,82.39) ; UG4.U2 v2(282.55,80.36)
FBB_D58: length 35.1
  IN1 w0.13: v2(281.75,78.76) 281.35,78.36 281.35,77.76 280.3,76.71 277.36,76.71 276.69,76.04 267.75,76.04 262.77,81.02 262.77,81.06 261.88,81.95 258.2,81.95 253.57,86.58 v2(253.57,86.65)
  BOTTOM w0.102: UG4.T4 v2(281.75,78.76) ; UG9.J50 v2(253.57,86.65)
FBB_D59: length 40
  IN1 w0.13: v2(282.55,81.16) UG4.T2 282.15,77.66 280.65,76.16 277.76,76.16 277,75.41 267.6,75.41 261.69,81.31 258.01,81.31 255.58,83.74 255.3,83.74 255.17,83.87 255.16,83.87 254.94,84.09 254.94,84.1 253.34,85.69 252.51,85.69 v2(252.17,85.35)
  BOTTOM w0.102: UG4.T2 v2(282.55,81.16) ; UG9.H48 v2(252.17,85.35)
FBB_D60: length 33.1
  IN1 w0.13: v2(279.35,79.56) 279.79,79.12 279.79,77.74 279.32,77.27 276.88,77.27 276.22,76.61 267.98,76.61 262.01,82.58 258.07,82.58 256.74,83.92 v2(256.74,84.73)
  BOTTOM w0.102: UG4.N4 v2(279.35,79.56) ; v2(256.74,84.73) 256.57,84.9 255.73,84.9 255.62,85.01 254.76,85.01 254.12,85.65 UG9.H51
FBB_D61: length 32.4
  IN1 w0.13: v2(254.37,86.75) 254.37,86.55 255.73,85.19 257.82,85.19 259.72,83.28 262.1,83.28 268.14,77.25 275.87,77.25 276.56,77.94 277.94,77.94 278.36,78.36 278.72,78.36 278.9,78.54 278.9,78.55 278.94,78.6 278.94,80.23 279.08,80.36 v2(279.35,80.36)
  BOTTOM w0.102: UG4.N2 v2(279.35,80.36) ; UG9.J51 v2(254.37,86.75)
FBB_D62: length 31.2
  IN1 w0.13: v2(256.95,86.22) 257.48,85.69 258.71,85.69 260.49,83.92 262.26,83.92 268.36,77.82 275.27,77.82 276.26,78.81 277.65,78.81 278.4,79.56 v2(278.55,79.56)
  BOTTOM w0.102: UG9.H49 252.92,86 254.92,86 255.17,85.75 256.48,85.75 v2(256.95,86.22) ; UG4.M4 v2(278.55,79.56)
FBB_D63: length 30.9
  IN1 w0.13: v2(279.35,81.16) UG4.M2 275.9,80.76 275.75,80.61 275.75,79.31 274.77,78.33 268.65,78.33 260.75,86.22 257.83,86.22 v2(257.78,86.27)
  BOTTOM w0.102: UG4.M2 279.17,80.98 v2(279.35,81.16) ; v2(257.78,86.27) 257.78,86.25 256.94,85.41 254.91,85.41 UG9.H52
FBB_DBI0: length 24.7
  IN2 w0.117: v2(250.79,63.31) 250.39,63.71 249.51,63.71 248.55,64.68 248.55,70.26 240.76,78.05 v2(240.62,78.05)
  BOTTOM w0.102: v2(240.62,78.05) 240.23,78.43 240.23,79.67 240.04,79.87 240.04,80.56 240.14,80.66 240.14,81.12 240.34,81.32 240.34,81.82 UG9.C32 ; v2(250.79,63.31) UG3.P2
FBB_DBI1: length 30
  IN2 w0.117: v2(241.77,83.25) 242.32,82.7 242.32,81 244.68,78.64 244.68,78.64 256.03,67.29 256.03,65.45 257.77,63.71 259.99,63.71 v2(260.39,63.31)
  BOTTOM w0.102: v2(260.39,63.31) UG3.P13 ; UG9.E33 241.47,83.55 v2(241.77,83.25)
FBB_DBI2: length 40.6
  IN2 w0.117: v2(248.77,83.25) 248.91,83.11 248.91,82.03 257.63,73.31 258.81,73.31 265.01,67.11 265.01,57.09 262.03,54.11 260.79,54.11 v2(260.39,54.51)
  BOTTOM w0.102: UG9.E44 v2(248.77,83.25) ; v2(260.39,54.51) UG3.D13
FBB_DBI3: length 52.7
  IN2 w0.117: v2(246.5,84.77) 247.55,83.72 247.55,81.93 255.66,73.82 255.98,73.82 257.18,72.61 258.53,72.61 264.32,66.82 264.32,58.05 261.98,55.71 257.74,55.71 257.34,55.31 256.14,55.31 254.94,54.11 251.39,54.11 251.18,54.32 251.18,54.92 v2(250.79,55.31)
  BOTTOM w0.102: UG3.D2 251.02,55.08 251.02,55.08 v2(250.79,55.31) ; v2(246.5,84.77) 246.51,84.78 246.51,84.8 246.38,84.93 245.59,84.93 UG9.G39
FBB_DBI4: length 24.7
  IN2 w0.117: v2(272.15,80.36) 271.76,80.75 267.17,80.75 261.28,86.65 260.42,86.65 258.1,88.97 257.25,88.97 v2(255.67,90.55)
  BOTTOM w0.102: UG9.P49 252.92,90.2 254.82,90.2 254.92,90.1 255.22,90.1 255.35,90.23 v2(255.67,90.55) ; UG4.D2 v2(272.15,80.36)
FBB_DBI5: length 29.6
  IN2 w0.117: v2(252.97,87.35) 253.22,87.6 254.14,87.6 254.75,86.99 254.75,86.05 257.51,83.28 257.51,83.27 257.73,83.05 257.74,83.05 257.9,82.89 259.6,82.89 267.91,74.58 271.31,74.58 271.75,74.14 271.75,71.96 v2(272.15,71.56)
  BOTTOM w0.102: v2(272.15,71.56) UG4.D13 ; v2(252.97,87.35) 252.9,87.42 252.44,87.42 252.11,87.75 UG9.L48
FBB_DBI6: length 38.6
  IN2 w0.117: v2(252.97,83.15) 252.97,83.24 253.45,83.72 254.37,83.72 254.7,83.39 254.7,82.02 261.84,74.88 261.84,74.48 267.8,68.52 276.59,68.52 277,68.93 279.55,68.93 280.55,69.93 280.55,71.16 v2(280.95,71.56)
  BOTTOM w0.102: UG4.P13 v2(280.95,71.56) ; UG9.D50 v2(252.97,83.15)
FBB_DBI7: length 33.6
  IN2 w0.117: v2(257.82,84.32) 260.51,84.32 267.82,77 276.1,77 278.26,79.16 279.56,79.16 279.75,79.35 279.75,80.76 v2(280.15,81.16)
  BOTTOM w0.102: UG9.H50 253.62,85.3 254.12,85.3 254.76,84.65 255.55,84.65 255.89,84.32 v2(257.82,84.32) ; UG4.P2 280.34,80.97 v2(280.15,81.16)
FBB_EDC0: length 23.1
  IN2 w0.117: v2(251.58,64.11) 251.19,64.51 249.72,64.51 249.22,65 249.22,70.81 v2(241.64,78.39)
  BOTTOM w0.102: v2(241.64,78.39) 241.8,78.55 241.8,81.02 UG9.B33 ; v2(251.58,64.11) 251.58,64.11 UG3.R2
FBB_EDC1: length 28.7
  IN2 w0.117: v2(242.47,83.85) 242.83,83.49 242.83,81.7 257.47,67.06 257.47,64.77 257.73,64.51 259.19,64.51 v2(259.59,64.11)
  BOTTOM w0.102: UG3.R13 v2(259.59,64.11) ; UG9.E35 v2(242.47,83.85)
FBB_EDC2: length 47.3
  IN2 w0.117: v2(259.59,53.71) 259.99,53.31 262.43,53.31 266.33,57.21 266.33,67.66 260.17,73.82 257.84,73.82 249.38,82.28 249.38,84.76 249.06,85.08 249.06,85.66 v2(248.88,85.84)
  BOTTOM w0.102: v2(248.88,85.84) 249.07,85.65 UG9.G44 ; UG3.C13 259.81,53.93 259.8,53.93 v2(259.59,53.71)
FBB_EDC3: length 51.2
  IN2 w0.117: v2(244.57,85.95) 244.42,85.95 244.21,85.74 243.57,85.74 243.37,85.54 243.37,81.97 243.92,81.42 244.57,81.42 258.52,67.47 259.98,67.47 261.59,65.86 261.59,59.93 260.56,58.91 258.12,58.91 257.74,58.53 255.04,58.53 254.93,58.42 254.93,57.93 254.82,57.82 254.59,57.82 254.48,57.93 254.48,58.41 254.37,58.52 254.2,58.52 252.8,57.12 252.8,57.07 252.8,57.07 252.8,56.75 252.8,56.74 252.8,56.27 252.8,56.27 252.8,55.95 252.8,55.94 252.8,55.92 252.59,55.71 252.17,55.71 251.99,55.53 251.99,54.91 v2(251.59,54.51)
  BOTTOM w0.102: v2(244.57,85.95) UG9.H38 ; v2(251.59,54.51) UG3.C2
FBB_EDC4: length 23.3
  IN2 w0.117: v2(257.42,90.55) 260.75,87.22 261.66,87.22 267.31,81.57 270.95,81.57 v2(271.35,81.16)
  BOTTOM w0.102: v2(257.42,90.55) 256.3,89.43 255.06,89.43 254.94,89.31 254.36,89.31 254.15,89.52 253.6,89.52 UG9.P50 ; UG4.C2 271.59,80.92 v2(271.35,81.16)
FBB_EDC5: length 26.2
  IN2 w0.117: v2(271.35,72.36) 270.95,72.76 267.23,72.76 255.74,84.25 255.74,84.36 255.7,84.4 255.7,84.41 255.48,84.63 255.47,84.63 253.83,86.27 253.32,86.27 253.2,86.39 252.43,86.39 v2(252.17,86.65)
  BOTTOM w0.102: v2(271.35,72.36) 271.75,71.96 UG4.C13 ; v2(252.17,86.65) UG9.J48
FBB_EDC6: length 41.1
  IN2 w0.117: v2(254.27,82.55) 254.27,82.4 253.95,82.08 253.95,82.01 253.95,81.31 253.95,80.25 253.95,80.24 253.95,80.24 254.17,80.02 254.17,80.02 256.44,77.76 257.4,77.76 268.03,67.12 275.22,67.12 275.94,67.85 276.87,67.85 277.28,68.25 280.88,68.25 282.15,69.52 282.15,71.96 v2(281.75,72.36)
  BOTTOM w0.102: UG4.R13 281.75,72.36 v2(281.75,72.36) ; UG9.D51 v2(254.27,82.55)
FBB_EDC7: length 33.6
  IN2 w0.117: v2(280.95,80.36) 280.55,79.96 280.55,79.26 280.06,78.77 280.06,77.83 279.33,77.11 277.92,77.11 276.92,76.1 267.56,76.1 260.23,83.43 v2(257.89,83.43)
  BOTTOM w0.102: v2(280.95,80.36) UG4.R2 ; UG9.F51 254.3,83.92 254.95,83.92 255.04,83.83 256.9,83.83 257.3,83.43 v2(257.89,83.43)
FBB_WCK01: length 31
  IN2 w0.089: v2(241.67,86.65) 241.39,86.37 241.16,86.37 240.81,86.02 240.81,81.61 240.82,81.6 240.82,81.41 241.99,80.24 241.99,80.12 253.68,68.44 253.68,64.04 253.36,63.72 252.81,63.72 v2(252.39,63.31)
  BOTTOM w0.102: UG9.J33 v2(241.67,86.65)
  BOTTOM w0.119: v2(252.39,63.31) 252.79,62.91 UG3.P4
FBB_WCK01#: length 31.1
  IN2 w0.089: v2(241.67,85.95) 241.43,86.19 241.23,86.19 241,85.96 241,81.61 241,81.61 241,81.48 242.17,80.32 242.17,80.2 253.85,68.51 253.85,63.96 253.43,63.54 253.34,63.54 253.3,63.5 253.19,63.39 253.19,63.31 v2(253.19,63.31)
  BOTTOM w0.102: UG9.H33 241.15,85.65 241.06,85.74 241.06,85.91 241.16,86.01 241.61,86.01 v2(241.67,85.95)
  BOTTOM w0.119: UG3.P5 253.34,62.91 253.19,63.06 v2(253.19,63.31)
