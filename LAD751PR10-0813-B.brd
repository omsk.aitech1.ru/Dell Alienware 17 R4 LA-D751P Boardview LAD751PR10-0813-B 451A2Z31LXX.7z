# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V_PCH: length 286.8
  TOP w0.381: v2(211.23,37.07) 210.52,37.78 CH189.1 ; RH558.2 214.56,30.9 v2(214.49,30.96) 214.49,31.02 213.54,31.97 RH7.1 ; v2(209.21,23.82) 209.13,23.82 208.73,24.23 208.73,25.24 209.18,25.69 RH130.1 210.69,25.19 211.12,24.76 RH23.2
  TOP w0.508: v2(128,159.8) 127.47,160.34 RC9.1 ; v2(215.37,17.25) 215.37,16.54 CH192.1 ; v2(221.26,25.94) 220.95,25.63 RH524.1 220.95,23.57 220.82,23.44 RH75.1 221.39,22.8 v2(221.69,22.51) 221.69,22.42 221.18,21.91 RH78.1 ; 224.48,37.05 225.22,36.32 228.46,36.32 229.14,37 229.14,38.39 230.39,39.63 230.39,41.1 229.66,41.83 R367.2 ; CH200.1 213.31,23.52 v2(213.31,24.07) ; v2(206.77,20.39) 206.46,20.39 206.01,19.95 CH190.1 ; v2(210.7,13.26) 210.7,12.92 210.15,12.38 RH461.1 RH460.1 ; CH186.1 214.02,30.49 v2(214.49,30.96) ; CH191.1 209.57,19.73 v2(209.22,20.08) ; v2(221.56,28.47) 220.98,29.05 220.95,29.05 RH506.2
  IN1 w0.508: v2(221.69,22.51) 221.34,22.17 v2(221.34,19.31)
  IN4 w0.508: v2(189.3,37.62) 187.36,39.57 187.36,40.82 188.48,41.94 190.22,41.94 ; v2(209.21,23.82) 209.21,24.12 207.59,25.75 207.59,29.83 207.08,30.33 203.26,30.33 202.62,30.97 202.62,31.04 202.08,31.59 200.54,31.59 198.95,33.18 198.95,33.8 197.04,35.72 195.4,35.72 194.51,36.61 194.51,37.65 190.22,41.94 ; 190.22,41.94 187.36,44.8 187.36,50.6 182.03,55.94 182.03,58.5 180.49,60.04 180.49,69.05 180.67,69.23 180.67,71.69 179.41,72.94 178.23,72.94 176.03,75.15 176.03,92.68 179.52,96.17 179.52,107.6 180.52,108.59 180.52,118.38 188.12,125.98 188.12,144.95 183.68,149.39 167.18,149.39 164.6,151.97 158.38,151.97 153.62,156.74 143.51,156.74 141.17,154.4 137.29,154.4 136.33,153.44 128.33,153.44 127.73,154.04 127.73,158.27 128,158.54 v2(128,159.8)
  BOTTOM w0.203: v2(214.49,30.96) 214.49,30.77 214.46,30.73 UH1.BA20 ; UH1.BA31 213.95,24.07 v2(213.31,24.07) ; UH1.BE4 UH1.BD3 UH1.BE3
  BOTTOM w0.254: v2(206.77,20.39) 206.7,20.34 206.68,20.23 206.29,19.96 UH1.AD41 ; RPH6.8 204.19,13.16 204.43,12.92 ; 204.43,12.92 204.69,13.18 RPH6.7 ; 204.43,12.92 v2(204.43,12.92) ; UH1.BC42 215.73,20.02 UH1.BD40 ; RPH6.6 205.19,13.16 v2(205.43,12.92) 205.68,13.18 RPH6.5 ; UH1.AN5 210.73,37.35 v2(211.23,37.07)
  BOTTOM w0.356: RG555.1 RG556.1 187.68,37.09 188.21,37.62 v2(189.3,37.62)
  BOTTOM w0.381: RH27.2 195.61,13.95 v2(195.84,13.72) 195.61,13.5 RH21.2 ; RH29.2 RH25.2 199.03,12.64 v2(198.97,12.58)
  BOTTOM w0.508: RH493.1 224.01,20.57 224.3,20.86 v2(224.3,21.76) ; RH571.2 216.75,42.39 216.74,42.38 216.74,40.79 217.25,40.28 217.25,39.19 ; v2(221.34,19.31) RH74.1
  vias: v2(210.14,20.08) v2(215.4,18.89) v2(216.87,38.63) v2(216.87,38.04) v2(220.24,39.33) v2(220.83,39.33) v2(221.41,39.33) v2(228.72,15.14) v2(229.31,15.14) v4(214.08,44.86)
+3VALW: length 525.3
  TOP w0.203: UE6.24 328.3,41.45 CE56.1
  TOP w0.254: v2(326.59,13.62) 326.32,13.36 JIO.8
  TOP w0.381: v2(158.2,162.04) 157.64,162.6 RE300.2 ; RU26.1 297.58,63.34 v2(297.16,63.76) ; PR24.2 312.71,49.6 PR3.2 v2(311.92,49.45) ; v2(207.93,35.76) 208.01,35.68 RH2.1 ; RA13.1 20.85,25.39 20.19,26.05 v2(19.91,26.05) 19.91,27.85 20.34,28.28 RA84.2
  TOP w0.508: v2(54.94,16.94) 55.04,17.04 55.63,17.04 56.14,17.55 PR718.2 ; RU20.2 RU16.2 RU15.2 21.36,52.84 21.36,50.44 20.1,49.18 15.44,49.18 v2(13.79,50.83) 13.79,52.39 14.63,53.23 RU17.2 RU18.2 RU19.2 ; RE70.1 310.35,16.84 v2(310.65,16.54) ; CH82.1 203.77,32.8 v2(204.46,32.8) ; RE102.2 286.9,12.41 v2(286.84,12.35) ; PR16.2 80.7,8.91 80.11,8.31 78.48,8.31 78.05,8.74 78.05,9.82 76.19,11.69 76.19,13.67 74.15,15.7 v4(69.4,15.7) v2(68.32,15.7) ; v2(239.06,42.13) 238.49,42.7 237.68,42.7 237.17,42.2 PR812.2 ; v2(125.22,114.12) 123.88,112.78 v2(123.39,112.78) ; PR709.2 59.25,17.49 59.26,17.48 v2(59.26,15.22) ; RE642.1 RE643.1 298.27,27.14 v2(298.58,27.45) ; v2(244.04,20.16) 244.12,20.24 PR301.1 ; R307.1 320.53,36.85 v2(320.11,37.27) ; R325.1 326.4,36.16 v2(328.05,34.51) ; RE530.1 318.16,54.03 v2(317.71,53.59) ; v2(308.38,8.59) 308.38,9.51 308.89,10.01 RE79.1 ; v2(280.74,148.56) PR6069.1 ; CE56.1 327.68,42.95 327.61,43.02 v2(327.6,43.02) ; RT53.1 v2(194.69,165.23) ; v2(66.75,16.38) 65.68,16.38 65.15,16.91 PR710.1 ; v2(330.46,37.7) RE91.1 ; v2(188.06,113.97) 188.06,115.28 189.36,116.59 192.82,116.59 193.78,117.55 194.71,117.55 196.26,116 198.93,116 199.36,116.43 203.53,116.43 205.02,114.93 207.21,114.93 207.73,115.45 v2(207.73,115.7) ; RE64.2 v2(288.06,6.78) ; RH2.1 208.76,36.04 208.61,36.19 208.61,37.82 208.35,38.07 208.35,38.77 210.51,40.93 210.51,45.05 211.03,45.57 221.99,45.57 222.26,45.31
  IN1 w0.508: v2(159.77,173.39) 159.08,174.09 152.39,174.09 v2(151.57,173.26) ; v2(311.92,49.45) 313.18,50.71 315.17,50.71 317.71,53.25 v2(317.71,53.59) ; v2(59.26,15.22) 59.26,16.52 60.78,18.04 64.09,18.04 64.3,17.84 ; v2(188.25,168.86) 188.25,167.18 188.76,166.67 189.33,166.67 189.94,166.06 194,166.06 194.69,165.37 v2(194.69,165.23)
  IN2 w0.381: v2(204.46,32.8) 205.11,32.8 205.81,32.1 208.35,32.1 208.67,31.78 210.47,31.78 210.96,31.3 210.96,30.77 211.4,30.32 214.46,30.32 214.8,29.98 214.8,29.34 215.35,28.8 v2(215.35,27.57)
  IN3 w0.508: v2(286.84,12.35) 287.45,11.74 287.45,9.37 288.06,8.76 v2(288.06,6.78) ; v2(97.38,41.79) 96.78,42.39 96.78,48.42 v2(98.24,49.88) ; v2(320.11,37.27) 319.3,37.27 317.8,38.77 317.8,38.94 317.45,39.3 316.61,39.3 315.92,39.99 315.92,41.69 v2(317.99,43.75) ; v2(59.26,15.22) 59.26,14.72 58.64,14.1 56.63,14.1 54.94,15.79 v2(54.94,16.94) ; v2(123.39,112.78) 123.28,112.78 122.75,113.31 122.75,115.33 123.39,115.97 123.39,117.38 124.53,118.52 124.53,120.81 125.55,121.83 125.55,123.93 119.14,130.34 119.14,142.94 120.72,144.53 120.72,146.39 121.52,147.19 123.61,147.19 124.34,147.92 124.34,148.77 125.48,149.91 125.48,150.69 127.8,153.01 137.49,153.01 138.88,154.4 141.38,154.4 144.81,157.83 144.81,158.72 145.27,159.17 145.84,159.17 147.02,160.36 147.02,162.5 148.36,163.84 148.36,164.29 149.59,165.53 149.59,167.02 149.28,167.33 149.28,169.85 149.96,170.52 149.96,172.08 151.14,173.26 v2(151.57,173.26) ; v2(13.79,50.83) 15.85,48.77 18.69,48.77 20.65,46.81 22.76,46.81 23.54,46.03 26.69,46.03 28.19,44.53 29.78,44.53 34.93,39.37 34.93,37.14 36.38,35.69 37.1,35.69 38.05,34.75 38.05,31.85 38.55,31.34 39.37,31.34 41.46,29.24 41.46,26.32 41.83,25.95 43.21,25.95 43.96,25.2 v2(43.96,23.63) ; v2(98.93,24.23) 99.34,24.23 101.7,26.59 101.7,27.4 102.71,28.41 v2(102.71,29.12)
  IN4 w0.381: v2(204.46,32.8) 205.18,32.8 206.11,33.72 206.94,33.72 206.95,33.72 206.96,33.72 207.32,34.08 207.32,35.37 207.7,35.76 v2(207.93,35.76)
  IN4 w0.508: v2(288.06,6.78) 288.87,5.96 296.31,5.96 v2(297.25,5.02) 297.7,4.57 303.77,4.57 v2(305.99,6.79) 307.79,8.59 v2(308.38,8.59) ; v2(97.38,41.79) 97.45,41.85 99.27,41.85 101.05,40.07 101.05,35.05 102,34.1 102,29.83 v2(102.71,29.12) ; v2(188.06,113.97) 188.85,114.76 188.85,118.45 193.96,123.56 193.96,127.26 194.64,127.94 194.64,129.07 195.9,130.33 195.9,134.51 196.57,135.17 196.57,137.17 195.68,138.05 195.68,145.79 192.2,149.28 192.2,151.38 190.81,152.76 190.81,160 189.94,160.88 189.94,163.61 189.24,164.31 188.63,164.31 188.25,164.69 v2(188.25,168.86)
  IN6 w0.508: v2(158.2,162.04) 158.2,163.53 v2(160.82,166.15) ; v2(13.79,50.83) 14.8,50.83 16.84,48.8 18.79,48.8 20.21,47.38 20.21,42.6 19.92,42.31 19.92,35.86 19.27,35.21 19.27,26.56 v2(19.91,26.05)
  BOTTOM w0.127: v2(215.35,27.57) 215.09,27.83 214.61,27.83 UH1.BA24
  BOTTOM w0.254: v2(239.06,42.13) 239.24,41.95 PU800.15 ; v2(204.46,32.8) 204.07,32.41 UH1.W15 ; PU509.15 123.46,115.4 124.08,114.79 124.08,114.45 124.53,114 PC5003.1
  BOTTOM w0.381: RM41.1 150.71,170.01 149.79,170.92 CM70.1 149.61,170.93 UM7.5
  BOTTOM w0.508: PR210.1 v2(97.38,41.79) ; PR8220.1 239.66,34.06 v2(238.91,33.31) ; RH533.2 221.37,31.5 220.86,32.01 RH453.2 RH515.2 RH545.2 221.86,33.92 v2(222.53,34.59) ; RM41.1 151.3,170.01 152.14,170.86 152.14,172.68 v2(151.57,173.26) ; v2(326.59,13.62) 325.64,14.57 325.64,16.62 326.45,17.43 v2(327.15,17.43) ; CE22.1 103.67,30.17 103.2,30.63 UE9.5 v2(102.71,29.12) ; PR1300.1 98.08,49.71 v2(98.24,49.88) ; RE644.2 v2(207.73,115.7) ; v2(125.22,114.12) 125.22,114.13 125.22,114.56 PR5033.2 ; v2(239.06,42.13) 239.06,44.23 PC817.1 ; RT97.1 178.37,174.61 177.6,175.37 175.57,175.37 175.3,175.1 175.3,173.77 175.35,173.73 v2(175.35,173.2) ; PC5003.1 124.53,113.37 123.94,112.78 v2(123.39,112.78)
  vias: v2(44.59,21.88) v2(44.78,22.45) v2(45.16,23.02) v2(45.22,21.88) v2(45.41,22.45) v2(45.47,23.59) v2(45.86,23.02) v2(45.86,21.88) v2(46.11,23.59) v2(46.11,22.45) v2(46.49,23.02) v2(46.49,21.88) v2(46.74,23.59) v2(46.74,22.45) v2(47.13,23.02) v2(47.13,21.88) v2(47.38,23.59) v2(47.38,22.45) v2(47.76,23.02) v2(47.82,21.88) v2(48.01,22.45) v2(48.08,23.59) v2(48.4,23.02) v2(48.71,23.59) v2(66.13,17.02) v2(66.18,15.77) v2(66.75,17.58) v2(66.75,17) v2(66.77,15.74) v2(66.77,15.16) v2(67.41,15.13) v2(68.04,15.13) v2(68.32,17.61) v2(68.32,16.97) v2(68.32,16.34) v2(174.74,173.2) v2(225.65,43.85) v2(226.02,43.39) v2(226.6,43.4) v2(228.95,33.46) v2(229.02,30.14) v2(229.02,26.96) v2(229.32,23.74) v2(230.81,34.35) v2(234.95,33.43) v2(234.95,30.19) v2(234.95,26.96) v2(234.96,23.78) v2(243.33,19.55) v2(243.91,19.55) v2(267.2,22.28) v2(267.8,22.89) v2(267.84,22.28) v2(268.3,23.37) v2(268.45,22.24) v2(268.58,22.85) v2(268.83,23.93) v2(268.89,23.35) v2(269.11,22.28) v2(269.41,24.07) v2(270.01,24.09) v2(270.6,24.09) v2(271.03,170.16) v2(271.03,169.58) v2(280.31,168.17) v2(280.48,167.6) v2(289.25,23.9) v2(289.69,23.46) v2(290.2,22.96) v2(297.04,25.18) v2(302.51,25.07) v2(310.9,23.97) v2(311.54,23.97) v2(313.7,54.96) v2(313.7,54.38) v4(43.15,23.9) v4(223.03,45.38)
+3VALW_PD: length 2.1
  BOTTOM w0.152: UT4.H1 198.15,163.57 197.8,163.57 197.76,163.61 197.75,163.61 197.59,163.77 196.99,163.77 v1(196.81,163.95) 196.71,164.05 v2(196.29,164.05)
+3VALWP: length 61.1
  IN1 w0.508: v2(60.24,44.37) 60.24,46.19 58.66,47.77 48.45,47.77 47,46.32 39.41,46.32 38.52,45.43 38.52,40.23 35.95,37.66 35.95,36.13 37.79,34.29 37.79,33.62 38.81,32.61 39.94,32.61 40.38,33.05 41.12,33.05 41.55,32.62 41.55,26.05 v2(42.35,25.24)
  BOTTOM w0.254: PC117.1 41.86,24.75 v2(42.35,25.24)
  BOTTOM w0.508: PR101.1 57.14,49.5 59.38,49.5 60.24,48.63 v2(60.24,44.37)
  vias: v1(42.67,18.03) v2(43.95,19.72) v2(44.14,19.15) v2(44.52,18.64) v2(44.59,19.72) v2(44.84,19.18) v2(44.78,18.07) v2(45.16,18.64) v2(45.22,19.72) v2(45.22,17.49) v2(45.41,18.07) v2(45.54,19.21) v2(45.86,19.72) v2(45.86,18.64) v2(45.86,17.49) v2(46.11,18.07) v2(46.17,19.21) v2(46.49,19.72) v2(46.49,18.64) v2(46.49,17.49) v2(46.74,18.07) v2(46.87,19.21) v2(47.13,18.64) v2(47.13,17.49) v2(47.19,19.72)
+3VLP: length 393.6
  TOP w0.381: CU26.1 27.92,43.68 28.05,43.81 UU5.5 28.88,43.81 29,43.68 29,43.6 29.3,43.3 30.05,43.3 30.61,42.73
  TOP w0.508: v2(296.52,36.42) v4(296.52,40.19) v2(295.92,40.79) PD5.3 ; RU1.1 25.07,41.66 25.09,41.69 25.78,41.69 26.83,42.74 ; 30.61,42.73 30.96,42.38 32.99,42.38 33.15,42.55 34.51,42.55 35.92,43.95 v2(35.92,45.3) 34.93,46.29 DU8.1 33.14,45.27 RU4.1 RU5.1 ; RA85.2 20.6,26.46 v2(20.82,26.23) ; 26.83,42.74 26.83,44.99 RU7.1 ; 26.83,42.74 CU26.1 ; PR25.2 v2(313.64,49.88)
  IN1 w0.508: v2(313.64,49.88) 313.64,49.75 312.56,48.67 312.56,45.71 310.69,43.84 308.94,43.84 308.62,43.52 305.59,43.52 303.48,41.41 298.62,41.41 297.99,40.79 v2(295.92,40.79) ; v2(85.42,48.48) 84.71,49.19 66.93,49.19 66.7,49.42 53.81,49.42 53.2,50.03 v2(52.69,50.03) 51.91,49.24 48.27,49.24 46.3,47.28 37.89,47.28 v2(35.92,45.3) 33.32,42.71 33.32,36.86 32.43,35.97 28.56,35.97 27.14,34.55 25.64,34.55 22.21,31.12 22.21,30.64 20.82,29.25 v2(20.82,26.23)
  IN2 w0.508: v2(85.42,48.48) 86.12,47.78 95.29,47.78 95.31,47.76 96.22,47.76 96.68,47.3 97.67,47.3 98.46,48.09 105.99,48.09 106.24,47.84 125.24,47.84 125.74,47.34 172.67,47.34 172.77,47.23 174.2,47.23 174.67,46.77 176.34,46.77 178.72,44.4 179.9,44.4 180.42,44.92 182.18,44.92 188.24,50.98 196.41,50.98 197.26,50.14 200.57,50.14 202.6,52.17 206.84,52.17 210.02,48.99 210.02,48.04 210.64,47.42 211.79,47.42 213.28,45.93 216.36,45.93 216.58,45.71 216.88,45.41 222.59,45.41 223.43,44.57 223.43,43.82 225.43,41.82 231,41.82 233.27,44.09 239.4,44.09 240.92,42.58 247.71,42.58 248.5,43.36 267.06,43.36 271.22,39.21 v2(272.02,39.21)
  IN3 w0.508: v2(296.52,36.42) 296.52,33.92 300.05,30.39 300.05,28.02 301.66,26.41 302.63,26.41 303.55,25.5 303.55,24.52 304.72,23.35 304.72,22.12 306.54,20.3 306.54,16.73 307.92,15.35 v2(308.41,15.35)
  IN6 w0.508: v2(272.02,39.21) 272.49,39.21 272.63,39.07 277.14,39.07 278.68,37.52 279.94,37.52 281.87,39.45 287.63,39.45 288.97,40.79 v2(295.92,40.79)
  BOTTOM w0.203: PU100.3 53.86,47.97 53.95,48.06 PC101.1
  BOTTOM w0.508: v2(52.69,50.03) 52.69,49.42 53.55,48.56 PC101.1
+3VS: length 677.2
  TOP w0.203: v2(18.79,22.88) 18.97,22.7 UA3.B2
  TOP w0.254: v2(324.37,13.05) 325.06,12.36 JIO.6 ; UG16.12 197.72,111.28 CG474.1 ; v2(197.4,109.68) 197.31,109.78 UG16.9
  TOP w0.305: US1.14 182.66,66.13 CS7.1 ; CS2.1 184.45,62.45 184.74,62.75 184.74,63.25 184.24,63.76 US1.1
  TOP w0.356: v2(312.9,55.04) RG561.1
  TOP w0.381: v2(156.98,37.75) 156.98,38.38 RD6.1 ; v2(207.79,33.19) 207.91,33.3 RH518.2 ; CH201.1 216.57,22.28 216.67,22.38 ; RG536.1 188.48,101.29 v2(188.3,101.47) ; v2(206.75,34.25) 206.75,34.22 206.32,33.79 CH188.1 ; v2(213.31,157.19) 213.52,157.41 RG506.1 ; v2(309.72,56.85) 309.72,57.18 309.15,57.75 RG534.1 ; 188.71,95.7 188.32,96.08 RG535.1 188.18,97.24 187.94,97.48 v2(187.46,97.48) ; v2(195.86,104.6) 196,104.46 CG475.1
  TOP w0.406: UH3.5 215.7,22.26 216.39,22.26 CH201.1 ; 216.67,22.38 216.86,22.38 216.93,22.45 v2(216.99,22.45)
  TOP w0.457: QS3.2 189.19,67.49 v2(189.28,67.4)
  TOP w0.508: RD3.1 156.55,48.49 157.43,49.37 v2(157.49,49.37) ; CD17.1 177.48,64.55 182.13,64.55 ; v2(127.38,149.94) 126.7,149.94 125.98,150.67 CM29.1 125.93,151.44 v2(125.93,152.24) 125.98,152.29 CM31.1 ; CG474.1 197.89,111.61 198.4,112.12 v2(198.47,112.12) ; RH520.1 RH463.1 RH462.1 214.58,14.69 215.08,15.2 v2(215.08,15.72) 215.2,15.83 217.27,15.83 218.52,17.09 218.52,19.27 218.52,19.27 ; v2(118.56,124.81) 120.02,124.81 120.65,124.18 120.65,122.91 v2(123.4,120.17) ; v2(122.31,134.33) 122.56,134.59 PR515.1 ; PR8219.1 244.04,28.21 243.74,27.91 243.74,26.84 244.24,26.33 244.96,26.33 v2(245.07,26.44) ; RA11.2 v2(40.79,27.53) ; 182.13,64.55 182.13,65.56 182.58,66.02 CS7.1 182.58,66.76 v2(182.71,66.88) ; 182.13,64.55 182.63,64.55 183.14,64.04 183.14,63.28 183.97,62.45 CS2.1 ; CD35.1 178.26,45.97 v2(178.34,45.9) 178.19,45.75 CD34.1 177.57,39.62 RD5.1 RD4.1 ; v2(160.73,162.68) 160.24,163.16 RV47.1 ; v2(118.42,85.44) 119,84.87 120.91,84.87 123.1,82.68 123.1,76.78 124.12,75.76 RH525.1 ; RH501.1 RH502.1 216.7,19.69 217.11,19.27 218.52,19.27 ; 218.52,19.27 218.59,19.34 218.59,21.67 217.81,22.45 v2(216.99,22.45) ; RV659.2 193.56,10.3 194.35,11.08 195.46,11.08 ; RH588.1 RH85.2 221.23,27.91 221.3,27.84 221.73,27.84 v2(221.79,27.79) ; v2(310.84,12.55) 310.3,12.01 RE84.1 ; v2(207.15,131.5) v2(207.15,130.14) 207.15,128.18 v2(205.75,126.78) 204.84,125.87 v2(204.84,125.29) 204.04,124.49 203.13,124.49 199.14,120.51 v2(199.14,118.65) ; RN16.1 317.59,39.22 ; v2(179.46,53.69) 179,53.23 178.82,53.23 RD2.1 178.25,52.66 RD1.1 ; RF2.2 v2(105.09,60.35) ; v2(193.05,131.99) 192.16,131.99 191.46,131.29 v2(191.46,130.15) ; v2(287.41,75.72) 286.77,75.09 RF5.2 RF4.2 ; 188.71,95.7 189.42,95.7 190.13,96.41 190.13,101.14 191.73,102.74 197.1,102.74 197.51,103.15 197.51,104.1 197.15,104.46 CG475.1 ; RF1.2 v2(105.11,58.57)
  IN1 w0.457: v2(123.71,157.29) 123.84,157.29 124.24,156.89
  IN1 w0.508: 124.24,156.89 v2(125.93,155.2)
  IN2 w0.508: v2(70.67,17) 70.67,16.19 68.83,14.34 66.65,14.34 65.93,15.07 64.39,15.07 63.61,15.84 63.61,17 62.07,18.54 54.75,18.54 54.41,18.19 53.29,18.19 52.78,17.69 52.78,16.68 52.35,16.25 52.32,16.25 52.31,16.24 46.74,16.24 46.09,16.88 44.94,16.88 43.35,18.47 37.38,18.47 34.5,21.35 v2(34.5,22.6) 34.69,22.6 35.19,23.09 35.19,23.51 37.52,25.84 39.1,25.84 v2(40.79,27.53) ; v2(207.79,33.19) 207.72,33.19 206.75,34.16 v2(206.75,34.25) ; v2(241.5,154.85) 242.48,155.82 263.84,155.82 264.35,156.33 264.35,158.71 265.91,160.27 265.91,167.51 v2(266.2,167.8) ; v2(98.69,29.24) 98.69,24.85 97.81,23.97 97.81,20.97 v2(96.08,19.25) ; v2(195.96,135.43) 194.75,135.43 193.05,133.72 v2(193.05,131.99)
  IN3 w0.508: v2(34.5,22.6) 32.61,22.6 30.94,24.26 20.68,24.26 20.1,24.85 18.79,24.85 18.04,24.1 18.04,23.06 18.22,22.88 v2(18.79,22.88) ; v2(169.05,161.7) 169.05,161.77 169.74,162.47 169.74,167.74 v2(167.78,169.7) ; v2(309.72,56.85) 311.24,55.33 312.6,55.33 v2(312.9,55.04) ; v2(127.38,149.94) 127.38,149.38 127.74,149.02 129.65,149.02 131.9,151.28 137.4,151.28 v2(138.85,149.83) ; v2(277.07,144.88) 277.07,146.33 275.1,148.3 v2(275.05,148.3) 273.6,149.75 273.6,153.17 274.87,154.44 275.66,154.44 276.17,154.95 276.17,156.94 276.95,157.72 276.95,165.08 272.91,169.12 272.91,169.51 271,171.42 268.11,171.42 267,170.31 267,168.6 v2(266.2,167.8) ; v2(207.79,33.19) 208.17,33.19 208.61,33.62 208.61,37.15 213.78,42.32 v2(213.96,42.32)
  IN4 w0.508: v2(195.86,104.6) 197.75,104.6 199.09,105.94 199.09,107.59 198.62,108.06 197.84,108.06 197.37,108.52 197.37,109.65 v2(197.4,109.68) 197.37,109.72 197.37,110.68 198.47,111.78 v2(198.47,112.12) ; v2(107.01,25.75) 107.01,28.2 103.92,31.29 103.92,45.97 107.73,49.78 107.73,55.42 105.11,58.03 v2(105.11,58.57) 105.09,58.59 v2(105.09,60.35) ; v2(309.72,56.85) 310.49,56.09 310.49,52.91 309.79,52.22 302.78,52.22 301.43,50.87 301.43,49.32 v2(301.7,49.05) ; v2(156.98,34.2) v2(156.98,37.75) 156.98,38.64 158.57,40.23 158.57,46.32 157.49,47.4 v2(157.49,49.37) ; v2(300.06,5.65) 302.11,7.7 305.34,7.7 310.19,12.55 v2(310.84,12.55) 313.39,12.55 313.89,13.05 v2(324.37,13.05)
  BOTTOM w0.203: v2(195.96,135.43) 196.32,135.07 UV21.35 ; UV21.60 203.56,130.18 204.05,129.69 204.05,128.77 204.34,128.49 204.34,127.62 204.8,127.16 204.8,126.03 CV437.1 ; CV436.1 193.14,130.15 193.18,130.18 UV21.21 ; UV21.49 201.92,135.4 202.18,135.67 202.65,135.67 203.12,136.14 RV25.2 ; v2(193.05,131.99) 193.25,132.18 UV21.26
  BOTTOM w0.254: U2407.1 185.89,46.62 185.7,46.82 C2498.1 ; CM33.1 125.86,156.09 126.45,156.68 UM8.24 ; UH1.AD13 206.25,33.73 206.75,34.22 v2(206.75,34.25)
  BOTTOM w0.305: RV672.2 236.57,162.47 v2(236.53,162.5) ; v2(178.34,45.9) 177.6,45.9 177.19,46.3 JDIMM2.255 ; v2(177.19,61.39) JDIMM1.255
  BOTTOM w0.356: v2(237.44,164.37) 237.35,164.28 RV671.2 ; RT107.1 203.62,155.48 v2(203.41,155.7) ; RM86.1 138.5,150.17 v2(138.85,149.83) ; RM66.2 138.92,158.26 RM85.1 ; v2(211.53,157.77) 211.22,157.77 210.84,157.39 210.84,157.28 210.7,157.14 210.7,156.86 210.41,156.57 210.4,156.57 210.31,156.48 209.6,156.48 QX3.1 ; QH5.5 208.42,14.83 208.06,14.47 RH537.2 206.85,14.47 v2(206.83,14.49) ; RT58.1 203.64,154.67 v2(203.12,155.19) ; RS2.2 v2(96.08,19.25) ; v2(236.22,164.31) 236.33,164.31 236.99,164.97 236.99,165.32 RV16.1
  BOTTOM w0.381: RM14.1 124.05,157.31 123.71,157.31 v2(123.71,157.29) ; 140.16,158.25 140.83,157.59 140.83,153.03 140.04,152.24 RM79.1 139.4,150.98 138.87,150.45 RM86.1 ; 140.16,158.25 140.42,158.51 140.42,160.86 140.15,161.13 139.2,161.13 138.92,160.85 RM26.1 ; 140.16,158.25 RM66.2 ; CM18.1 168.41,160.69 168.59,160.51 UM4.16 ; RV631.2 207.53,127.18 207.91,126.8 RG517.1 ; UM4.5 168.59,152.61 CM20.1 ; 164.4,160.43 164.92,160.94 165.61,160.94 165.99,160.56 UM4.12 ; RT58.1 204.72,154.78 205.7,154.78 RT57.1 ; UM4.9 165.99,152.36 CM21.1
  BOTTOM w0.432: v2(209.69,15.84) 209.69,15.39 210.24,14.83 QH5.2
  BOTTOM w0.508: v2(182.32,33.24) 182.32,38.7 184.73,41.12 C2498.1 ; v2(125.93,155.2) CM30.1 ; CM30.1 125.23,153.98 125.12,153.87 125.12,153.05 v2(125.93,152.24) ; CM30.1 CM33.1 ; v2(202,141.45) 202.31,141.76 204.86,141.76 205.56,141.06 RV658.2 ; RV627.2 RV623.2 206.51,129.5 v2(207.15,130.14) ; RV625.2 196.99,137.97 v2(196.87,138.08) ; RH584.2 200.88,12.91 v2(200.55,12.58) ; v2(127.38,149.94) RM76.1 RM81.1 ; v2(162.26,160.89) 162.75,160.89 163.21,160.43 164.09,160.43 ; RH5.1 214.01,42.37 v2(213.96,42.32) ; v2(304.19,19.96) 303.88,19.65 303.88,11.3 300.67,8.08 300.67,6.26 v2(300.06,5.65) ; QX2.1 227.27,167.1 226.21,166.04 v2(226.21,164.64) ; RV634.1 206.32,127.43 205.75,126.86 v2(205.75,126.78) ; RV634.1 RV635.1 ; RV634.1 206.76,127.59 RV631.2 ; R2.1 194.35,13.43 v2(195.04,14.13) ; RL5.2 266.59,167.41 v2(266.2,167.8) ; v2(191.46,130.15) 191.68,130.15 CV436.1 ; PR6042.1 277.31,144.63 v2(277.07,144.88) ; RE20.2 98.83,29.38 v2(98.69,29.24) ; v2(207.15,131.5) 206.93,131.5 206.9,131.53 RV21.2 RV629.2 ; v2(190.13,141.64) 190.13,135.66 190.64,135.15 RV19.1 ; PR820.2 228.39,36.34 227.88,35.83 227.88,34.3 227.38,33.79 227.14,33.79 225.92,32.57 225.92,31.74 226.36,31.3 226.36,30.69 225.86,30.18 225.86,29.9 224.68,28.72 224.68,27.73 224.86,27.55 224.86,26.88 222.79,24.81 222.78,24.81 ; CV437.1 204.72,125.41 v2(204.84,125.29) ; 164.4,160.43 164.09,160.43 ; 164.09,160.43 CM19.1 ; RC62.2 213.61,13.24 RC65.2 214.18,13.4 215.16,14.38 RH517.1 215.17,14.59 215.17,15.31 215.08,15.4 v2(215.08,15.72) ; v2(34.5,22.6) 34.84,22.6 RA5.2 ; CM20.1 v2(167.14,152.36) CM21.1 v2(165.22,152.36) ; R181.1 186.43,38.12 185.05,36.74 185.05,31.66 v2(184.48,31.08) ; v2(301.7,49.05) 299.94,50.81 299.94,57.11 300.52,57.68 300.52,61.16 299.19,62.49 299.19,62.93 298.26,63.86 298.26,67.86 293.13,72.99 292.71,72.99 289.98,75.72 v2(287.41,75.72) ; RV25.2 203.12,136.32 203.89,137.09 204.07,137.09 204.58,137.6 204.58,138.32 203.95,138.94 202.22,138.94 201.24,139.92 v2(201.24,140.27) ; RM18.1 173.31,158.37 172.81,157.86 172.8,157.86 v2(172.76,157.82) ; RM20.1 RM96.1 v2(170.3,150.83) ; RV45.2 167.53,167.11 167.9,167.48 167.9,167.95 168.28,168.33 168.28,169.2 v2(167.78,169.7) 167.59,169.89 CV21.1 166.06,170.56 RV81.1 ; PR5016.1 v2(123.4,120.17) ; CM18.1 168.46,161.37 168.74,161.65 169,161.65 v2(169.05,161.7)
  vias: v2(70.67,18.27) v2(70.67,17.63) v2(71.37,18.27) v2(71.37,17.63) v2(71.37,17) v2(72,18.27) v2(72,17.63) v2(72,17) v2(72.7,18.27) v2(72.7,17.63) v2(72.7,17) v2(120.11,23.08) v2(120.11,22.5) v2(120.7,23.08) v2(120.7,22.5) v2(121.28,23.08) v2(121.28,22.5) v2(121.87,23.08) v2(121.87,22.5) v2(161.61,165.5) v2(162.19,165.5) v2(164.5,165.36) v2(164.82,165.86) v2(165.35,165.12) v2(165.4,165.72) v2(172.02,164.79) v2(172.02,164.2) v2(176.41,34.89) v2(176.41,34.26) v2(177.19,62.02) v2(177.49,34.77) v2(177.49,34.07) v2(178.19,34.77) v2(186.93,67.26) v2(186.95,66.64) v2(205.38,24.73) v2(205.77,24.34) v2(221.85,24.2) v2(222.3,23.75) v2(239.89,161.43) v2(240.29,160.94) v2(300.78,39.35) v2(301.45,39.34) v2(302.08,39.34) v2(302.72,39.34) v2(316.87,39.91) v2(317.55,39.92) v2(318.18,39.92) v4(199.36,15.78)
+3VS_CAM: length 31.4
  TOP w0.102: v1(162.42,182.35) 163.12,181.65 v2(163.12,181.17)
  TOP w0.254: JEDP.24 v2(163.12,181.17) ; v2(166.89,181.16) 167.12,180.92 JEDP.32
  TOP w0.508: RV47.2 159.33,163.4 v2(159.58,163.15)
  IN3 w0.508: v2(159.58,163.15) 159.58,167.16 160.87,168.45 160.87,171.01 161.46,171.61 161.46,172.03 161.81,172.37 161.81,172.75 162.98,173.92 165.32,173.92 167.58,176.17 167.58,176.97 168.26,177.66 168.26,179.79 v2(166.89,181.16) 166.87,181.17 v2(163.12,181.17)
+3VS_DP: length 0.4
  TOP w0.203: 239.67,163.76 v4(239.25,163.76)
  vias: v2(240.1,164.12) v2(240.1,163.48) v2(240.74,164.12) v2(240.74,163.48)
+3VS_SSD: length 132.8
  TOP w0.356: C623.1 331.55,31.62 331.2,31.97 329.7,31.97 328.99,31.26 R363.2 ; v2(280.81,6.51) 278.08,6.51 277.31,7.27 R365.2
  TOP w0.508: v2(334.56,45.37) 333.78,46.16 C618.1 C617.1 333.78,47.39 333.38,47.78 C622.1 ; v2(321.61,25.88) 321.61,25.08 C624.1
  IN2 w0.508: v2(234.6,20.12) 234.6,20.24 233.68,21.16 230.89,21.16 228.13,23.93 228.13,33.79 228.63,34.3 229.83,34.3 230.64,35.1 235.69,35.1 236.91,33.89 238.45,33.89 238.48,33.92 239.99,33.92 240.71,33.19 240.71,30.08 242.38,28.42 247.84,28.42 248.67,27.59 265.31,27.59 267.53,25.37 270.29,25.37 273.34,22.32 275.85,22.32 v2(277,21.18)
  IN2 w2.032: 325,5.3 330.35,5.3 333.38,8.34 333.38,27.1
  BOTTOM w0.356: v2(234.6,20.12) R364.2
  BOTTOM w0.508: v2(333.07,28.63) 331.83,27.4 325.13,27.4 324.62,27.91 322.45,27.91 321.61,27.06 v2(321.61,25.88)
  vias: v2(236.19,6.53) v2(236.77,6.53) v2(252.55,6.64) v2(253.13,6.64) v2(253.72,6.64) v2(254.64,6) v2(255.23,6) v2(255.79,8.6) v2(255.81,6) v2(256.37,8.6) v2(256.4,6) v2(256.96,8.6) v2(260.99,14.64) v2(261.58,14.64) v2(262.16,14.64) v2(262.75,14.64) v2(277,20.35) v2(277.58,20.35) v2(278.14,21.18) v2(278.16,20.35) v2(280.81,7.09) v2(281.43,6.8) v2(281.43,6.19) v2(333.07,29.24) v2(333.68,29.24) v2(333.68,28.63) v2(334.6,44.73) v2(334.9,44.23) v2(335.23,45.37) v2(335.24,44.75) v4(247.15,6.38)
+3VS_TBT: length 41.1
  TOP w0.178: v2(180.01,167.07) 179.68,166.73 UT1.H9
  TOP w0.254: UT1.R13 181.94,163.17 v2(181.94,163.15)
  IN2 w0.508: 174.13,156.05 173.74,155.67 173.74,153.87 174.25,153.36 176.9,153.36 178.16,154.63 178.65,154.63 178.72,154.55 183.25,154.55 184.35,155.65 v2(184.35,155.8)
  IN6 w0.508: v2(178.19,151.35) 178.19,152.18 177.3,153.07 177.3,153.77 176.31,154.76 176.21,154.76 175.2,155.76 175.2,157.38 177.68,159.86 181.36,159.86 181.94,160.43 v2(181.94,163.15)
  BOTTOM w0.381: CT48.1 181.9,163.19 v2(181.94,163.15) ; RT20.1 178.18,152.69 RT76.2 v2(178.19,151.35) ; v2(184.35,155.8) 184.1,155.54 v1(184.1,154.27) 184.1,152.88 183.89,152.67 RT77.2 ; RT21.1 179.68,172.9 v2(179.78,173.01)
  vias: v2(177.55,173.96) v2(177.55,173.32)
+3VS_TOUCH: length 123.5
  TOP w0.203: v4(194.78,10.49) 194.78,9.99 v2(194.83,9.94)
  TOP w0.508: v2(300.05,6.94) 300.83,6.15 300.83,5.27 301.34,4.76 RE100.1 RE101.1
  IN2 w0.508: v2(215.85,9.62) 217.09,10.87 232.29,10.87 232.89,11.47 241.32,11.47 242.79,10 250.68,10 252.24,11.56 259.3,11.56 259.91,12.17 267.11,12.17 267.41,11.88 276.87,11.88 280.18,8.57 287.49,8.57 287.68,8.38 292.53,8.38 292.72,8.19 295.3,8.19 296.54,6.94 v2(300.05,6.94)
  IN4 w0.508: v2(194.83,9.94) 194.83,9.56 195.72,8.67 206.18,8.67 207.1,9.59 215.81,9.59 v2(215.85,9.62)
  BOTTOM w0.305: v2(194.83,9.94) 194.83,9.83 194.36,9.37 192.86,9.37 191.82,10.4 JTP.11 191.82,13.09 R2.2
  BOTTOM w0.508: C2.1 192.4,14.12 192.16,13.88 R2.2
+5V_HDD: length 0.8
  TOP w0.203: v4(127.43,12.35) 127.52,12.26 v2(127.52,11.54)
  vias: v2(126.88,11.54) v2(126.88,10.95) v2(127.52,10.95) v2(128.15,11.54) v2(128.15,10.95)
+5V_PVDD: length 2.9
  BOTTOM w0.508: v2(27.38,41.24) CA5.1 27.81,40.11 CA6.1 27.82,39.58 RA68.2
  vias: v1(30.23,40.76)
+5V_TOBII:
  vias: v4(155.62,163.44)
+5V_USB_PWR1:
  vias: v2(18.52,47.44) v2(18.52,46.81) v2(19.16,47.44) v2(19.16,46.81) v4(19.99,47.44)
+5V_USB_PWR2: length 3.3
  TOP w0.102: JIO.3 324.78,10.85 324.1,10.18 324.1,8.92 v4(323.87,8.69)
  vias: v2(320.66,20.69) v2(320.66,20.1) v2(320.71,21.85) v2(320.72,21.27) v2(326.46,11.53) v2(326.46,10.83) v2(327.08,11.53) v2(327.1,10.83)
+5V_USBC_VBUS: length 355.4
  TOP w0.203: v4(11.64,52.77) 11.7,52.83 v2(11.7,53.33)
  TOP w0.254: JUSBC2.B4 6.28,59.17 6.3,59.16 6.33,59.16 6.62,58.86 v2(6.72,58.86) 6.78,58.92 JUSBC2.A9 8.29,58.92 v2(8.35,58.87) ; v2(9.15,61.56) v2(9.79,61.56) ; JUSBC2.B9 6.54,61.68 v2(6.68,61.82) 6.78,61.82 7.18,61.42 JUSBC2.A4 8.2,61.42 8.34,61.57 v2(8.39,61.57)
  TOP w0.279: v2(9.15,61.56) 9.15,61.57 v2(8.39,61.57)
  TOP w0.381: RU24.1 v2(295.27,64.26)
  IN2 w0.381: v2(295.27,64.26) 295.83,63.7 295.83,59.42 298.78,56.48 298.78,39.58 296.83,37.64 292.21,37.64 290.46,35.88 283.49,35.88 281.84,37.54 276.99,37.54 268.99,45.54 256.46,45.54 251.91,50.08 241.07,50.08 240.95,49.97 234.22,49.97 233.93,49.68 230.5,49.68 230.22,49.97 212.11,49.97 206.61,55.47 203.7,55.47 200.1,59.07 196.18,59.07 191.62,54.52 183.59,54.52 182.51,55.61 182.51,58.52 177.57,63.46 111.2,63.46 107.25,67.41 104.36,67.41 102.7,65.74 102.7,62.48 94.06,53.84 91.4,53.84 90.83,53.27 90.83,51.42 89.79,50.38 83.48,50.38 82.34,49.23 67.33,49.23 66.61,49.95 57.93,49.95 57.46,49.48 47.37,49.48 45.96,50.9 42.78,50.9 41.38,52.29 34.58,52.29 32.65,50.37 26.48,50.37 22.59,54.26 12.51,54.26 12.43,54.18
  vias: v2(11.06,54.55) v2(11.06,53.91) v2(11.06,53.33) v2(11.7,54.55) v2(11.7,53.91)
+5VA: length 6.7
  TOP w0.203: v2(28.47,37.11) 27.76,37.11 v1(27.5,37.37)
  TOP w0.508: RA8.1 28.79,36.79 v2(28.47,37.11)
  BOTTOM w0.203: 29.55,35.46 30.42,34.59 UA1.45
  BOTTOM w0.508: v2(28.47,37.11) 28.6,37.11 CA14.1 28.74,36.11 CA15.1 29.55,35.46
+5VALW: length 493.8
  TOP w0.254: PU300.7 246.71,17.49 247.72,16.48 PC308.1 ; v2(182.95,77.87) 183.2,77.87 183.82,77.25 C2520.1
  TOP w0.305: U19.3 178.63,77.87 v2(178.49,77.73) ; v2(182.95,77.87) 182.95,77.87 U20.3
  TOP w0.356: v2(226.58,32.29) 226.67,32.2 RE529.1 ; RE525.1 226.81,22.49 226.13,21.81 v2(226.13,21.62) ; RE521.1 227.15,29.05 226.7,29.5 v2(226.7,29.53) ; v2(226.51,26.37) 226.59,26.37 227.15,25.81 RE449.1
  TOP w0.381: v2(226.51,26.37) 226.26,26.37 225.94,26.06 QE54.1 ; v2(224.2,25.32) 223.99,25.53 RE517.1
  TOP w0.432: QE55.1 225.94,29.1 226.37,29.53 v2(226.7,29.53) ; v2(224.2,25.32) 224.64,24.88 QE54.4 ; v2(226.58,32.29) 226.43,32.44 224.82,32.44 QE56.1
  TOP w0.508: v2(62.97,15.03) 62.97,9.76 v4(64.26,8.48) 65.48,7.25 PR14.2 ; RE158.1 v2(204.99,175.23) ; 188.72,109.07 188.48,109.32 RG509.1 ; 188.72,109.07 RG511.1 188.72,107.84 188.29,107.41 188.29,106.24 v2(188.26,106.21) ; 188.72,109.07 190.38,109.07 191.27,108.19 RG513.1 ; RE161.2 CE81.1 153.36,162.91 v2(152.98,162.53) ; JWDB.1 205.49,9.94 v2(205.11,9.57) ; v2(178.49,77.73) 178.16,77.73 C2521.1 ; CG384.1 194.37,103.79 v2(193.99,103.41) ; v2(198.66,170.4) 198.41,170.66 RE156.1 ; RE154.1 201.3,175.19 v2(201.24,175.25) ; CU46.1 315.31,23.5 CU48.1 316.57,23.5 317.31,22.77 317.57,22.77 ; PC308.1 247.85,15.93 v2(247.98,15.81) ; PR8.1 v2(314.78,52.1)
  IN1 w0.508: v2(305.67,51.43) 305.95,51.43 306.27,51.75 309.5,51.75 309.83,51.42 314.09,51.42 v2(314.78,52.1)
  IN2 w0.508: v2(208.54,146.72) 207.12,146.72 204.97,144.57 204.97,131.15 203.86,130.03 201.97,130.03 201.35,129.41 199.2,129.41 198.69,128.9 198.69,128.47 197.48,127.26 194.74,127.26 193.68,126.2 193.68,124.82 189.58,120.73 189.58,110.82 188.29,109.52 188.29,106.24 v2(188.26,106.21) 188.53,106.21 189.11,105.63 ; v2(92.85,40.1) 92.85,39.85 93.35,39.34 95.77,39.34 96.21,39.78 v2(96.21,40.1) ; v2(221.46,165.12) 221.46,165.25 220.93,165.78 212.68,165.78 210.02,168.45 210.02,168.92 207.67,171.27 207.67,172.55 v2(204.99,175.23) ; v2(193.99,103.41) 193.99,103.62 192.25,105.37 189.38,105.37 189.11,105.63 ; 189.11,105.63 189.11,104.27 186,101.16 186,94.48 187.91,92.57 187.91,82.82 v2(182.95,77.87) ; v2(290.6,82.06) 290.6,80.58 292.48,78.7 292.48,72.22 296.54,68.15 296.54,59.52 299.17,56.89 304.2,56.89 305.3,55.79 305.3,51.8 v2(305.67,51.43)
  IN3 w0.508: v2(92.85,40.1) 91.26,40.1 89.32,42.04 89.32,45.65 90.88,47.21 93.04,47.21 95.07,49.24 96.71,49.24 98.25,50.78 99.45,50.78 101.19,52.52 101.19,55.04 101.9,55.75 v2(101.9,56.66) 101.9,57.76 103.32,59.18 103.32,62 v2(105.94,64.62) ; v2(314.78,52.1) 320.07,46.81 332.04,46.81 332.28,46.56 332.28,45.85 331.67,45.24 331.67,43.31 331.9,43.09 331.9,42.23 331.6,41.94 331.6,41.22 332.72,40.1 332.72,34.44 331.81,33.52 330.22,33.52 329.61,32.91 329.61,31.21 329.41,31.01 329.41,24.95 325.59,21.13 325.59,14.65 325.01,14.08 323.11,14.08 320.49,11.46 v2(320.49,10.07)
  IN4 w0.508: v2(96.21,40.1) 98.05,40.1 99.64,38.51 99.64,35.56 101.36,33.84 101.36,30.27 97.99,26.89 97.99,24.71 95.29,22 85.29,22 76.97,13.68 66.94,13.68 v2(64.4,16.22) ; v2(245.4,14.21) 244.74,14.87 241.02,14.87 239.47,16.42 236.04,16.42 234.9,15.27 230.83,15.27 226.01,20.1 226.01,21.5 v2(226.13,21.62)
  IN6 w0.508: v2(203.9,160.03) 203.17,160.75 203.17,162.73 202.45,163.45 v2(202.17,163.45)
  BOTTOM w0.203: v2(64.4,16.22) 64.69,15.93 U17.4 ; UT4.H10 202.28,163.57 v2(202.17,163.45)
  BOTTOM w0.254: UZ21.4 127.6,97.71 127.35,97.45 C2519.1
  BOTTOM w0.305: UG14.3 v2(193.99,103.41) ; v2(266.44,19.87) 266.12,19.55 U16.3
  BOTTOM w0.406: v2(223.88,9.62) 223.47,9.21 JKB.1
  BOTTOM w0.508: C2519.1 119.97,97.45 117.67,95.16 117.67,81.44 108.91,72.68 108.91,66.82 108.16,66.07 ; v2(254.07,22.45) 253.31,22.45 249.94,25.81 249.94,29.88 250.45,30.39 250.45,31.97 249.37,33.06 PR8200.2 ; RG543.1 v2(290.6,82.06) 290.6,82.79 RG541.1 ; v2(144.85,162.59) 146.44,162.59 146.63,162.4 147.77,162.4 148.36,162.99 RM91.1 RM92.1 ; v2(182.95,77.87) 182.11,78.71 179.47,78.71 v2(178.49,77.73) ; C2516.1 266.44,19.14 v2(266.44,19.87) ; RM94.1 RM93.1 152.74,162.77 v2(152.98,162.53) ; PR204.1 92.27,39.47 92.85,40.04 v2(92.85,40.1) ; v2(208.54,146.72) 208.41,146.85 208.41,152.63 208.24,152.8 208.24,154.39 ; CE61.1 220.81,165.77 v2(221.46,165.12) ; PR203.1 v2(96.21,40.1)
  vias: v2(20.56,40.9) v2(20.56,40.27) v2(21.26,40.9) v2(21.26,40.27) v2(24.5,49.45) v2(24.5,48.81) v2(24.5,48.18) v2(25.13,49.45) v2(25.13,48.81) v2(25.13,48.18) v2(39.32,44.74) v2(39.44,45.37) v2(39.95,44.74) v2(40.08,45.37) v2(40.36,44.18) v2(40.59,44.74) v2(40.78,45.37) v2(40.97,44.18) v2(41.22,44.74) v2(41.41,45.37) v2(41.6,44.18) v2(41.86,44.74) v2(42.05,45.37) v2(42.24,44.23) v2(42.55,44.8) v2(42.68,45.37) v2(42.87,44.23) v2(43.81,45.45) v2(44.42,45.45) v2(45.06,45.45) v2(45.69,45.45) v2(46.33,45.45) v2(61.73,16.92) v2(61.7,16.3) v2(61.7,15.66) v2(61.7,15.03) v2(62.37,16.92) v2(62.34,16.3) v2(62.34,15.66) v2(62.34,15.03) v2(62.97,16.3) v2(62.97,15.66) v2(105.94,66.59) v2(105.94,65.96) v2(105.94,65.3) v2(106.57,66.59) v2(106.57,65.96) v2(106.57,65.3) v2(106.57,64.62) v2(118.95,147.25) v2(118.95,146.67) v2(118.95,146.06) v2(119.58,147.25) v2(119.58,146.67) v2(119.58,146.06) v2(142.76,165.64) v2(142.68,163.91) v2(143.26,163.91) v2(143.46,165.7) v2(143.58,162.59) v2(143.85,163.91) v2(144.22,162.59) v2(147.46,179.55) v2(147.46,178.91) v2(148.09,179.55) v2(148.09,178.91) v2(148.73,179.55) v2(148.73,178.91) v2(149.34,179.52) v2(149.34,178.89) v2(172.42,178.12) v2(172.42,177.54) v2(173.01,178.12) v2(173.01,177.54) v2(207.65,156.32) v2(207.65,155.73) v2(207.65,155.15) v2(207.65,154.57) v2(208.24,156.9) v2(208.24,156.32) v2(208.24,155.73) v2(208.24,155.15) v2(223.59,26.51) v2(318.56,22.8) v2(318.56,22.22) v2(318.56,21.63) v2(318.56,21) v2(319.99,9.43) v2(320.62,9.43) v2(321.26,9.43) v4(39.14,47.21) v4(208.82,154.71)
+5VALW_LED: length 10.6
  TOP w0.508: JPWR.1 210.32,167.1 209.81,167.61 208.61,167.61 208.02,167.02 208.02,164 v1(208.82,163.2) 208.83,163.19 208.83,161.04 QE8.1
+5VALWP: length 23.8
  TOP w0.508: v2(53.46,43.28) 53.46,43.8 52.52,44.74 50.17,44.74 47.95,42.51 46.11,42.51
  BOTTOM w0.203: v2(53.46,43.28) PU100.14
  BOTTOM w0.254: PR102.2 49.4,49.42 46.81,46.83 37.85,46.83 37.41,46.39
  vias: v1(38.08,40.42) v2(39.12,42.01) v2(39.44,42.51) v2(39.38,41.43) v2(39.76,42.01) v2(39.7,40.93) v2(40.01,41.43) v2(40.14,42.51) v2(40.33,40.93) v2(40.46,42.01) v2(40.65,41.43) v2(40.78,42.51) v2(40.97,40.93) v2(41.09,42.01) v2(41.28,41.43) v2(41.41,42.51) v2(41.66,40.93) v2(41.73,42.01) v2(42.05,42.51) v2(41.98,41.43) v2(42.36,42.01) v2(42.62,41.43) v2(42.74,42.51)
+5VS: length 862.7
  TOP w0.356: v2(239.78,159.54) 240.13,159.89 CV23.1
  TOP w0.381: UV22.16 199.57,9.38 v2(199.02,9.94) ; PR599.2 157.3,143.19 PR5028.1 157.14,142.19 v2(156.45,142.19) ; PR5026.1 182,143.73 181.75,143.99 181.75,146.72 ; v2(188.73,64.21) 188.91,64.03 RS1.1
  TOP w0.457: v2(226.72,152.1) 226.72,151.95 PC6201.1
  TOP w0.508: v2(183.21,100.62) 183.43,100.62 183.82,101 183.82,109.77 187.14,113.09 188.87,113.09 190.69,114.92 193.6,114.92 193.79,115.11 195.81,115.11 196.55,114.36 v2(196.55,113.85) ; 174.26,147.21 174.26,146.49 173.3,145.53 173.3,143.61 173.63,143.27 PR5019.2 174.27,143.27 174.87,142.67 PR5030.1 ; 174.26,147.21 175.54,147.21 176.05,147.72 v2(176.05,147.94) 180.52,147.94 v2(181.68,146.78) 182.19,146.27 187.08,146.27 193.3,140.05 195.4,140.05 197.68,142.34 201.68,142.34 209.59,150.24 v2(210.55,150.24) ; 174.26,147.21 173.55,147.92 v2(167.7,147.92) 167.45,147.92 166.45,146.92 ; PR6400.1 308.4,47.06 310.7,49.36 310.7,49.95 311.44,50.69 311.44,51.61 312.66,52.83 v2(312.9,52.83) ; RA8.2 30.56,37.32 30.72,37.47 v2(30.72,38.16) 30.04,38.83 RA3.2 ; 148.98,149.78 148.98,146.97 149.39,146.56 PR5023.2 149.9,146.56 150.55,145.91 PR5032.1 ; 148.98,149.78 150.24,149.78 v2(151.69,151.23) 156.23,151.23 158.73,148.72 v2(158.73,148.34) 160.03,147.05 164.04,147.05 164.62,147.62 165.75,147.62 166.45,146.92 ; 148.98,149.78 148.68,150.08 146.63,150.08 145.5,151.21 v2(143.36,151.21) 142.74,150.59 142.38,150.59 141.87,150.08 141.87,149.64 141.23,149 140.34,149 139.9,148.56 139.9,147.95 140.47,147.38 140.47,147.16 141.1,146.53 PR5021.2 141.67,146.53 142.22,145.99 PR5031.1 ; v2(121.13,134.21) 120.4,134.94 120.4,136.45 120.76,136.81 121.85,136.81 122.4,137.36 124.43,137.36 124.94,136.85 124.94,136.4 125.76,135.58 126.08,135.58 126.37,135.29 PR505.1 ; v2(129.12,152.38) 128.28,153.21 128.28,153.57 126.62,155.23 CV484.1 ; PR5029.1 165.9,141.92 PR5011.2 165.9,143.39 164.98,144.31 164.98,145.45 166.45,146.92 ; v2(236.66,159.17) 237.62,159.17 237.99,159.54 v2(239.78,159.54) ; PR6202.2 226.17,150.51 226.54,150.88 226.69,150.88 PC6201.1 ; PR6104.2 253.87,150.68 254.15,150.96 254.44,150.96 PC6101.1 254.92,151.52 254.45,151.99 254.45,152.23 v2(254.44,152.24) 254.44,152.38 253.92,152.91 252.26,152.91 251.9,152.55 v2(251.9,151.81) 251.7,151.61 PR6106.1 ; PR6111.2 239.91,150.86 240.48,150.86 PC6114.1 240.43,152 240.43,152.86 240.07,153.22 238.74,153.22 238.07,152.56 v2(238.07,151.75) 237.87,151.54 PR6113.1
  TOP w1.016: 92.2,9.23 94.62,11.65 104.89,11.65 110.58,5.96 131.25,5.96 ; 161.51,4.78 171.46,4.78 173.51,6.83 173.51,13.64 176.12,16.25 182.54,16.25 187.52,11.27 192.73,11.27 192.92,11.46 ; 131.39,10.76 131.39,15.91 126.95,20.35 108.09,20.35
  IN1 w0.508: v2(224.41,151.68) 224.8,151.29 226.11,151.29 226.72,151.9 ; 226.72,151.9 v2(226.72,152.1) ; 226.72,151.9 226.72,151.85 227.8,150.77 232.48,150.77 233.46,151.75 v2(238.07,151.75) 238.6,151.21 247.79,151.21 248.38,151.81 v2(251.9,151.81) ; v2(283.96,137.07) 284.62,137.73 284.62,143.73 281.47,146.88 272.23,146.88 271.73,146.37 267.64,146.37 265.02,149 265.02,149.8 263.46,151.35 255.09,151.35 254.45,151.99 254.45,152.23 v2(254.44,152.24) ; v2(34.74,51.15) 34.74,50.25 30.93,46.44 30.93,38.37 v2(30.72,38.16) ; v2(315.24,55.53) 314.52,54.82 314.52,53.33 314.02,52.83 v2(312.9,52.83) ; 223.85,151.29 223.33,150.77 213.8,150.77 213,151.57 v2(213,152.1)
  IN1 w1.016: 299.35,63.41 299.35,66.64 292.87,73.12 292.87,75.39 292.55,75.39 ; 223.29,152.55 222.87,152.97 222.87,153.65 222.58,153.94 222.58,157.47 223.07,157.97 223.07,157.98 223.24,158.15 223.24,159.24 223.07,159.4 223.07,160.74 223.24,160.9 223.24,164.98 222.38,165.84 222.38,167.71 223.39,168.73 223.85,168.73
  IN2 w0.508: v2(196.55,113.85) 196.5,113.9 196.5,114.03 195.96,114.58 195.96,116.13 194.54,117.55 192.93,117.55 192.43,118.04 191.22,118.04 190.42,118.83 190.42,120.67 193.43,123.68 196.16,123.68 196.92,122.92 197.44,122.92 197.8,123.27 197.8,126.68 198.8,127.69 204.13,127.69 205.61,129.16 205.61,139.66 210.96,145.01 210.96,147.67 210.65,147.99 210.1,147.99 209.76,148.33 209.76,149.45 v2(210.55,150.24)
  IN3 w0.457: v2(181.51,69.69) 180.54,68.72
  IN3 w0.508: v2(199.02,9.94) 199.02,10 197.62,11.4 194.26,11.4 v2(193.49,12.16) ; v2(121.13,134.21) 120.09,135.25 120.09,140.68 120.61,141.2 120.61,143.51 121.36,144.26 121.36,145.4 121.8,145.84 123.16,145.84 124.98,147.66 124.98,148.51 126.25,149.78 126.25,150.28 127.02,151.05 128.61,151.05 129.12,151.56 v2(129.12,152.38) 142.43,152.38 143.36,151.45 v2(143.36,151.21) ; 180.54,68.72 180.54,58.58 181.68,57.44 181.68,54.35 183.51,52.51 183.51,32.93 176.87,26.29 174.6,26.29 173.96,26.93 169.72,26.93 169.43,26.64 163.84,26.64 v2(162.7,25.5)
  IN3 w1.524: 283.79,19.84 283.79,17.75 282.36,16.31 282.36,8.96 283.03,8.29 283.03,6.7
  IN4 w1.016: 108.09,59.47 108.87,58.68 108.87,49.4 104.81,45.33 104.81,31.65 108.09,28.38 108.09,26.07
  IN6 w0.254: v2(158.73,148.34) 158.73,147.3 158,146.56 158,144.37 157.49,143.86 157.49,142.72 156.96,142.19 v2(156.45,142.19)
  IN6 w0.508: v2(181.51,69.69) 181.49,69.68 181.49,65.9 182.79,64.6 187.51,64.6 187.9,64.21 v2(188.73,64.21) ; v2(210.55,150.24) 211.48,151.16 212.05,151.16 v2(213,152.1) ; v2(291.55,75.83) 291.55,79.65 285.9,85.3 285.9,117.18 283.96,119.12 v2(283.96,133.38)
  BOTTOM w0.203: UG12.4 196.66,113.25 196.55,113.35 v2(196.55,113.85)
  BOTTOM w0.305: PC6214.1 213,152.74 v2(213,152.1) 213.06,152.03 PU6201.3 ; PU6100.3 254.21,152.01 v2(254.44,152.24) ; PU6200.3 v2(226.72,152.1) ; PU6101.3 240.43,152.17
  BOTTOM w0.381: UV3.16 v2(236.66,159.17)
  BOTTOM w0.508: v2(162.7,25.5) 162.7,9.3 ; PR5004.2 v2(167.7,147.92) ; PR6051.2 283.35,135.23 284.59,135.23 ; JKB3.5 62.93,6.14 62.43,6.64 JKB3.6 62.43,9.31 62.18,9.56 ; 284.59,135.23 284.59,133.89 284.08,133.38 v2(283.96,133.38) PR6052.2 283.35,131.67 282.27,130.59 PR6050.2 PR6046.2 278.44,130.59 PR6048.2 277.82,130.59 277.31,131.1 PR6035.1 ; 284.59,135.23 284.59,136.45 283.97,137.07 v2(283.96,137.07) PR6047.2 ; 240.43,152.17 240.43,153.25 239.76,153.92 ; v2(188.73,64.21) 189.9,65.38 189.9,65.88 189.71,66.07 189.71,66.58 189.9,66.77 189.9,68.23 189.26,68.87 189.26,82.37 189.9,83.01 189.9,98.7 187.98,100.62 v2(183.21,100.62) ; PR6201.2 223.14,152.19 v2(222.89,151.95) 222.89,150.78 223.27,150.4 PR6204.1 ; PR5025.2 182.38,146.21 181.81,146.78 v2(181.68,146.78) ; PR6200.2 224.53,151.81 v2(224.41,151.68) ; PR5022.2 v2(143.36,151.21) ; PC6214.1 211.83,153.91 PR6209.2 211.21,153.91 210.95,153.64 210.34,153.64 209.86,153.17 PR6207.2 209.1,151.8 PR6208.2 209.1,151.11 PR6211.1 ; 239.76,153.92 237.72,153.92 237.36,153.56 PR6109.2 237.36,151.76 PR6110.2 v2(238.07,151.75) ; 239.76,153.92 239.76,159.51 v2(239.78,159.54) ; PR5020.2 v2(176.05,147.94) ; CG386.1 196.74,114.04 v2(196.55,113.85) ; v2(251.9,151.81) PR6103.2 251.14,151.82 PR6102.2 ; PR5024.2 v2(151.69,151.23) ; v2(158.73,148.34) 159.16,147.92 PR553.2
  vias: v2(35.38,51.15) v2(44.27,49.37) v2(44.27,48.74) v2(59.14,9.18) v2(59.27,10.25) v2(59.52,9.68) v2(59.84,9.18) v2(59.9,10.25) v2(60.22,9.75) v2(60.54,10.25) v2(60.47,9.18) v2(60.85,9.75) v2(61.11,9.18) v2(61.17,10.25) v2(61.49,9.75) v2(90.98,7.85) v2(90.98,7.22) v2(91.61,7.85) v2(91.61,7.22) v2(92.25,7.85) v2(92.25,7.22) v2(92.85,7.84) v2(92.88,7.22) v2(93.48,7.84) v2(93.48,7.21) v2(94.12,7.84) v2(94.12,7.21) v2(106.24,61.12) v2(106.24,60.23) v2(106.94,21.94) v2(107.2,21.21) v2(131.36,7.53) v2(132,7.53) v2(132.63,7.53) v2(133.27,7.53) v2(133.9,7.53) v2(157.36,9.3) v2(157.36,8.67) v2(158,9.3) v2(158,8.67) v2(224.75,168.54) v2(225.43,168.52) v2(282.01,5.47) v2(282.6,5.47) v2(283.22,5.49) v2(283.73,22.77) v2(283.73,22.13) v2(283.73,21.5) v2(291.55,75.19) v2(307.34,59.98) v2(307.97,59.98) v4(152.69,9.89)
+5VS_TP_LED: length 113.1
  TOP w0.508: R147.1 v2(110.04,25.69) ; R146.1 v2(112.49,23.55) ; Q2409.4 192.36,14.78 192.12,15.02 C2508.1 v4(189.9,15.02) 189.26,15.02 188.41,14.18 v2(188.41,12.29) ; R154.1 v2(117.74,23.17) ; R150.1 115.57,24.11 v2(115.13,23.68) 115.13,22.05 114.56,21.48 111.98,21.48 R144.1 R145.1
  IN1 w0.508: v2(110.04,25.69) 110.04,24.19 110.68,23.55 v2(112.49,23.55) 112.87,23.93 114.88,23.93 v2(115.13,23.68) 115.64,23.17 v2(117.74,23.17) 117.74,23.53 118.44,24.23 175.04,24.23 186.98,12.29 v2(188.41,12.29)
  IN3 w0.508: v2(196.8,9.94) 196.16,10.57 193.75,10.57 192.77,11.55 189.15,11.55 v2(188.41,12.29)
+AVDDH: length 16.9
  TOP w0.203: v2(275.95,159.47) 276.65,159.47 v1(276.77,159.35)
  TOP w0.508: CL5.1 CL6.1 275.44,159.47 v2(275.95,159.47)
  IN6 w0.508: v2(267.04,159.03) 267.44,158.63 274.86,158.63 275.7,159.47 v2(275.95,159.47)
  BOTTOM w0.203: UL1.22 268.85,160.24 268.27,159.66 CL7.1 ; UL1.9 275.49,160.24 275.96,159.76 275.96,159.48 v2(275.95,159.47)
  BOTTOM w0.508: CL7.1 267.38,159.38 v2(267.04,159.03)
+AVDDL: length 10.9
  TOP w0.203: v1(277.05,161.42) 276.91,161.28 276,161.28 v2(275.98,161.31)
  TOP w0.508: v2(275.98,161.31) 275.94,161.35 CL18.1 CL19.1 ; CL24.1 273.43,157.08 v2(273.4,157.05) ; CL25.1 271.02,157.79 v2(271,157.82)
  BOTTOM w0.203: UL1.31 v2(270.6,165.22) ; v2(275.98,161.31) 275.97,161.32 275.68,161.32 275.56,161.44 UL1.6 ; v2(271.71,165.26) 271.71,165.04 271.8,164.96 UL1.34 ; UL1.19 v2(271,157.82) ; v2(273.4,157.05) UL1.13
+DVDDL: length 3.7
  TOP w0.508: CL44.1 CL43.1 273.38,165.29 v2(273.36,165.3)
  BOTTOM w0.102: v2(273.36,165.3) 273.36,165.37 v1(273.87,165.88)
  BOTTOM w0.203: v2(273.36,165.3) 273.36,165.11 273,164.74 UL1.37
+PVDD: length 11.6
  TOP w0.203: CA54.1 37.99,4.97 ; v4(40.26,6.48) 39.71,7.03 v2(39.57,7.03) ; v2(33.04,5.02) 33.45,5.43 UA4.48 ; UA4.37 30.04,9.21 29.6,9.66 ; v2(34.86,5.05) 34.65,5.25 UA4.51
  TOP w0.381: 29.6,9.66 29.61,9.67 29.61,10.06
  TOP w0.508: CA54.1 38.3,5.11 v2(38.3,5.62) ; v2(27.06,10.38) 27.1,10.34 CA62.1 CA63.1 29.33,10.34 29.61,10.06
  BOTTOM w0.508: CA52.1 38.3,6.76 38.57,7.03 v2(39.57,7.03) ; CA61.1 28.14,10.38 v2(27.06,10.38)
  vias: v2(28.58,4.03) v2(29.22,4.03) v2(31,5.56)
+VCC_CORE: length 30.2
  TOP w0.254: v2(168.66,134.46) 168.2,134.46 PR569.2 167.11,133.37 PR571.1 PR570.1 ; PR581.1 PR580.1 176.05,134.16 PR579.2 176.84,134.16 v2(177.02,134.34) ; v2(160.28,134.21) 160.23,134.16 PR559.2 PR560.1 158.67,133.25 PR561.1
  BOTTOM w0.203: CPU1.AD13 156.7,101.4 v2(157.03,101.72) 156.7,102.05 CPU1.AD14 ; CPU1.P13 163.79,101.4 v2(163.47,101.72) ; CPU1.AE14 155.83,102.05 v2(156.17,101.71) 155.86,101.4 CPU1.AE13 ; v2(157.98,101.72) 157.65,101.4 CPU1.AC13 ; v2(157.98,101.72) 158.3,101.4 CPU1.AA13 ; v2(157.98,101.72) 157.65,102.05 CPU1.AC14 ; CPU1.L14 166.57,102.05 v2(166.25,101.73) ; v2(167.22,101.51) 167.33,101.62 CPU1.K14 ; v2(167.22,101.51) 167.1,101.4 CPU1.L13 ; v2(167.22,101.51) 167.27,101.46 CPU1.K13 ; v2(161.66,102.38) 161.32,102.05 CPU1.V14 CPU1.V13 ; v2(163.47,101.72) 163.79,102.05 CPU1.P14 ; v2(163.47,101.72) 163.14,101.4 CPU1.R13 ; CPU1.N14 164.7,102.05 v2(164.36,101.71) 164.67,101.4 CPU1.N13 ; v2(159.83,102.38) 160.16,102.05 CPU1.W14 CPU1.W13
  BOTTOM w0.254: v2(160.28,134.21) 161.63,135.57 PL501.1 ; v2(168.66,134.46) 168.12,134.46 167.14,135.44 PL502.1 ; v2(164.47,120.55) 164.54,120.55 CPU1.N38 ; PL503.1 v2(177.02,134.34)
  vias: v2(154.77,113.76) v2(155.03,119.89) v2(155.03,118.58) v2(155.06,116.01) v2(155.02,108.49) v2(155.02,103.66) v2(155.21,121.12) v2(155.21,107.34) v2(155.21,106.14) v2(155.4,113.76) v2(155.4,110.39) v2(155.52,121.68) v2(155.65,108.49) v2(155.65,103.66) v2(155.85,121.12) v2(155.81,120.54) v2(155.81,119.23) v2(155.81,117.93) v2(156.15,121.68) v2(156.42,110.39) v2(156.47,130.97) v2(156.48,121.12) v2(156.6,119.89) v2(156.6,118.58) v2(156.6,117.28) v2(156.6,115.98) v2(156.79,122.89) v2(156.79,121.68) v2(157.04,132.18) v2(157.04,131.41) v2(156.98,130.65) v2(157.12,123.41) v2(157.12,122.33) v2(157.12,121.12) v2(157.18,113.76) v2(157.42,122.89) v2(157.42,121.68) v2(157.39,117.93) v2(157.39,116.63) v2(157.39,115.34) v2(157.43,108.49) v2(157.43,103.66) v2(157.55,131.79) v2(157.55,131.03) v2(157.56,107.34) v2(157.56,106.14) v2(157.75,123.41) v2(157.75,122.33) v2(157.75,121.12) v2(157.81,113.76) v2(158.06,122.89) v2(158.06,121.68) v2(158.07,108.49) v2(158.07,103.66) v2(158.18,119.89) v2(158.18,118.58) v2(158.18,115.98) v2(158.39,123.41) v2(158.39,122.33) v2(158.39,121.12) v2(158.69,122.89) v2(158.69,121.68) v2(158.96,120.54) v2(158.96,119.23) v2(158.96,117.93) v2(158.96,116.63) v2(159.02,123.41) v2(159.02,122.33) v2(159.02,121.12) v2(159.15,110.39) v2(159.33,122.89) v2(159.33,121.68) v2(159.66,123.41) v2(159.66,122.33) v2(159.66,121.12) v2(159.59,113.76) v2(159.75,118.58) v2(159.76,117.27) v2(159.75,115.98) v2(159.73,115.34) v2(159.85,108.49) v2(159.85,103.66) v2(159.96,122.89) v2(159.96,121.68) v2(159.91,107.34) v2(159.91,106.14) v2(160.16,110.39) v2(160.23,113.76) v2(160.29,123.41) v2(160.29,122.33) v2(160.29,121.12) v2(160.54,120.54) v2(160.54,119.23) v2(160.54,117.93) v2(160.48,108.49) v2(160.48,103.66) v2(160.6,122.89) v2(160.6,121.68) v2(160.93,123.41) v2(160.93,122.33) v2(160.93,121.12) v2(161.23,122.89) v2(161.23,121.68) v2(161.32,120.54) v2(161.32,119.89) v2(161.32,118.58) v2(161.32,117.28) v2(161.32,115.98) v2(161.56,123.41) v2(161.56,122.33) v2(161.56,121.12) v2(161.87,122.89) v2(161.87,121.68) v2(161.87,132.18) v2(161.87,131.54) v2(161.87,130.91) v2(161.87,130.27) v2(162,113.76) v2(162.13,123.54) v2(162.11,119.23) v2(162.11,117.93) v2(162.11,116.63) v2(162.11,115.34) v2(162.25,122.27) v2(162.2,121.12) v2(162.26,108.49) v2(162.26,107.34) v2(162.26,106.14) v2(162.23,103.66) v2(162.44,123.01) v2(162.51,132.18) v2(162.51,131.54) v2(162.51,130.91) v2(162.51,130.27) v2(162.5,121.68) v2(162.55,102.4) v2(162.64,113.76) v2(162.64,110.39) v2(162.83,121.12) v2(162.87,103.66) v2(162.89,122.58) v2(162.9,120.54) v2(162.9,119.89) v2(162.9,118.58) v2(162.9,115.98) v2(162.89,108.49) v2(163.2,122.06) v2(163.39,121) v2(163.45,102.39) v2(163.65,121.63) v2(163.66,118.6) v2(163.69,119.23) v2(163.69,117.93) v2(163.68,117.26) v2(163.69,116.63) v2(163.7,115.96) v2(164.03,121) v2(164.22,121.57) v2(164.46,116.64) v2(164.49,119.24) v2(164.47,118.58) v2(164.5,115.98) v2(164.61,103.66) v2(165.11,132.24) v2(165.11,131.6) v2(165.11,130.97) v2(165.11,130.33) v2(165.24,103.66) v2(165.74,132.24) v2(165.74,131.6) v2(165.74,130.97) v2(165.74,130.33) v2(165.81,104.49) v2(165.94,105.88) v2(168.41,129.64) v2(168.41,129) v2(169.05,129.64) v2(169.05,129) v2(169.68,129.64) v2(169.68,129) v2(170.32,129.64) v2(170.32,129) v2(170.95,129.64) v2(170.95,129) v2(171.59,129.64) v2(171.59,129) v2(172.85,129.58) v2(172.87,128.94) v2(172.87,128.31) v2(172.87,127.67) v2(172.87,127.04) v2(173.43,129.27) v2(173.43,128.63) v2(173.43,128) v2(173.43,127.36) v2(174.02,129.58) v2(174.02,128.94) v2(174.02,128.31) v2(174.02,127.67) v2(174.82,125.98) v2(178.95,127.6) v4(177.9,131.72)
+VCCGT: length 11.2
  TOP w0.254: PR598.1 151.38,137.49 PR597.2 151.98,137.49 v2(152.15,137.32) ; v2(143.96,137.58) 143.89,137.5 PR588.2 143.27,137.5 PR589.1
  BOTTOM w0.254: v2(143.96,137.58) 143.57,137.18 PL505.1 ; v2(152.15,137.32) 150.69,135.87 PL506.1
  BOTTOM w0.508: v2(151.38,121.86) 151.4,121.88 RH203.1
  vias: v2(133.42,123.97) v2(133.42,123.38) v2(133.71,122.84) v2(133.82,118.74) v2(133.9,122.13) v2(134,123.97) v2(134,123.38) v2(134.29,122.84) v2(134.48,122.13) v2(134.59,123.97) v2(134.59,123.38) v2(134.88,122.84) v2(135.07,122.13) v2(135.17,123.97) v2(135.17,123.38) v2(135.46,122.84) v2(135.65,122.13) v2(135.75,123.97) v2(135.75,123.38) v2(136.05,122.84) v2(136.24,122.13) v2(136.39,121.57) v2(136.67,124.03) v2(136.67,123.45) v2(136.96,122.9) v2(136.92,120.56) v2(137.03,121.57) v2(137.15,122.19) v2(137.25,124.03) v2(137.25,123.45) v2(137.36,121) v2(137.54,122.9) v2(137.66,121.57) v2(137.61,106.34) v2(137.73,122.19) v2(137.7,119.89) v2(137.7,118.58) v2(137.7,117.93) v2(137.7,115.98) v2(137.84,124.03) v2(137.84,123.45) v2(138.13,122.9) v2(138.32,122.19) v2(138.3,121.57) v2(138.42,124.03) v2(138.42,123.45) v2(138.49,117.93) v2(138.49,116.63) v2(138.49,115.34) v2(138.49,113.34) v2(138.71,122.9) v2(138.76,109.82) v2(138.9,122.19) v2(138.93,121.57) v2(139,124.03) v2(139,123.45) v2(139.14,107.73) v2(139.14,104) v2(139.3,122.9) v2(139.28,119.89) v2(139.28,118.58) v2(139.28,115.98) v2(139.49,122.19) v2(139.57,121.57) v2(139.69,102.37) v2(139.84,104) v2(140.06,120.54) v2(140.06,119.23) v2(140.06,117.93) v2(140.06,116.63) v2(140.07,121.12) v2(140.16,106.01) v2(140.16,104.74) v2(140.27,113.34) v2(140.39,121.63) v2(140.61,101.72) v2(140.71,121.12) v2(140.85,118.58) v2(140.85,117.28) v2(140.85,115.98) v2(140.85,115.34) v2(140.95,113.32) v2(141.03,121.63) v2(141.05,109.82) v2(141.34,121.12) v2(141.49,107.73) v2(141.52,102.36) v2(141.66,121.63) v2(141.64,120.54) v2(141.64,119.23) v2(141.62,104) v2(141.98,121.12) v2(142.26,104) v2(142.3,121.63) v2(142.43,119.89) v2(142.43,118.58) v2(142.43,117.28) v2(142.43,115.98) v2(142.45,106.07) v2(142.45,104.8) v2(142.4,102.38) v2(142.42,101.77) v2(142.61,121.12) v2(142.77,113.34) v2(142.93,121.63) v2(143.08,122.24) v2(143.25,121.12) v2(143.21,117.93) v2(143.21,116.63) v2(143.21,115.34) v2(143.42,113.35) v2(143.4,109.82) v2(143.57,121.63) v2(143.67,122.24) v2(143.78,107.73) v2(143.88,121.12) v2(144,119.89) v2(144,118.58) v2(144,115.98) v2(144.03,104) v2(144.25,122.24) v2(144.2,121.63) v2(144.52,121.12) v2(144.67,106.07) v2(144.67,104.8) v2(144.83,122.24) v2(144.84,121.63) v2(144.79,120.54) v2(144.79,119.23) v2(144.79,117.93) v2(144.79,116.63) v2(144.86,104) v2(145.15,121.12) v2(145.23,113.35) v2(145.18,102.37) v2(145.18,101.72) v2(145.42,122.24) v2(145.47,121.63) v2(145.58,118.58) v2(145.58,117.28) v2(145.58,115.98) v2(145.59,115.35) v2(145.79,121.12) v2(145.86,113.35) v2(145.81,109.82) v2(146,122.24) v2(146.1,134.7) v2(146.1,134.07) v2(146.1,133.43) v2(146.11,121.62) v2(146.19,107.73) v2(146.36,120.54) v2(146.36,119.23) v2(146.42,121.12) v2(146.59,123.58) v2(146.59,122.88) v2(146.59,122.24) v2(146.64,104) v2(146.69,134.7) v2(146.69,134.07) v2(146.69,133.43) v2(146.77,121.6) v2(147.06,121.11) v2(147.02,106.07) v2(147.02,104.8) v2(147.15,119.89) v2(147.15,118.58) v2(147.15,117.28) v2(147.15,115.98) v2(147.17,123.58) v2(147.17,122.88) v2(147.17,122.24) v2(147.27,134.7) v2(147.27,134.07) v2(147.27,133.43) v2(147.27,132.8) v2(147.27,104.04) v2(147.41,121.6) v2(147.76,122.88) v2(147.76,122.24) v2(147.72,121.1) v2(147.74,113.37) v2(147.86,134.7) v2(147.86,134.07) v2(147.86,133.43) v2(147.86,132.8) v2(147.94,117.93) v2(147.94,116.63) v2(147.94,115.34) v2(148.05,121.6) v2(148.34,122.24) v2(148.37,121.1) v2(148.29,109.82) v2(148.44,134.7) v2(148.44,134.07) v2(148.44,133.43) v2(148.44,132.8) v2(148.42,113.38) v2(148.54,107.73) v2(148.73,121.7) v2(148.73,119.89) v2(148.73,118.58) v2(148.73,115.98) v2(148.83,101.72) v2(149.03,133.23) v2(149.03,132.64) v2(149.04,121.06) v2(149.08,104.04) v2(149.37,106.07) v2(149.37,104.8) v2(149.42,121.57) v2(149.51,120.54) v2(149.51,119.23) v2(149.51,117.93) v2(149.51,116.63) v2(149.5,116) v2(149.61,133.23) v2(149.61,132.64) v2(149.69,104.04) v2(149.75,101.72) v2(149.79,102.38) v2(150.16,113.38) v2(150.19,133.23) v2(150.19,132.64) v2(150.19,111.73) v2(150.3,120.54) v2(150.3,118.58) v2(150.3,115.98) v2(150.77,113.38) v2(150.78,133.23) v2(150.78,132.64) v2(150.83,111.73) v2(151.09,119.89) v2(151.09,119.23) v2(151.09,117.93) v2(151.09,116.63) v2(151.27,110.39) v2(151.27,109.06) v2(151.27,107.79) v2(151.46,104.04) v2(151.59,106.01) v2(151.59,104.74) v2(151.88,118.58) v2(151.88,117.28) v2(151.88,115.98) v2(152.66,117.93) v2(152.66,116.63) v2(152.66,115.34) v2(152.61,113.38) v4(142.64,134.45)
