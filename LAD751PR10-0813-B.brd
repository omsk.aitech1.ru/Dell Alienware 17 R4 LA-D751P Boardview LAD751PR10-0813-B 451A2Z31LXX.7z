# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BKOFF#: length 288.4
  TOP w0.102: v2(300.4,16.61) 300.4,15.13 300.98,14.56 301.69,14.56 303.35,12.9 306.12,12.9 306.23,13.01 UE5.105 ; DV1.2 v2(171.76,159.39)
  IN4 w0.102: v2(171.76,159.39) 172.17,159.8 175.42,159.8 177.01,158.21 178.57,158.21 178.89,157.89 180.26,157.89 181.66,156.5 181.66,155.38 182.47,154.56 186.18,154.56 191.08,149.66 191.08,148.81 194.57,145.33 194.57,137.59 195.08,137.07 195.08,136.45 194.41,135.78 194.15,135.51 194.15,130.15 193.53,129.53 193.53,128.41 192.84,127.72 192.84,124.03 187.73,118.91 187.73,115.64 186.55,114.46 186.55,111.75 185.24,110.44 185.24,99.22 185.05,99.02 185.05,94.25 186.85,92.45 186.85,82.18 185.79,81.12 185.79,72.52 186.37,71.94 186.37,67.69 186.12,67.43 186.12,65.79 186.72,65.19 186.72,63.17 186.12,62.57 186.12,58.73 203.08,41.78 204.94,41.78 206.08,42.91 209.59,42.91 210.44,42.06 210.44,41.41 211.51,40.33 218.81,40.33 218.89,40.42 222.04,40.42 224.74,37.71 239.56,37.71 241.32,35.95 241.32,34.43 241.95,33.81 242.5,33.81 242.6,33.7 242.6,32.11 241.91,31.41 241.91,29.95 243.33,28.53 243.33,26.12 243.95,25.5 251.53,25.5 252.48,26.45 256.23,26.45 258.02,24.66 258.02,23.5 258.35,23.17 259.75,23.17 261.05,24.47 265.04,24.47 269.04,28.47 274.99,28.47 276.36,29.84 280.55,29.84 281.32,29.07 292.01,29.07 292.74,29.8 297.37,29.8 v2(298.01,30.45)
  BOTTOM w0.102: v2(298.01,30.45) v1(298.4,30.07) 298.4,27.84 297.99,27.44 297.99,21.59 298.59,20.99 298.59,16.61 299,16.2 300,16.2 v2(300.4,16.61)
BOARD_ID: length 25.8
  BOTTOM w0.089: 212.44,15.16 212.44,15.45 211.06,16.83 209.78,16.83 209.5,17.11 209.5,17.56 209.73,17.79 UH1.AL44
  BOTTOM w0.102: 212.44,15.16 212.44,14.94
  BOTTOM w0.107: 212.44,14.94 212.44,12.93 211.21,11.7 210.07,11.7 209.25,10.88 199.01,10.88 v1(198.33,11.57) 197.66,12.23 196.98,12.23 196.82,12.39 RH22.1 RH21.1
BOOT_1.2V: length 1.5
  BOTTOM w0.114: v1(88.87,44.96) 89.61,44.23 PR200.2
BST_1.2V: length 1.6
  BOTTOM w0.114: PR200.1 88.21,44.29 v1(87.45,45.05)
BST_+1VALWP: length 1.9
  TOP w0.102: v1(247.63,22.28) 246.58,21.23 PR302.1
BT_OFF#: length 152.9
  TOP w0.102: RN17.2 v2(317.86,36.15)
  IN6 w0.102: v2(213.81,16.35) 213.81,16.35 213.81,16.35 214.11,16.64 219.37,16.64 220.43,15.59 226.74,15.59 227.15,16.01 230.69,16.01 231.1,15.6 233.89,15.6 234.46,16.16 244.73,16.16 246.64,18.08 246.64,22.13 248.66,24.14 255.38,24.14 261.49,18.04 267.17,18.04 268.36,16.85 270.88,16.85 271.92,15.8 292.02,15.8 292.66,15.17 298.36,15.17 298.64,14.89 299.29,14.89 300.36,15.96 306.47,15.96 307.7,14.73 314.41,14.73 317.38,11.75 318.91,11.75 v2(319.31,12.16)
  BOTTOM w0.089: UH1.AV43 212.96,18.69 213.2,18.45 213.2,17.77 213,17.57 213,17.23 213.81,16.42 v2(213.81,16.35) 213.81,16.35 213.81,15.99 214.25,15.56 214.25,15.16
  BOTTOM w0.107: RH517.2 214.25,15.16 ; v2(317.86,36.15) 319.02,36.15 319.64,36.77 320.25,36.77 321.6,35.41 321.6,29.54 321.89,29.25 321.89,27.96 v1(320.8,26.87) 319.87,25.94 319.87,12.72 v2(319.31,12.16)
BT_OFF#_R: length 9.6
  TOP w0.102: v2(316.68,38.53) 316.67,38.51 RN16.2 CN25.1 316.71,36.93 RN17.1 316.71,35.77 v1(316.01,35.07)
  BOTTOM w0.107: JWLAN.46 313.57,38.64 313.97,38.24 316.4,38.24 v2(316.68,38.53)
BTST_CHG: length 1.2
  TOP w0.102: PR708.2 v1(61.41,20.49)
BUSPOWER#: length 6.7
  BOTTOM w0.076: 203.55,162.82 202.86,162.82 202.66,162.61 UT4.F10
  BOTTOM w0.102: RT74.2 207.62,162.82 207.4,162.61 v1(207.4,162.3)
  BOTTOM w0.107: RT74.2 207.11,163.74 204.97,163.74 204.62,163.39 204.57,163.39 203.95,162.77 203.6,162.77 203.55,162.82
CALDERA_ PWRGD: length 354.2
  TOP w0.102: UE6.15 331.54,45.69 v2(331.03,46.2) 329.99,47.24 v1(329.99,47.76)
  IN4 w0.089: 218.84,33.56 218.02,33.56 216.95,34.64
  IN4 w0.102: v2(331.03,46.2) 330.56,46.67 329.46,46.67 329.13,46.33 329.13,43.84 333.36,39.61 333.36,34.56 331.78,32.98 326.66,32.98 324.35,30.66 311.96,30.66 311.36,30.06 305.08,30.06 301.26,26.24 286.19,26.24 285.52,25.57 285.52,25.13 284.18,23.79 280.49,23.79 279.44,22.74 270.98,22.74 270.08,21.84 266.2,21.84 265.13,20.76 257.41,20.76 256.37,21.8 254.1,21.8 252.94,22.96 241.92,22.96 238.6,26.27 238.6,30.39 238.07,30.93 238.07,33.53 236.52,35.08 232.62,35.08 232.47,35.24 225.13,35.24 223.43,33.54 218.87,33.54 218.84,33.56 ; 216.95,34.64 216.61,34.64 215.91,35.34 214.96,35.34 214.58,35.72 213.31,35.72 212.73,36.29 212.73,37.67 211.35,39.06 203.85,39.06 200.67,42.25 199.71,42.25 198.44,43.52 191.84,43.52 189.66,45.7 189.66,51.5 184.29,56.87 184.29,65.62 183.34,66.57 183.34,68.68 183.57,68.91 183.57,69.62 184.22,70.26 184.22,71.51 183.96,71.76 183.96,81.87 185.02,82.93 185.02,91.69 182.38,94.33 182.38,106.36 183.41,107.39 183.41,114.88 184.74,116.21 184.74,118.51 191.01,124.78 191.01,140.18 191.68,140.84 191.68,145.48 184.43,152.73 181.71,152.73 181.06,153.38 172.35,153.38 171.68,154.05 169.44,154.05 168.61,154.88 168.61,155.09 165.93,157.77 165.93,159.93 162.78,163.08 162.78,166.75 159.52,170.02 154.54,170.02 153.69,170.87 153.69,174.46 v2(152.67,175.48)
  BOTTOM w0.102: 152.66,175.47 152.24,175.06 RM42.1
  BOTTOM w0.107: 152.66,175.47 v2(152.67,175.48) JCDRA.2
CALDERA_ON: length 329.9
  TOP w0.107: UE5.108 306.18,14.21 305.3,15.09 v2(305.27,15.09)
  IN4 w0.102: v2(150.26,173.65) 150.31,173.6 150.31,171.45 151.23,170.53 151.23,167.39 151.67,166.94 151.67,164.34 152.31,163.71 153.07,163.71 154.03,162.74 156.17,162.74 157.85,161.07 161.5,161.07 162.09,160.48 163.45,160.48 164.56,159.36 164.56,155.09 165.6,154.05 167.5,154.05 168.87,152.68 171.11,152.68 171.78,152.01 178.22,152.01 179.28,150.95 184.27,150.95 189.64,145.58 189.64,125.35 182.04,117.75 182.04,107.96 181.01,106.93 181.01,95.5 177.55,92.05 177.55,81.83 179.97,79.42 179.97,73.7 182.2,71.46 182.2,69.48 181.38,68.65 181.38,64.62 182.16,63.84 182.16,59.62 182.91,58.87 182.91,56.31 188.25,50.97 188.25,45.17 192.1,41.32 197.94,41.32 198.79,40.47 198.79,39.82 199.12,39.5 200.35,39.5 200.97,38.87 200.97,37.64 202.52,36.1 202.52,32.95 204.29,31.17 205.3,31.17 205.8,31.68 208.8,31.68 208.85,31.64 212.23,31.64 213.27,30.59 223.31,30.59 223.37,30.54 226.49,30.54 227.08,31.13 227.08,33.11 227.84,33.86 229.12,33.86 229.51,33.47 229.51,33.35 231.13,31.73 232.76,31.73 234.81,29.67 235.3,29.67 235.81,29.17 235.81,26.35 240.47,21.69 240.47,19.41 243.04,16.84 245.32,16.84 246.79,15.37 247.83,15.37 248.02,15.18 255.57,15.18 256.65,16.26 258.87,16.26 261.99,19.39 265.79,19.39 266.73,18.45 279.21,18.45 279.97,19.21 291.32,19.21 291.83,18.7 299.42,18.7 301.73,21.01 306.18,21.01 306.71,20.48 306.71,16.54 v2(305.27,15.09)
  BOTTOM w0.107: RM41.2 150.62,170.92 150.26,171.28 v2(150.26,173.65) UM7.2 150.26,175.05 v1(150.84,175.63) 151.87,176.66 JCDRA.1
CALDERA_PRSNT#: length 409.8
  TOP w0.102: v2(332.11,39.28) 332.27,39.43 332.27,40.04 332.04,40.27 UE6.5
  TOP w0.107: UE1.28 316.42,13.93 316.81,14.32 317.38,14.32 v2(317.76,13.94)
  IN3 w0.102: v2(139.14,153.79) 141.38,153.79 145.86,158.27 145.86,158.58 146,158.73 146,158.73 149.13,161.86 150.38,161.86 150.61,162.08 150.61,163.67 150.01,164.27 150.01,164.66 150.21,164.87 150.21,167.01 149.71,167.51 149.71,169.67 155.38,175.33 v2(158.95,175.33) ; v2(332.11,39.28) 330.66,39.28 329.9,38.52 329.9,36.93 329.18,36.21 329.18,34.36 324.02,29.2 324.02,25.33 322.84,24.15 322.84,22.78 321.84,21.77 321.84,19.51 321.29,18.97 321.29,18.17 317.76,14.64 v2(317.76,13.94)
  IN4 w0.102: v2(332.11,39.28) 333.13,38.26 333.13,34.65 331.68,33.2 326.57,33.2 324.26,30.89 311.86,30.89 311.26,30.29 300.89,30.29 298.76,28.15 283.69,28.15 282.01,26.47 277.93,26.47 276.84,27.55 270.26,27.55 266.26,23.55 261.42,23.55 260.13,22.26 257.96,22.26 257.11,23.11 257.11,24.14 256.66,24.58 243.11,24.58 242.41,25.28 242.41,28.15 240.99,29.57 240.99,33.47 240.41,34.05 240.41,35.58 239.18,36.8 224.36,36.8 222.26,38.91 219.69,38.91 219.6,39 214,39 213.84,38.84 211.87,38.84 211.47,39.25 203.99,39.25 200.76,42.48 199.81,42.48 198.54,43.75 191.94,43.75 189.89,45.8 189.89,51.6 184.52,56.97 184.52,65.71 183.57,66.66 183.57,68.58 183.8,68.82 183.8,69.52 184.45,70.16 184.45,71.6 184.19,71.86 184.19,81.78 185.25,82.84 185.25,91.78 183.45,93.59 183.45,99.69 183.64,99.88 183.64,114.79 184.97,116.12 184.97,118.42 191.24,124.69 191.24,128.39 191.93,129.07 191.93,130.44 191.24,131.12 191.24,136.09 192.95,137.79 192.95,140.35 191.91,141.39 191.91,145.58 184.52,152.96 181.81,152.96 181.16,153.61 172.44,153.61 171.78,154.28 169.53,154.28 168.84,154.97 168.84,155.19 166.16,157.86 166.16,160.03 163.01,163.18 163.01,166.85 160.28,169.58 160.28,174 v2(158.95,175.33)
  BOTTOM w0.107: RM61.1 139.37,154.02 v2(139.14,153.79) ; JCDRA.21 160.62,176.67 160.73,176.56 160.73,176.12 159.94,175.33 v2(158.95,175.33) 158.69,175.07 RM5.2
CALDERA_RST#: length 297.1
  TOP w0.114: UE6.16 331.04,45.56 v2(331.03,45.56)
  IN1 w0.081: v2(331.03,45.56) 330.47,45 312.69,45 310.94,43.24 309.19,43.24 307.99,42.05 305.74,42.05 304.51,40.81 299.77,40.81 299.13,40.17 274.16,40.17 268.56,45.77 253.67,45.77 253.07,46.36 249.55,46.36 248.69,45.5 219.88,45.5 219.01,46.37 219.01,47.17 218.63,47.56 216.48,47.56 215.78,48.25 215.78,50.15 212.74,53.19 212.74,55.46 200.77,67.43 192.77,67.43 189.55,70.65 189.55,83.77 191.77,85.99 191.77,94.43 190.03,96.17 190.03,98.37 189.7,98.69 189.7,101.05 189.43,101.33 189.43,103.66 189.75,103.98 189.75,109.56 193.07,112.89 193.07,120.64 193.81,121.38 193.81,126.21 198.54,130.94 v2(198.54,144.37)
  IN3 w0.127: v2(164.22,172.09) 164.92,171.39 164.92,169.26 167.17,167.01 167.17,161.54 167.1,161.47 167.1,157.99 168.77,156.32 168.77,154.54 171.26,152.05 173.01,152.05 173.27,151.8 184.6,151.8 189.56,146.84 196.06,146.84 v2(198.54,144.37)
  BOTTOM w0.114: UM3.1 161.48,172.58 161.61,172.7 161.82,172.7 161.82,172.7 RM6.2 162.28,172.7 162.89,172.09 v2(164.22,172.09)
CAPS: length 103.6
  TOP w0.102: RE639.1 270.33,37.55 271.31,38.53 273.31,38.53 274.21,37.62 274.21,34.47 276.34,32.35 277.26,32.35 277.86,31.76 v1(277.86,28.37) 277.86,27.31 279.69,25.48 279.69,18.92 281.24,17.37 v2(281.24,17.1)
  IN4 w0.102: v2(281.24,17.1) 279.48,15.35 269,15.35 268.69,15.65 261.35,15.65 259.03,13.34 255.25,13.34 254.8,12.9 247.1,12.9 245.96,14.04 245.96,14.26 244.75,15.47 242.4,15.47 240.31,17.56 234.5,17.56 v2(233.23,18.83)
  BOTTOM w0.107: v2(233.23,18.83) 232.86,18.83 231.52,17.49 231.52,16.78 232.23,16.06 232.23,10.68 230.44,8.88 225.46,8.88 224.31,10.03 223.22,10.03 222.47,9.28 JKB.3
CAPS_LED: length 57.1
  TOP w0.107: UE5.91 303.54,7.25 303.54,7.24 303.54,4.63 303.23,4.32 v1(290.67,4.32) 288.97,6.03 285.15,6.03 284.26,6.92 284.26,12.39 279.23,17.42 279.23,25.29 277.21,27.31 277.21,29.49 274.44,32.25 271.87,32.25 271.17,32.95 RE640.1
CDR_BTN#: length 313.6
  TOP w0.107: v2(302.49,16.73) 303.38,16.73 304.97,18.33 305.5,18.33 306.19,19.01 UE5.120
  IN4 w0.102: v2(164.15,173.31) 163.39,172.56 163.39,171.35 162.64,170.6 162.64,167.87 163.58,166.92 163.58,163.25 166.62,160.22 166.62,158.05 169.3,155.38 169.3,155.16 169.72,154.74 171.86,154.74 172.5,155.38 176.36,155.38 176.99,154.76 180.66,154.76 182,153.42 184.86,153.42 193.42,144.85 193.42,137.62 191.7,135.9 191.7,132.31 192.91,131.1 192.91,130.53 192.38,130.01 192.38,128.88 191.7,128.2 191.7,124.5 186.58,119.38 186.58,116.99 185.13,115.53 185.13,111.95 184.1,110.92 184.1,99.69 183.9,99.5 183.9,93.78 185.71,91.97 185.71,82.65 184.65,81.59 184.65,72.05 184.9,71.79 184.9,69.97 184.26,69.33 184.26,68.63 184.03,68.39 184.03,66.85 184.98,65.9 184.98,58.26 186.85,56.38 186.85,54.96 191.37,50.44 191.37,44.63 192.03,43.98 198.63,43.98 199.9,42.7 200.86,42.7 204.12,39.44 211.54,39.44 211.95,39.03 213.76,39.03 213.93,39.2 218.53,39.2 219.06,39.73 221.75,39.73 224.46,37.03 239.28,37.03 240.64,35.67 240.64,34.15 241.22,33.56 241.22,29.67 242.64,28.25 242.64,25.38 243.21,24.81 252.4,24.81 252.62,25.03 256.54,25.03 257.34,24.23 257.34,23.21 258.06,22.49 260.03,22.49 261.33,23.78 266.16,23.78 270.16,27.78 276.94,27.78 277.38,27.34 281.93,27.34 282.97,28.38 297.36,28.38 v2(297.95,28.98)
  BOTTOM w0.102: v2(302.49,16.73) 301.73,15.97 298.91,15.97 298.35,16.52 298.35,20.91 297.76,21.5 297.76,27.53 297.95,27.72 v1(297.95,28.21) v2(297.95,28.98)
  BOTTOM w0.107: v2(164.15,173.31) 164.15,173.71 163.37,174.49 RM17.2 163.14,175.68 162.62,176.19 JCDRA.26
CDR_ON_ELC: length 327.9
  TOP w0.107: UE1.27 313.79,14.73 314.14,15.08 v2(314.14,15.77)
  IN4 w0.102: v2(150.74,171.84) 151.46,171.13 151.46,167.48 151.9,167.04 151.9,164.44 152.4,163.94 153.99,163.94 154.95,162.97 156.27,162.97 157.95,161.29 162.96,161.29 164.79,159.46 164.79,155.18 165.69,154.28 167.59,154.28 168.96,152.91 171.21,152.91 171.88,152.24 180.59,152.24 181.65,151.18 184.36,151.18 190.53,145.01 190.53,141.31 189.87,140.65 189.87,125.26 182.27,117.65 182.27,107.87 181.24,106.84 181.24,95.41 177.78,91.95 177.78,81.93 180.2,79.51 180.2,73.81 182.43,71.57 182.43,69.38 181.61,68.56 181.61,64.72 182.39,63.93 182.39,59.72 183.14,58.97 183.14,56.4 188.48,51.07 188.48,45.27 192.2,41.55 198.03,41.55 198.98,40.6 198.98,39.9 199.19,39.69 200.43,39.69 201.16,38.95 201.16,37.72 202.71,36.18 202.71,33.03 204.37,31.36 205.22,31.36 205.73,31.87 208.88,31.87 208.93,31.83 214.01,31.83 214.48,31.36 216.3,31.36 216.74,31.8 224.92,31.8 227.21,34.09 229.22,34.09 229.74,33.57 229.74,33.44 231.23,31.96 233.71,31.96 234.21,32.46 235.82,32.46 236.93,31.35 236.93,30.45 237.46,29.92 237.46,25.8 240.7,22.56 240.7,19.5 243.14,17.07 247.29,17.07 248.94,15.41 255.47,15.41 256.55,16.49 257.58,16.49 260.7,19.62 265.89,19.62 266.82,18.68 279.12,18.68 279.88,19.44 291.92,19.44 292.43,18.93 299.32,18.93 301.63,21.24 310.59,21.24 312.81,19.02 312.81,16.42 313.46,15.77 v2(314.14,15.77)
  BOTTOM w0.102: v2(150.74,171.84) 151.58,171.84 v1(151.61,171.81)
  BOTTOM w0.107: v2(150.74,171.84) 150.74,172.39 UM7.4
CDR_TXRX_GOOD: length 354.4
  TOP w0.102: UE6.18 330.04,45.39 v2(329.87,45.56) 329.39,46.04 v1(329.39,46.36)
  IN4 w0.102: v2(329.87,45.56) 329.87,43.43 333.59,39.71 333.59,34.47 331.02,31.89 325.9,31.89 324.45,30.44 312.05,30.44 311.45,29.83 305.17,29.83 301.12,25.78 289.71,25.78 287.26,23.34 280.68,23.34 279.62,22.28 271.17,22.28 270.27,21.38 266.39,21.38 265.31,20.3 257.22,20.3 256.18,21.34 253.91,21.34 252.75,22.5 241.73,22.5 238.15,26.08 238.15,30.2 237.61,30.74 237.61,33.34 236.33,34.63 232.43,34.63 232.28,34.78 225.32,34.78 223.02,32.48 216.29,32.48 214.99,33.78 212.86,33.78 209.84,36.79 209.84,37.09 208.91,38.02 206.31,38.02 206.13,38.2 205.37,38.2 205.27,38.09 204.01,38.09 202.81,39.29 201.63,39.29 201.24,39.68 201.24,41.08 200.49,41.83 199.49,41.83 199.08,42.23 192.48,42.23 189.16,45.55 189.16,51.35 183.83,56.69 183.83,59.25 183.08,60 183.08,64.21 182.29,65 182.29,68.27 183.12,69.1 183.12,69.8 183.76,70.45 183.76,71.32 183.51,71.57 183.51,78 178.47,83.04 178.47,91.67 181.92,95.12 181.92,106.55 182.95,107.58 182.95,115.07 184.29,116.4 184.29,118.7 190.56,124.97 190.56,140.37 191.22,141.03 191.22,145.3 184.24,152.28 181.53,152.28 180.87,152.93 172.16,152.93 171.49,153.6 169.25,153.6 168.15,154.69 168.15,154.9 165.48,157.58 165.48,159.74 161.14,164.08 156.19,164.08 153.47,166.8 153.47,173.79 v2(150.73,176.53)
  BOTTOM w0.107: v2(150.73,176.53) 149.61,175.42 UM7.1
CDRA_LED RED: length 31.6
  IN3 w0.508: v2(164.06,175.25) 163.38,175.25 162.78,174.66 159.97,174.66 159.12,173.81 159.12,173.09 160.09,172.12 160.09,168.65 158.89,167.45 158.89,161.68 v2(159.91,160.66)
  BOTTOM w0.203: v2(164.06,175.25) 163.69,175.62 163.69,176.57 163.49,176.77 163.49,176.78 163.42,176.85 JCDRA.28
  BOTTOM w0.508: v2(159.91,160.66) 159.4,160.66 159.08,160.33 158.28,160.33 v1(157.74,159.8) 155.84,159.8 155.33,160.31 155.33,161.58 154.25,162.66 QM3.1
CDRA_LED RED_MOS: length 309
  TOP w0.107: v2(305.05,20.23) 306.24,21.41 UE5.126
  IN4 w0.102: v2(149.3,163.29) 149.49,163.48 152.97,163.48 153.94,162.52 155.95,162.52 158.78,159.69 162.06,159.69 162.09,159.66 163.2,159.66 164.33,158.53 164.33,154.99 165.5,153.82 167.4,153.82 168.77,152.45 171.02,152.45 172.75,150.73 184.17,150.73 189.41,145.49 189.41,125.45 181.81,117.84 181.81,108.06 180.78,107.03 180.78,95.6 177.33,92.14 177.33,81.74 179.74,79.32 179.74,73.6 181.97,71.37 181.97,69.57 181.15,68.75 181.15,64.53 181.94,63.74 181.94,59.53 182.69,58.78 182.69,56.21 188.02,50.88 188.02,45.08 192.01,41.09 197.84,41.09 198.56,40.37 198.56,39.78 199.04,39.31 200.27,39.31 200.78,38.79 200.78,37.56 201.63,36.72 201.63,32.45 201.9,32.18 202.32,32.18 203.22,31.27 203.22,31.2 203.51,30.92 208.64,30.92 208.98,31.25 210.51,31.25 211.4,30.36 223.22,30.36 223.27,30.31 226.58,30.31 227.31,31.04 227.31,32 228.36,33.05 229.49,33.05 231.04,31.5 232.66,31.5 234.72,29.45 235.21,29.45 235.58,29.07 235.58,26.25 240.24,21.59 240.24,19.32 242.95,16.61 245.23,16.61 246.69,15.15 247.7,15.15 247.89,14.95 255.66,14.95 256.74,16.03 258.96,16.03 262.09,19.16 265.7,19.16 266.63,18.22 279.31,18.22 280.07,18.98 291,18.98 291.51,18.47 299.89,18.47 301.8,20.38 304.9,20.38 v2(305.05,20.23)
  BOTTOM w0.107: v2(149.3,163.29) 149.45,163.44 149.78,163.44 150.06,163.72 150.06,165.66 149.95,165.77 QM2.5
CDRA_LED RED_R: length 4.6
  BOTTOM w0.508: QM3.3 155.22,165.18 154.95,164.92 154.53,164.92 154.49,164.88 154.06,164.88 153.91,164.73 153.88,164.73 153.36,164.2 153.36,164.18 152.87,163.68 RM93.2
CDRA_LED WHITE: length 35.1
  IN3 w0.508: v2(163.24,176.33) 162.24,177.32 150.5,177.32 149.64,176.46 149.64,174.33 148.95,173.64 148.95,170.41 145.94,167.4 145.94,164.49 145.27,163.82 v2(144.51,163.82)
  BOTTOM w0.102: v1(142.34,166.39) 142.34,165.44 142.97,164.8 QM1.1
  BOTTOM w0.203: JCDRA.27 163.02,176.55 v2(163.24,176.33)
  BOTTOM w0.508: QM1.1 144,164.8 144.51,164.29 v2(144.51,163.82)
CDRA_LED WHITE_MOS: length 300
  TOP w0.102: UE5.21 297.54,22.36 296.83,21.65 296.83,19.93 v2(296.55,19.65)
  IN4 w0.102: v2(296.55,19.65) 296.11,19.21 292.74,19.21 292.11,19.84 268.99,19.84 268.23,20.61 266.27,20.61 265.5,19.84 259.53,19.84 255.33,15.64 249.04,15.64 247.38,17.3 243.23,17.3 240.93,19.6 240.93,22.65 237.69,25.89 237.69,30.01 237.16,30.55 237.16,31.44 235.92,32.68 234.11,32.68 233.62,32.19 232.58,32.19 231.69,33.08 231.1,33.08 230.95,32.93 230.58,32.93 230.15,33.36 230.15,33.49 229.31,34.32 227.12,34.32 224.82,32.03 216.7,32.03 216.22,31.55 214.56,31.55 214.09,32.02 209.01,32.02 208.96,32.06 205.65,32.06 205.14,31.55 204.45,31.55 202.98,33.02 202.98,36.2 201.35,37.83 201.35,39.03 200.86,39.52 200.86,40.92 200.33,41.45 199.33,41.45 199,41.78 192.29,41.78 188.71,45.36 188.71,51.16 183.37,56.5 183.37,59.06 182.62,59.81 182.62,64.03 181.83,64.81 181.83,68.46 182.66,69.29 182.66,71.77 182.05,72.38 182.05,73.52 181.71,73.86 180.83,73.86 180.43,74.26 180.43,79.61 178.01,82.02 178.01,91.86 181.47,95.31 181.47,106.74 182.5,107.77 182.5,117.56 190.1,125.16 190.1,140.56 190.76,141.22 190.76,145.11 184.05,151.82 181.34,151.82 180.69,152.47 171.97,152.47 171.3,153.14 169.06,153.14 167.68,154.51 165.79,154.51 165.02,155.28 165.02,159.55 163.05,161.52 158.04,161.52 156.36,163.2 155.05,163.2 152.62,165.63 v2(152.31,165.63)
  BOTTOM w0.107: QM2.2 151.59,165.63 v2(152.31,165.63)
CDRA_LED WHITE_R: length 2
  BOTTOM w0.508: QM1.3 146.34,163.23 RM91.2
CDRA_RST#: length 3.7
  BOTTOM w0.114: JCDRA.22 161.02,175.84 v1(160.71,175.53) 159.82,174.64 UM3.4
CFG0: length 94.2
  TOP w0.114: JPCMC.1 123.09,157.55 v2(123.09,157.91)
  IN6 w0.081: v2(123.09,157.91) 122.85,157.67 122.85,156.18 122.24,155.56 122.24,154.73 119.32,151.81 118.18,151.81 117.82,151.45 117.82,150.76 115.3,148.24 115.3,146.53 115.8,146.03 115.8,131.25 115.43,130.88 115.43,123.1 115.4,123.07 115.4,99.83 118.28,96.95 126.34,96.95 128.34,98.95 128.34,102.11 129.83,103.6 129.83,105.98 131.4,107.55 131.73,107.55 131.96,107.77 131.96,109.3 133.22,110.56 133.79,110.56 134.63,111.4 v2(134.63,111.45)
  BOTTOM w0.076: v2(134.63,111.45) 134.31,111.13 CPU1.BN25
CFG1: length 53.1
  TOP w0.114: v2(121.8,149.26) 123.99,151.45 123.99,155.6 123.18,156.41 123.01,156.41 JPCMC.3
  IN6 w0.081: 129.44,116.79 127.45,118.78 127.45,126.04 119.97,133.52 119.97,140.97 120.61,141.62 120.61,143.91 121.41,144.7 121.41,148.86 v2(121.8,149.26) ; v2(134.63,113.03) 132.86,114.8
  IN6 w0.089: 129.44,116.79 130.06,116.17 131.49,116.17 132.86,114.8
  BOTTOM w0.076: CPU1.BN27 134.31,112.7 v2(134.63,113.03)
CFG2: length 85.8
  TOP w0.089: v2(133.98,111.45) 133.77,111.66 RH184.1 133.25,112.09 v1(132.76,112.58)
  TOP w0.114: JPCMC.5 123.15,155.23 123.19,155.23 123.43,154.99 v2(123.58,154.99)
  IN6 w0.081: v2(123.58,154.99) 123.58,154.34 117.73,148.49 117.73,130.45 117.36,130.08 117.36,122.29 117.33,122.27 117.33,100.63 119.08,98.88 122.31,98.88 127.06,103.63 127.06,105.89 128.6,107.43 128.6,109.44 131.01,111.86 131.39,111.86 131.79,111.45 v2(133.98,111.45)
  BOTTOM w0.076: CPU1.BN26 134.31,111.78 v2(133.98,111.45)
CFG3: length 63.9
  TOP w0.114: v2(115.84,151.87) 115.84,157.07 116.59,157.82 JPCMC.23 ; v2(120.91,148.63) 120.91,148.96 122.7,150.75 122.7,154.45 122.42,154.73 JPCMC.7
  IN6 w0.081: v2(133.98,113.03) 131.98,115.03 130.58,115.03 127.06,118.55 127.06,125.88 119.58,133.36 119.58,141.13 120.23,141.78 120.23,144.07 121.02,144.86 121.02,148.52 v2(120.91,148.63)
  BOTTOM w0.076: v2(133.98,113.03) 134.31,113.35 CPU1.BN28
  BOTTOM w0.114: v2(120.91,148.63) 119.08,148.63 v2(115.84,151.87)
CFG4: length 90.3
  TOP w0.114: JPCMC.9 121.86,154.07 121.86,151.39 118.87,148.4 115.75,148.4 115.57,148.22 v2(114.51,148.22)
  IN6 w0.081: v2(131.2,106.27) 131.14,106.27 130.53,105.66 130.53,102.96 129.16,101.59 129.16,98.68 126.02,95.54 118.6,95.54 114.51,99.62 v2(114.51,148.22)
  BOTTOM w0.076: v2(131.2,106.27) 131.87,106.94 132.01,106.94 132.2,106.75 132.91,106.75 133.01,106.84 CPU1.BR20
  BOTTOM w0.114: v2(131.2,106.27) 130.72,106.27 RH185.1
CFG5: length 85
  TOP w0.107: v2(134.63,106.73) 134.63,105.92 RH186.1
  TOP w0.114: v2(115.69,149.37) 115.77,149.45 118.74,149.45 121.02,151.74 121.02,153.59 JPCMC.11
  IN1 w0.081: v2(134.63,106.73) 134.63,105.57 132.4,103.34 130.87,103.34 130.5,102.97 130.5,102.09 125.93,97.52 117.4,97.52 115.4,99.52 115.4,132.02 115.97,132.59 115.97,146.9 115.7,147.16 115.7,149.06 115.69,149.07 v2(115.69,149.37)
  BOTTOM w0.114: CPU1.BM20 134.96,107.05 v2(134.63,106.73)
CFG6: length 88.5
  TOP w0.114: v2(114.54,151.25) 115.28,151.25 116.24,150.29 118.39,150.29 120.19,152.09 120.19,153.36 JPCMC.13
  IN6 w0.081: v2(114.54,151.25) 114.91,150.88 114.91,146.37 115.41,145.87 115.41,131.41 115.04,131.04 115.04,123.26 115.01,123.23 115.01,99.67 118.76,95.93 125.86,95.93 128.72,98.79 128.72,101.7 130.15,103.13 130.15,105.79 v2(131.2,106.84)
  BOTTOM w0.076: CPU1.BT20 131.48,107.12 v2(131.2,106.84)
  BOTTOM w0.114: RH187.1 130.34,106.84 v2(131.2,106.84)
CFG7: length 83.4
  TOP w0.114: JPCMC.15 119.35,153.37 119.35,152.43 118.21,151.3 v2(118.21,151.29)
  IN6 w0.081: v2(131.01,107.66) 129.45,106.1 129.45,103.76 127.95,102.27 127.95,99.11 126.18,97.33 118.44,97.33 115.78,99.99 115.78,122.91 115.81,122.93 115.81,130.72 116.18,131.09 116.18,146.19 115.68,146.69 115.68,148.08 118.23,150.63 118.23,151.27 118.21,151.28 v2(118.21,151.29)
  BOTTOM w0.076: v2(131.01,107.66) 131.33,107.66 131.5,107.49 131.98,107.49 132.1,107.62 132.93,107.62 133.13,107.42 133.36,107.42 CPU1.BP20
  BOTTOM w0.114: v2(131.01,107.66) 130.21,107.66 RH188.1
CFG8: length 85.6
  TOP w0.114: v2(123.25,156.93) 123.25,156.93 123.18,156.86 JPCMC.2
  IN6 w0.081: v2(123.25,156.93) 123.25,156.03 122.62,155.4 122.62,154.48 116.96,148.81 116.96,130.77 116.58,130.4 116.58,122.61 116.56,122.59 116.56,100.31 118.76,98.11 124.56,98.11 127.01,100.55 127.01,102.49 128.68,104.15 128.68,106.42 130.96,108.7 v2(130.96,109.05)
  BOTTOM w0.076: v2(130.96,109.05) 130.96,109.8 131.03,109.88 132.61,109.88 CPU1.BR23
CFG9: length 84.2
  TOP w0.114: JPCMC.4 122.65,155.99 123.01,155.99 v2(123.39,155.61)
  IN1 w0.081: v2(133.32,108.34) 133.28,108.34 132.62,107.68 132.62,105.08 131.61,104.08 129.72,104.08 124.77,99.13 118.06,99.13 116.94,100.25 116.94,131.38 117.51,131.95 117.51,144.61 117.7,144.8 117.7,150.45 117.02,151.12 117.02,152.65 117.37,152.99 118.36,152.99 118.6,153.23 119.93,153.23 122.31,155.61 v2(123.39,155.61)
  BOTTOM w0.114: v2(133.32,108.34) 133.01,108.66 CPU1.BR22
CFG10: length 80.7
  TOP w0.114: v2(123.02,154.82) 122.93,154.82 122.43,155.31 JPCMC.6
  IN6 w0.081: v2(131.31,109.52) 129.92,109.52 129.79,109.39 129.79,108.08 127.44,105.73 127.44,103.47 122.47,98.49 118.92,98.49 116.94,100.47 116.94,122.43 116.97,122.45 116.97,130.24 117.34,130.61 117.34,148.65 123.02,154.33 v2(123.02,154.82)
  BOTTOM w0.114: v2(131.31,109.52) 132.32,109.52 CPU1.BT23
CFG11: length 83.5
  TOP w0.114: v2(116.53,147.63) 118.7,147.63 122.28,151.22 122.28,154.26 JPCMC.8
  IN6 w0.081: v2(131.44,108.53) 131.33,108.53 129.06,106.26 129.06,103.99 127.57,102.5 127.57,99.27 126.02,97.72 118.6,97.72 116.17,100.15 116.17,122.75 116.2,122.77 116.2,130.56 116.57,130.93 116.57,147.59 v2(116.53,147.63)
  BOTTOM w0.089: CPU1.BT22 132.18,108.53 v2(131.44,108.53)
CFG12: length 86.8
  TOP w0.114: JPCMC.10 121.28,154.1 121.44,153.94 121.44,151.56 118.7,148.82 115.31,148.82 v2(115.31,148.81)
  IN1 w0.081: v2(115.31,148.81) 115.31,146.8 115.58,146.52 115.58,132.75 115.01,132.18 115.01,99.02 116.9,97.14 126.09,97.14 130.89,101.93 130.89,103.03 131,103.15 132.59,103.15 135.28,105.84 v2(135.28,106.73)
  BOTTOM w0.114: v2(135.28,106.73) 134.96,106.41 CPU1.BM19
CFG13: length 88.3
  TOP w0.114: v2(114.47,149.9) 114.51,149.87 118.57,149.87 120.61,151.91 120.61,153.63 120.55,153.68 JPCMC.12
  IN6 w0.081: v2(130.95,105.55) 130.89,105.5 130.89,102.79 129.55,101.44 129.55,98.52 126.18,95.16 118.44,95.16 114.12,99.47 114.12,149.55 v2(114.47,149.9)
  BOTTOM w0.076: v2(130.95,105.55) 131.34,105.94 132,105.94 132.1,105.84 132.63,105.84 133.01,106.21 CPU1.BR19
CFG14: length 82.2
  TOP w0.114: v2(115.84,151.29) 116.41,150.71 118.22,150.71 119.77,152.26 119.77,153.71 JPCMC.14
  IN1 w0.081: v2(133.35,106.69) 133.35,104.74 132.14,103.52 130.74,103.52 130.12,102.9 130.12,102.26 125.79,97.93 117.56,97.93 115.78,99.7 115.78,131.86 116.35,132.43 116.35,147.06 116.09,147.32 116.09,149.98 115.84,150.23 v2(115.84,151.29)
  BOTTOM w0.114: CPU1.BP19 133.66,106.39 v2(133.35,106.69)
CFG15: length 73.5
  TOP w0.114: JPCMC.16 118.99,153.58 118.9,153.49 v2(118.9,152.83)
  IN1 w0.081: v2(118.9,152.83) 119.52,152.21 119.52,148.5 120.32,147.69 120.32,145.78 118.67,144.13 118.67,131.47 118.1,130.9 118.1,119.32 119.63,117.79 119.63,114.62 118.17,113.17 118.17,101 118.85,100.33 123.44,100.33 128.55,105.44 129.68,105.44 129.99,105.12 131.7,105.12 131.89,105.31 131.89,106.24 v2(131.83,106.3)
  BOTTOM w0.089: v2(131.83,106.3) 131.87,106.34 CPU1.BT19
CFG16: length 79.8
  TOP w0.114: v2(117.54,152.6) 116.43,153.71 116.43,154.08 JPCMC.21
  IN1 w0.081: v2(117.54,152.6) 118.61,151.52 118.61,149.49 118.47,149.36 118.47,144.48 118.29,144.29 118.29,131.63 117.72,131.06 117.72,119.16 119.24,117.63 119.24,114.78 117.72,113.26 117.72,100.61 118.39,99.93 123.59,99.93 128.66,105 129.61,105 129.74,104.87 130.76,104.87 130.95,104.68 131.58,104.68 132.25,105.34 132.25,108.79 v2(133.33,109.88)
  BOTTOM w0.114: CPU1.BP23 133.66,109.55 v2(133.33,109.88)
CFG17: length 78.2
  TOP w0.114: v2(117.42,151.29) 118.48,152.35 118.48,153.63 JPCMC.17
  IN1 w0.081: v2(133.98,109.88) 133.98,109.86 132.43,108.31 132.43,105.21 131.48,104.26 130.51,104.26 130.17,104.6 128.8,104.6 123.73,99.53 118.23,99.53 117.33,100.43 117.33,131.22 117.9,131.79 117.9,144.45 118.09,144.64 118.09,150.62 v2(117.42,151.29)
  BOTTOM w0.114: v2(133.98,109.88) 134.31,109.55 CPU1.BN23
CFG18: length 81.1
  TOP w0.114: v2(116.91,153.83) 116.91,153.97 117.6,154.66 JPCMC.20
  IN1 w0.081: v2(116.91,153.83) 116.23,153.15 116.23,150.65 116.93,149.95 116.93,145.12 116.74,144.93 116.74,132.27 116.17,131.7 116.17,99.89 117.73,98.33 125.06,98.33 130.13,103.4 130.23,103.4 130.54,103.71 131.88,103.71 132.99,104.82 132.99,107 133.85,107.86 134.24,107.86 v2(134.68,108.3)
  BOTTOM w0.114: v2(134.68,108.3) 134.68,108.32 CPU1.BN22
CFG19: length 79.9
  TOP w0.114: JPCMC.18 118.26,154 118.06,153.8 118.06,152.52 117.72,152.18 116.79,152.18 v2(116.63,152.34)
  IN1 w0.081: v2(133.96,108.34) 132.8,107.18 132.8,104.95 131.75,103.89 130.41,103.89 130.32,103.8 129.99,103.8 124.92,98.73 117.9,98.73 116.56,100.07 116.56,131.54 117.13,132.11 117.13,144.77 117.31,144.96 117.31,150.29 116.63,150.97 v2(116.63,152.34)
  BOTTOM w0.114: CPU1.BP22 133.66,108.63 v2(133.96,108.34)
CFG_RCOMP: length 3.4
  BOTTOM w0.076: RH59.1 129.87,109.51 130.36,110 130.36,110.43 131,111.07 132.35,111.07 CPU1.BT25
CHG_B+:
  vias: v1(68.02,28.98) v2(62.37,29.5) v2(62.37,28.86) v2(62.87,29.81) v2(62.87,29.18) v2(62.87,28.54) v2(63.51,29.81) v2(63.51,29.18) v2(63.51,28.54) v2(64.14,29.81) v2(64.14,29.18) v2(64.14,28.54) v2(64.78,29.81) v2(64.78,29.18) v2(64.78,28.54)
CLK_PCI_LPC: length 97.8
  TOP w0.107: v2(300.68,21.56) 301.14,22.02 UE5.12 301.14,24.68 302.13,25.68 RE89.2
  IN3 w0.127: v2(300.68,21.56) 300.68,22.19 300.3,22.57 298.03,22.57 296.94,21.48 292.53,21.48 287.55,26.46 278.54,26.46 277.64,27.36 276.08,27.36 275.76,27.68 247.46,27.68 243.78,24 239.55,24 236.22,20.67 230.99,20.67 229.48,22.18 227.23,22.18 226.58,22.83 226.58,23.27 224.99,24.86 223.97,24.86 222.96,25.88 v2(222.96,26.77)
  BOTTOM w0.107: RH89.1 221.01,29.55 222.06,29.55 v1(222.27,29.34) 223.15,28.46 223.15,26.96 v2(222.96,26.77)
CLK_PCIE_DGPU#_C: length 18.5
  IN6 w0.089: v2(165.04,174.71) 164.84,174.51 164.84,169.11 162.86,167.14 162.86,164.8 162.12,164.06 162.12,163.02 161.72,162.62 161.72,162.47 v2(161.91,162.28)
  BOTTOM w0.099: JCDRA.34 165.82,176.7
  BOTTOM w0.107: v2(161.91,162.28) 161.99,162.36 162.26,162.36 162.44,162.18 CM99.2 ; 165.82,176.7 165.74,176.63 165.74,176.05 164.9,175.2 164.9,174.85 v2(165.04,174.71)
CLK_PCIE_DGPU_C: length 18.8
  IN6 w0.089: v2(164.46,174.71) 164.67,174.49 164.67,169.18 162.7,167.21 162.7,164.87 161.96,164.13 161.96,163.09 161.55,162.69 161.55,162.51 v2(161.32,162.28)
  BOTTOM w0.099: JCDRA.33 165.42,176.66
  BOTTOM w0.107: CM98.2 162.28,162.69 161.74,162.69 v2(161.32,162.28) ; 165.42,176.66 165.54,176.54 165.54,176.14 164.69,175.28 164.69,174.94 v2(164.46,174.71)
CLK_PCIE_N1: length 157.1
  IN1 w0.089: v2(199.03,36.54) 199.04,36.54 199.63,37.12 199.63,37.23 199.85,37.45 200.59,37.45 201.52,36.52 201.52,33.92 200.33,32.72 200.33,31.67 200.82,31.18 200.82,29.68 202.14,28.36 202.14,25.76 204.78,23.13 204.78,19.94 206.89,17.82 207.66,17.82 207.98,17.51 207.98,16.91 208.2,16.69 211.8,16.69 212.75,15.74 214.03,15.74 214.96,16.67 218.68,16.67 218.93,16.92 220.94,16.92 221.66,16.21 226.65,16.21 228.06,17.63 235.41,17.63 235.81,18.03 237.94,18.03 241.05,21.14 241.05,21.97 242.55,23.46 243.52,23.46 247.68,27.62 248.03,27.97 259.43,27.97 260.45,28.99 274.65,28.99 275.51,29.84 279.27,29.84 279.51,29.61 286.3,29.61 286.56,29.88 289.38,29.88 292.42,32.91 308.86,32.91 309.08,33.14 320.98,33.14 322.63,34.78 323.81,34.78 323.9,34.69 323.9,34.56 323.51,34.17 v2(323.49,34.17)
  BOTTOM w0.099: JSSD1.53 324.92,35.11
  BOTTOM w0.107: 324.92,35.11 323.74,35.11 323.49,34.86 v2(323.49,34.17) ; v2(199.03,36.54) 199.03,36.59 199.26,36.82 199.44,36.82 UH1.L7
CLK_PCIE_N2: length 118.2
  IN3 w0.127: v2(273.63,23.97) 273.74,24.09 273.74,24.18 273.4,24.52 268.77,24.52 265.3,21.05 259.61,21.05 256.18,24.48 248.43,24.48 245.48,21.53 244.45,21.53 239.55,16.62 234.85,16.62 233.82,15.59 231.54,15.59 230.42,16.71 227.76,16.71 226.69,17.78 223.4,17.78 222.77,18.42 222.25,18.42 221.65,17.81 219.18,17.81 218.61,18.38 216.53,18.38 215.8,17.66 213.77,17.66 213.69,17.75 208.11,17.75 208.11,17.75 206.65,17.75 205.12,19.27 204.3,19.27 202.23,21.33 201.28,21.33 200.39,22.23 200.39,26.42 200.03,26.78 200.03,32.37 199.43,32.97 199.43,35 199.25,35.18 198.88,35.18 198.7,35.18 198.42,35.46 198.42,37.38 198.37,37.43 198.37,37.78 197.98,38.16 197.41,38.16 v2(197.31,38.06)
  BOTTOM w0.107: UH1.D3 196.78,38.46 196.84,38.41 196.96,38.41 v2(197.31,38.06) ; JSSD2.53 272.69,11.25 272.87,11.08 273.47,11.08 273.88,11.5 273.88,22.25 273.81,22.32 273.81,23.78 v2(273.63,23.97)
CLK_PCIE_N3: length 149.7
  TOP w0.094: UT1.T19 v2(184.55,163.16)
  IN1 w0.089: v2(191.7,103.98) 191.63,103.92 191.38,103.92 191.14,104.15 191.14,109.89 193.83,112.57 193.83,118.58 195.45,120.2 195.45,121.24 195.13,121.56 195.13,123.07 195.45,123.39 195.45,124.56 196.03,125.15 196.03,127.1 196.6,127.67 197.49,127.67 198.26,128.43 198.26,129.05 199.16,129.95 199.65,129.95 200.49,130.8 200.49,133.24 199.3,134.43 199.3,142.81 200.49,144 200.49,146.36 196.01,150.85 196.01,154.22 190.45,159.78 189.27,159.78 186.27,162.77 184.94,162.77 v2(184.55,163.16)
  IN3 w0.127: v2(191.7,103.98) 191.56,103.84 191.2,103.84 190.86,103.51 190.86,102.93 189.59,101.66 189.59,86.86 188.26,85.53 188.26,65.59 189.32,64.52 189.32,46.31 192.3,43.34 192.99,43.34 195.14,41.18 195.72,41.18 196.71,40.19 196.71,37.36 197.27,36.8 v2(197.96,36.8)
  BOTTOM w0.107: UH1.E5 197.15,37.35 197.15,37.2 197.43,36.92 197.84,36.92 v2(197.96,36.8)
CLK_PCIE_N4: length 208.7
  IN3 w0.127: v2(269.18,165.22) 269.06,165.34 268.79,165.34 268.66,165.21 268.66,163.44 267.85,162.63 267.85,160.48 262.1,154.74 242.29,154.74 241.76,154.21 237.54,154.21 236.48,155.26 234.42,155.26 233.55,154.4 227.42,154.4 227.38,154.36 225.58,154.36 225.27,154.06 215.42,154.06 214.71,153.35 211.83,153.35 209.87,151.39 209.87,148.56 209.21,147.9 209.21,146.81 209.56,146.46 209.56,132.32 211.93,129.94 211.93,127.18 211.56,126.81 211.56,123.66 208.93,121.04 208.18,121.04 206.85,119.72 206.85,113.93 205.31,112.38 205.31,110.04 201.88,106.62 196.36,106.62 194.81,105.07 191.53,105.07 188.95,102.5 188.95,87.13 187.62,85.79 187.62,64.16 188.03,63.75 188.03,59.27 188.69,58.61 188.69,45.63 194.06,40.25 194.06,39.69 195.15,38.61 195.23,38.61 195.99,37.85 196.2,37.85 196.32,37.97 v2(196.32,38)
  BOTTOM w0.099: UH1.D5 196.08,37.6
  BOTTOM w0.107: v2(196.32,38) 196.34,37.98 196.34,37.71 196.23,37.6 196.08,37.6 ; v2(269.18,165.22) 269.18,165.02 269.07,164.91 268.88,164.91 268.78,165.02 268.78,165.04 268.77,165.05 268.77,165.49 269.04,165.77 v3(270.15,165.77) 270.66,165.77 271.1,165.33 271.1,165.01 271.19,164.91 271.19,164.77 271,164.57 UL1.32
CLK_PCIE_N5: length 136.2
  IN6 w0.089: v2(196.55,36.42) 196.45,36.42 196.35,36.53 196.35,36.61 196.09,36.88 195.61,36.88 195.31,37.18 195.31,39.88 198.24,42.81 201.1,42.81 201.99,43.7 207.08,43.7 207.32,43.94 214.3,43.94 215.16,43.07 223.65,43.07 226.49,40.24 227.13,40.24 228.22,39.15 232.88,39.15 233.56,38.48 239.81,38.48 240.43,39.1 247.28,39.1 249.43,41.25 265.2,41.25 273.88,32.57 279.08,32.57 279.98,31.66 287.1,31.66 288.79,33.35 310.8,33.35 312.15,34.7 312.15,35.33 312.38,35.56 312.61,35.56 v2(312.82,35.35)
  BOTTOM w0.089: UH1.D8 196.34,36.21 v2(196.55,36.42)
  BOTTOM w0.099: 312.64,35.53 v2(312.82,35.35)
  BOTTOM w0.107: 312.64,35.53 312.31,35.53 312.17,35.39 312.17,34.65 312.32,34.5 JWLAN.41
CLK_PCIE_N6: length 185.6
  IN1 w0.089: v2(200.99,35.82) 200.83,35.99 200.68,35.99 200.59,35.89 200.59,35.26 200.66,35.19 200.66,34.41 200.36,34.12 198.34,34.12 197.62,34.85 195.66,34.85 195.22,34.41 193.88,34.41 193.12,33.65 191.96,33.65 190.76,34.85 190.76,40.41 188.16,43.02 188.16,55.09 187.36,55.89 187.36,59.25 185.58,61.03 185.58,62 184.24,63.34 184.24,66.01 183.3,66.96 183.3,68.52 183.74,68.97 183.74,72.75 183.47,73.02 183.12,73.02 v2(182.89,72.79)
  IN3 w0.127: v2(169.89,155.14) 170.1,154.93 170.1,154.1 171.52,152.69 173.28,152.69 173.53,152.44 184.86,152.44 189.82,147.48 198.4,147.48 202.26,143.63 202.26,143.32 204.46,141.11 204.46,136.52 204.87,136.11 204.87,134.66 203.21,133 203.21,131.04 204.18,130.07 204.18,128.87 204.42,128.63 204.42,127.82 203.52,126.92 202.42,126.92 202.09,127.25 201.28,127.25 200.58,126.55 200.58,123.16 197.53,120.11 197.53,119.25 196.21,117.93 194.22,117.93 193.39,117.1 193.39,116.42 191.49,114.52 191.49,112.55 183.8,104.87 183.8,99.37 183.61,99.18 183.61,95.68 182.67,94.74 180.96,94.74 178.19,91.97 178.19,87.42 180.48,85.13 180.48,74.27 180.89,73.85 181.66,73.85 182.13,73.38 182.13,73.25 182.38,72.99 182.69,72.99 v2(182.89,72.79)
  BOTTOM w0.089: v2(200.99,35.82) 201.16,35.99 UH1.R8
  BOTTOM w0.107: UM4.3 169.89,154.61 170.13,154.85 170.13,154.91 v2(169.89,155.14)
CLK_PCIE_N7: length 62.7
  IN6 w0.089: v2(239.1,21.19) 239.1,21.2 238.9,21.41 238.9,22.32 238.32,22.89 236.21,22.89 235.89,23.21 234.38,23.21 232.16,25.43 232.16,27.06 230.35,28.87 230.35,34.08 229.63,34.8 228.57,34.8 226.77,36.6 225.86,36.6 222.57,39.89 216.68,39.89 216.08,40.49 215.04,40.49 214.55,40.01 213.52,40.01 213.05,40.48 210.62,40.48 209.67,39.54 207.13,39.54 206.58,38.99 204.08,38.99 203.59,38.5 203.59,37.31 203.5,37.22 203.31,37.22 v2(203.08,37.45)
  BOTTOM w0.099: UH1.U5 202.71,37.45 v2(203.08,37.45)
  BOTTOM w0.107: v2(239.1,21.19) 238.91,21 238.91,18.81 238.06,17.96 238.06,15.14 238.5,14.7 240.52,14.7 240.9,14.32 240.9,13.98 241.02,13.85 JSSD3.53
CLK_PCIE_P1: length 157.1
  IN1 w0.089: v2(199.03,37.11) 199.1,37.04 199.31,37.04 199.46,37.19 199.46,37.3 199.78,37.61 200.66,37.61 201.69,36.58 201.69,33.85 200.5,32.65 200.5,31.74 200.99,31.25 200.99,29.75 202.31,28.43 202.31,25.83 204.94,23.2 204.94,20.01 206.96,17.99 207.73,17.99 208.14,17.58 208.14,16.98 208.27,16.85 211.87,16.85 212.82,15.91 213.96,15.91 214.89,16.83 218.61,16.83 218.86,17.09 221.01,17.09 221.72,16.38 226.58,16.38 227.99,17.79 235.34,17.79 235.74,18.19 237.87,18.19 240.89,21.21 240.89,22.03 242.48,23.63 243.46,23.63 247.52,27.69 247.97,28.14 259.36,28.14 260.38,29.15 274.58,29.15 275.44,30.01 279.34,30.01 279.57,29.78 286.23,29.78 286.5,30.04 289.31,30.04 292.35,33.08 308.79,33.08 309.01,33.3 320.91,33.3 322.56,34.94 323.88,34.94 324.06,34.76 324.06,34.19 v2(324.07,34.17)
  BOTTOM w0.107: UH1.L5 199.09,37.11 v2(199.03,37.11) ; JSSD1.55 325.07,34.61 324.79,34.89 323.83,34.89 323.72,34.79 323.72,34.65 323.8,34.58 323.92,34.58 324.07,34.42 v2(324.07,34.17)
CLK_PCIE_P2: length 118.5
  IN3 w0.127: v2(197.31,38.61) 197.32,38.61 197.55,38.38 198.07,38.38 198.59,37.87 198.59,37.52 198.64,37.47 198.64,35.55 198.79,35.4 199.34,35.4 199.65,35.09 199.65,33.06 200.25,32.46 200.25,26.87 200.61,26.51 200.61,22.32 201.37,21.55 202.33,21.55 204.39,19.49 205.21,19.49 206.74,17.97 208.2,17.97 208.2,17.97 213.78,17.97 213.86,17.88 215.71,17.88 216.44,18.6 218.7,18.6 219.27,18.03 221.56,18.03 222.16,18.64 222.86,18.64 223.49,18 226.78,18 227.85,16.93 230.51,16.93 231.63,15.81 233.73,15.81 234.76,16.84 239.46,16.84 244.36,21.75 245.39,21.75 248.34,24.7 256.27,24.7 259.7,21.27 265.21,21.27 268.68,24.73 273.49,24.73 273.93,24.3 273.96,24.23 274.21,23.98 v2(274.21,23.97)
  BOTTOM w0.107: v2(197.31,38.61) 197.31,38.61 196.98,38.61 196.87,38.72 UH1.F2 ; JSSD2.55 272.7,10.76 272.83,10.88 273.55,10.88 274.09,11.41 274.09,22.17 274.09,22.33 274.02,22.41 274.02,23.79 v2(274.21,23.97)
CLK_PCIE_P3: length 149.2
  TOP w0.089: UT1.V19 184.23,162.18
  TOP w0.094: 184.23,162.18 v2(184.55,162.51)
  IN1 w0.089: v2(191.7,103.4) 191.37,103.72 191.34,103.72 190.98,104.08 190.98,109.96 193.66,112.64 193.66,118.65 195.29,120.27 195.29,121.17 194.97,121.49 194.97,123.13 195.29,123.46 195.29,124.63 195.87,125.21 195.87,127.16 196.54,127.83 197.43,127.83 198.09,128.5 198.09,129.12 199.09,130.12 199.58,130.12 200.33,130.87 200.33,133.17 199.13,134.37 199.13,142.88 200.33,144.07 200.33,146.29 195.84,150.78 195.84,154.15 190.38,159.61 189.2,159.61 186.21,162.6 184.65,162.6 v2(184.55,162.51)
  IN3 w0.127: v2(197.99,37.37) 197.98,37.37 197.63,37.02 197.36,37.02 196.93,37.45 196.93,40.29 195.81,41.4 195.24,41.4 193.08,43.56 192.39,43.56 189.54,46.4 189.54,64.61 188.48,65.68 188.48,85.44 189.81,86.77 189.81,101.57 191.08,102.84 191.08,103.42 191.29,103.63 191.47,103.63 191.7,103.4 v2(191.7,103.4)
  BOTTOM w0.107: v2(197.99,37.37) 197.74,37.12 197.51,37.12 197.35,37.29 197.35,37.43 UH1.G4
CLK_PCIE_P4: length 208.4
  IN3 w0.127: v2(268.25,165.21) 268.45,165.01 268.45,163.53 267.63,162.72 267.63,160.57 262.01,154.95 242.2,154.95 241.67,154.43 237.63,154.43 236.57,155.48 234.33,155.48 233.46,154.62 225.52,154.62 225.18,154.28 215.32,154.28 214.62,153.57 211.74,153.57 209.65,151.48 209.65,148.65 208.99,147.99 208.99,146.72 209.34,146.37 209.34,132.23 211.71,129.85 211.71,127.27 211.34,126.9 211.34,123.75 208.84,121.26 208.09,121.26 206.64,119.81 206.64,114.02 205.09,112.47 205.09,110.13 201.79,106.84 196.27,106.84 194.72,105.29 191.43,105.29 188.74,102.59 188.74,87.22 187.41,85.88 187.41,64.07 187.81,63.66 187.81,59.18 188.47,58.52 188.47,45.54 193.85,40.16 193.85,39.57 195.02,38.39 195.14,38.39 195.89,37.64 195.91,37.64 196.13,37.42 196.13,37.4 196.29,37.24 v2(196.35,37.24)
  BOTTOM w0.099: v2(196.35,37.24) 196.76,37.24 UH1.E6
  BOTTOM w0.107: v2(268.25,165.21) 268.45,165.21 268.56,165.32 268.56,165.58 268.96,165.97 269.84,165.97 269.87,166 270.44,166 270.46,165.97 270.75,165.97 271.3,165.41 271.3,165.09 271.4,165 UL1.33
CLK_PCIE_P5: length 136.9
  IN6 w0.089: v2(312.82,35.93) 312.62,35.73 312.31,35.73 311.98,35.4 311.98,34.77 310.73,33.52 288.72,33.52 287.03,31.83 280.05,31.83 279.15,32.73 273.95,32.73 265.27,41.41 249.36,41.41 247.21,39.27 240.36,39.27 239.74,38.65 233.63,38.65 232.95,39.32 228.29,39.32 227.2,40.41 226.56,40.41 223.72,43.24 215.23,43.24 214.37,44.1 207.25,44.1 207.01,43.86 201.92,43.86 201.03,42.97 198.17,42.97 195.14,39.95 195.14,37.11 195.54,36.71 196.02,36.71 196.19,36.55 196.19,36.41 196.08,36.3 v2(195.96,36.3)
  BOTTOM w0.089: UH1.D7 196.14,36.47
  BOTTOM w0.099: 196.14,36.47 v2(195.96,36.3)
  BOTTOM w0.107: v2(312.82,35.93) 312.62,35.73 312.22,35.73 311.97,35.48 311.97,34.63 311.82,34.48 JWLAN.39
CLK_PCIE_P6: length 185.3
  IN1 w0.089: v2(182.89,73.37) 183.08,73.18 183.54,73.18 183.9,72.82 183.9,68.9 183.46,68.45 183.46,67.02 184.41,66.08 184.41,63.41 185.75,62.07 185.75,61.1 187.52,59.32 187.52,55.96 188.32,55.16 188.32,43.08 190.93,40.48 190.93,34.92 192.03,33.81 193.05,33.81 193.81,34.58 195.15,34.58 195.59,35.01 197.68,35.01 198.41,34.28 200.29,34.28 200.49,34.48 200.49,35.12 200.42,35.19 200.42,35.96 200.62,36.15 200.82,36.15 v2(201.06,36.39)
  IN3 w0.127: v2(170.54,155.14) 170.32,154.93 170.32,154.2 171.61,152.9 173.37,152.9 173.62,152.65 184.95,152.65 189.91,147.7 198.49,147.7 202.47,143.72 202.47,143.41 204.68,141.2 204.68,136.61 205.09,136.2 205.09,134.57 203.43,132.91 203.43,131.13 204.4,130.16 204.4,128.96 204.63,128.72 204.63,127.73 203.61,126.7 202.33,126.7 202,127.03 201.37,127.03 200.8,126.46 200.8,123.07 197.75,120.02 197.75,119.16 196.3,117.71 194.31,117.71 193.61,117.01 193.61,116.33 191.71,114.43 191.71,112.46 184.02,104.78 184.02,99.28 183.83,99.09 183.83,95.59 182.76,94.52 181.05,94.52 178.41,91.88 178.41,87.51 180.69,85.22 180.69,74.36 180.98,74.07 181.75,74.07 182.35,73.47 182.35,73.34 182.47,73.21 182.72,73.21 v2(182.89,73.37)
  BOTTOM w0.089: v2(201.06,36.39) 201.42,36.75 UH1.R7
  BOTTOM w0.107: UM4.2 170.54,154.64 170.33,154.85 170.33,154.94 v2(170.54,155.14)
CLK_PCIE_P7: length 62.5
  IN6 w0.089: v2(203.08,36.9) 203.23,37.05 203.57,37.05 203.75,37.24 203.75,38.43 204.15,38.83 206.65,38.83 207.19,39.37 209.74,39.37 210.68,40.32 212.98,40.32 213.45,39.85 214.62,39.85 215.1,40.33 216.01,40.33 216.61,39.73 222.5,39.73 225.79,36.44 226.7,36.44 228.5,34.64 229.56,34.64 230.19,34.01 230.19,28.8 231.99,26.99 231.99,25.36 234.31,23.04 235.82,23.04 236.14,22.73 238.26,22.73 238.73,22.25 238.73,21.41 v2(238.51,21.19)
  BOTTOM w0.099: v2(203.08,36.9) 202.74,36.9 UH1.U7
  BOTTOM w0.107: JSSD3.55 240.53,13.73 240.69,13.89 240.69,14.24 240.43,14.5 238.41,14.5 237.85,15.06 237.85,18.04 238.71,18.89 238.71,21 v2(238.51,21.19)
CLK_PEG_GPU: length 140.4
  IN3 w0.127: v2(199.98,35.77) 199.98,35.85 199.76,36.06 199.69,36.06 199.41,36.34 199.41,37.8 197.34,39.87 197.34,40.51 196.82,41.03 196.82,46.77 190.18,53.41 190.18,65.07 189.56,65.69 189.56,66.64 189.71,66.8 189.71,67.63 189.11,68.23 189.11,85.18 190.44,86.51 190.44,101.3 191.79,102.65 208.99,102.65 210.32,103.98 210.32,113.63 211.59,114.89 211.59,119.38 211.53,119.45 211.28,119.45 v2(211.15,119.31)
  BOTTOM w0.089: v2(211.15,119.31) 211.15,119.38 211.46,119.7 212.58,119.7 213.88,118.4 215.94,118.4 216.55,119.01 218.71,119.01 219.02,119.32 222.05,119.32 223.79,121.06 v3(226.48,121.06) 235.66,121.06 236.79,119.93 236.79,116.61 236.63,116.45 UG9.BM26
  BOTTOM w0.107: UH1.N8 200.47,35.85 200.05,35.85 v2(199.98,35.77)
CLK_PEG_GPU#: length 140.1
  IN3 w0.127: v2(200.03,36.35) 199.63,36.76 199.63,37.89 197.56,39.97 197.56,40.6 197.04,41.12 197.04,46.86 190.39,53.5 190.39,65.16 189.77,65.78 189.77,66.55 189.93,66.71 189.93,67.72 189.33,68.32 189.33,85.09 190.66,86.42 190.66,101.21 191.88,102.43 209.08,102.43 210.54,103.89 210.54,113.53 211.81,114.8 211.81,119.48 211.62,119.67 211.37,119.67 v2(211.15,119.89)
  BOTTOM w0.089: UH1.N7 200.24,36.35 v2(200.03,36.35) ; v2(211.15,119.89) 212.66,119.89 213.96,118.59 215.85,118.59 216.47,119.21 218.63,119.21 218.94,119.51 221.97,119.51 223.71,121.26 226.14,121.26 226.16,121.29 226.77,121.29 226.8,121.26 235.58,121.26 235.74,121.26 236.99,120.01 236.99,119.85 236.99,116.63 UG9.BM27
CLK_SMB: length 10.5
  TOP w0.114: v2(85.36,9.25) 85.23,9.38 85.23,10.21 84.64,10.79 v3(83.73,10.79) 82.54,10.79 82.15,11.17 82.15,11.5 PR19.1
  BOTTOM w0.114: v2(85.36,9.25) 85.23,9.38 85.23,9.94 85.42,10.13 85.71,10.13 85.82,10.24 PBATT1.5
CLKDET#: length 2.3
  TOP w0.089: v2(214.53,28.82) v1(214.53,29.39) 214.53,29.61 RH558.1
  BOTTOM w0.089: UH1.BB22 214.71,28.82 v2(214.53,28.82)
CLKREQ#_DGPU: length 291
  TOP w0.107: v2(293.44,34.07) v1(294.24,33.27) 295.11,32.4 295.11,30.47 296.36,29.22 296.36,28.67 297.58,27.45 297.58,25.42 298.34,24.66 UE5.19
  IN1 w0.089: 219.18,23.44 217.71,23.44 216.67,24.48 212.25,24.48 v2(211.8,24.04)
  IN1 w0.097: 219.18,23.44 v2(219.27,23.44)
  IN1 w0.102: v2(219.27,23.44) 220.54,22.17 220.54,19.02 221.07,18.5 222.5,18.5 223.63,17.37 226.17,17.37 227.7,18.89 228.43,18.89 230.13,20.59 232.04,20.59 233.18,19.45 235.6,19.45 245.28,29.13 258.95,29.13 259.97,30.14 271.42,30.14 272,30.73 274.75,30.73 275.18,31.16 288.81,31.16 291.71,34.07 v2(293.44,34.07)
  IN2 w0.102: v2(194.7,59.48) 194.7,59.15 193.35,57.8 186.81,57.8 184.91,59.71 184.91,61.09 174.81,71.19 174.81,82.42 177.08,84.69 177.08,92.07 178.69,93.68 178.69,103.06 180.87,105.23 180.87,119.5 188.51,127.14 188.51,146.88 183.6,151.79 172.99,151.79 170.94,153.84 169.36,153.84 169.11,154.08 169.11,156.75 169.93,157.58 169.79,157.72 169.79,158.35 v2(169.69,158.45)
  IN3 w0.089: v2(211.8,24.04) 211.8,24.4 209.13,27.07 204.9,27.07 204.81,27.16 204.81,30.99 204.99,31.16 204.99,38.63 201.64,41.98 201.64,42.08
  IN3 w0.102: 201.64,42.08 201.64,42.77 199.72,44.68 199.72,47.96 197.17,50.51 197.17,51.45 193.95,54.67 193.95,57.46 194.7,58.21 v2(194.7,59.48)
  BOTTOM w0.089: UH1.AT33 211.8,23.88 v2(211.8,24.04)
  BOTTOM w0.127: RP5.5 219.3,23.47 v2(219.27,23.44)
  BOTTOM w0.381: v2(169.69,158.45) 169.24,158.9 UM4.17
CLKREQ#_GPU: length 144.7
  IN1 w0.089: 201.54,41.24 202.7,40.08 202.7,39.4 204.15,37.95 204.63,37.95 205.14,37.44 205.14,33.64 206.76,32.02 208.62,32.02 209.21,31.43 210.67,31.43 210.94,31.16 210.94,29.89 212.6,28.23 215.44,28.23 216.6,27.07 v2(218.28,27.07)
  IN1 w0.102: v2(191.91,106.01) 192.38,106.48 192.38,110.27 194.3,112.19 195,112.19 196.06,113.25 196.06,117.22 197.04,118.2 199.27,118.2 199.72,118.65 199.72,119.92 200.19,120.39 v2(200.52,120.39) ; 201.54,41.24 201.3,41.24 200.28,42.27 197.8,42.27 197.21,42.87 197.21,46.91 195.94,48.18 195.24,48.18 192.53,50.88 192.53,55.98 191.66,56.85 191.66,58.08 192.48,58.89 192.48,60.7 192.22,60.96 192.22,62.49 192.68,62.95 v2(193.18,62.95)
  IN6 w0.102: v2(191.91,106.01) 191.65,105.76 191.3,105.76 188.45,102.9 188.19,102.9 184.48,99.19 184.48,92.96 184.83,92.61 184.83,76.73 182.8,74.7 182.32,74.7 181.71,74.08 181.11,74.08 179.2,72.17 179.2,70.14 180.7,68.64 180.7,66.08 182.61,64.17 187.33,64.17 188.14,63.36 190.93,63.36 191.35,62.95 v2(193.18,62.95)
  BOTTOM w0.089: UH1.BC24 215.66,28.12 215.81,27.97 216.11,27.97 216.32,28.18 216.58,28.18 216.67,28.28 217.4,28.28 217.64,28.04 217.64,27.44 218.02,27.07 v2(218.28,27.07)
  BOTTOM w0.102: QG510.1 198.23,120.78 198.62,120.39 v2(200.52,120.39)
  BOTTOM w0.107: v2(218.28,27.07) 218.89,26.45 RP3.5
CLKREQ_PCIE#1: length 146.2
  TOP w0.089: v2(213.08,27.37) 213.81,28.1 216.58,28.1 216.79,28.31 217.99,28.31 219.18,27.12
  TOP w0.107: 219.18,27.12 219.3,27 v2(219.3,26.96)
  IN1 w0.097: 219.4,26.95 219.4,26.96 v2(219.3,26.96)
  IN1 w0.102: 219.4,26.95 219.68,26.95 223.24,23.38 223.24,18.4 223.82,17.82 225.98,17.82 226.94,18.78 227.12,18.97 227.12,19.5 227.92,20.29 229.18,20.29 229.94,21.05 233.16,21.05 233.58,20.63 236.14,20.63 245.09,29.58 255.82,29.58 256.84,30.6 271.23,30.6 271.82,31.19 274.56,31.19 275.75,32.38 279.41,32.38 279.85,31.93 287.18,31.93 290.15,34.91 290.15,35.5 291.77,37.12 310.11,37.12 310.89,36.34 313.46,36.34 313.83,35.97 316.81,35.97 317.39,36.56 321.96,36.56 v2(322.16,36.76)
  BOTTOM w0.089: UH1.AW24 213.49,27.67 213.38,27.67 v2(213.08,27.37)
  BOTTOM w0.102: JSSD1.52 332.07,35.36 331.63,34.91 331.63,32.25 330.97,31.59 328.57,31.59 327.43,32.73 324.21,32.73 322.87,34.08 322.87,36.02 v1(322.59,36.29) 322.59,36.32 v2(322.16,36.76)
  BOTTOM w0.107: v2(219.3,26.96) 219.3,26.95 RP3.6
CLKREQ_PCIE#2: length 102.7
  TOP w0.089: v2(211.78,27.37) 212.14,27.73 213.01,27.73 213.56,28.28 216.47,28.28 216.67,28.48 218.25,28.48 v1(218.75,27.98) 219.09,27.65 219.18,27.65
  TOP w0.102: 219.18,27.65 v2(219.33,27.65)
  IN1 w0.102: v2(219.33,27.65) 220.13,27.65 223.48,24.3 223.48,18.48 223.91,18.05 225.89,18.05 226.89,19.06 226.89,19.59 227.85,20.54 229.05,20.54 229.8,21.29 233.25,21.29 233.68,20.86 236.04,20.86 245,29.81 255.73,29.81 256.95,31.03 263.87,31.03 264.12,31.03 264.78,31.69 264.78,32.2 265.46,32.89 272.2,32.89 273.39,31.7 v2(273.95,31.7)
  BOTTOM w0.089: v2(211.78,27.37) 211.78,27.4 212.22,27.84 UH1.AT24
  BOTTOM w0.102: JSSD2.52 278.02,11.5 275.75,13.78 275.75,23.69 274.88,24.57 274.88,26.75 274.24,27.39 274.24,29.9 273.95,30.19 v2(273.95,31.7)
  BOTTOM w0.127: RP3.7 219.52,27.45 v2(219.33,27.65)
CLKREQ_PCIE#3: length 167.8
  IN1 w0.089: 201.67,41.43 202.88,40.23 202.88,39.48 203.52,38.83 205.31,38.83 206.08,38.06 206.08,33.93 206.39,33.62 207.02,33.62 207.15,33.5 207.15,32.67 207.62,32.2 208.69,32.2 209.29,31.6 210.75,31.6 211.12,31.23 211.12,29.96 212.68,28.4 215.68,28.4 216.17,27.91 v2(216.94,27.91)
  IN1 w0.102: v2(192.07,57.4) 192.76,56.71 192.76,50.97 195.33,48.41 196.03,48.41 197.43,47 197.43,42.96 197.89,42.5 200.37,42.5 201.44,41.43 201.67,41.43
  IN2 w0.102: v2(177.48,151.32) 178.39,150.4 184.67,150.4 188.28,146.79 188.28,127.24 180.64,119.6 180.64,105.33 178.5,103.19 178.5,93.81 176.85,92.16 176.85,84.79 174.58,82.52 174.58,71.09 184.68,60.99 184.68,59.61 186.72,57.58 191.89,57.58 v2(192.07,57.4)
  BOTTOM w0.089: UH1.BD25 216.11,27.79 216.82,27.79
  BOTTOM w0.102: v2(177.48,151.32) 177.48,151.68 177.14,152.03 RT24.1 RT2.2
  BOTTOM w0.127: 216.82,27.79 v2(216.94,27.91)
