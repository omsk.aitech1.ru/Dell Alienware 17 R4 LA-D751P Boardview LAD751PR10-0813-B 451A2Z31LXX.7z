# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS2: length 51.3
  IN6 w0.081: v2(135.08,88.68) 134.84,88.91 134.67,88.91 134.54,88.78 134.54,87.55 135.24,86.85 135.24,78.06 131.17,73.98 131.17,69.59 126.98,65.39 126.98,63 125.98,62 125.98,58.74 125.71,58.47 125.71,57.91 125.94,57.68 125.94,56.71 125.62,56.39 124.87,56.39 v2(124.69,56.22)
  BOTTOM w0.076: CPU1.BF3 138.73,94.77 138.73,94.53 138.57,94.37 138.57,93.3 138.6,93.26 138.62,93.26 138.87,93.02 138.87,92.36 138.84,92.33 138.82,92.33 138.82,92.17 135.57,88.93 135.34,88.93 v2(135.08,88.68)
  BOTTOM w0.107: JDIMM1.55 125.19,58.97
  BOTTOM w0.114: v2(124.69,56.22) 124.9,56.43 125.23,56.43 125.55,56.74 125.55,57.75 125.1,58.21 125.1,58.87 125.19,58.97
DDR_A_DQS3: length 49.8
  IN6 w0.081: v2(130.29,54.95) 130.29,55.01 130.69,55.41 131.34,55.41 131.67,55.74 131.67,58.13 132.2,58.65 132.2,63.44 135.14,66.38 135.14,71.82 139.68,76.35 139.68,86.16 139.44,86.4 139.44,89.56 139.66,89.78 v2(139.95,89.78)
  BOTTOM w0.076: v2(139.95,89.78) 139.95,89.91 140.2,90.16 140.81,90.16 141.21,90.56 141.21,92.05 141.08,92.17 141.08,94.61 CPU1.BC3
  BOTTOM w0.107: JDIMM1.76 130.44,52.83
  BOTTOM w0.114: v2(130.29,54.95) 130.15,55.08 129.93,55.08 129.74,54.9 129.74,53.82 130.33,53.23 130.33,52.94 130.44,52.83
DDR_A_DQS4: length 49.1
  IN6 w0.081: v2(158.09,56.33) 158,56.42 157.86,56.42 157.78,56.35 157.53,56.35 157.28,56.59 157.28,57.81 157.91,58.44 158.16,58.44 158.28,58.57 158.28,58.89 158.16,59.02 157.78,59.02 157.58,59.22 157.58,59.63 157.82,59.87 158.03,59.87 158.2,60.04 158.2,60.35 158.06,60.5 157.92,60.5 157.65,60.77 157.65,63.41 161.26,67.02 161.26,84.66 158,87.92 158,88.05 158,88.49 158.24,88.73 v2(158.24,88.97)
  BOTTOM w0.076: v2(158.24,88.97) 158.41,88.97 159.23,89.78 159.23,90.37 158.52,91.08 158.52,94.59 CPU1.AB3
  BOTTOM w0.114: JDIMM1.179 158.19,58.6 158.7,58.1 158.7,57.92 158.75,57.87 158.75,56.85 158.44,56.54 158.3,56.54 v2(158.09,56.33)
DDR_A_DQS5: length 49.6
  IN6 w0.081: v2(161.66,89.14) 161.66,88.8 161.53,88.68 161.53,88.42 165.5,84.45 165.5,65.74 163.01,63.24 163.01,59.36 162.79,59.14 162.79,58.34 163.06,58.07 163.34,58.07 163.53,57.87 163.53,57.57 163.44,57.48 163.15,57.48 162.9,57.23 162.9,56.62 162.56,56.29 162.56,55.56 162.81,55.31 163.27,55.31 v2(163.51,55.07)
  BOTTOM w0.076: CPU1.V3 160.94,94.89 161.04,94.8 161.04,92.57 162.15,91.46 162.15,89.31 161.97,89.14 v2(161.66,89.14)
  BOTTOM w0.107: JDIMM1.200 163.44,52.83 163.32,52.95
  BOTTOM w0.114: v2(163.51,55.07) 163.37,55.21 163.07,55.21 162.96,55.1 162.96,53.71 163.32,53.35 163.32,52.95
DDR_A_DQS6: length 50
  IN6 w0.081: v2(169.02,56.98) 168.75,56.7 168.74,56.7 168.08,56.7 167.91,56.87 167.91,57.23 168.02,57.35 168.36,57.35 168.58,57.57 168.58,58 168.36,58.23 168.16,58.23 168.06,58.33 168.06,62.07 169.74,63.75 169.74,85.46 168.09,87.1 168.09,87.38 165.84,89.63 165.59,89.63 165.43,89.48 v2(165.13,89.48)
  BOTTOM w0.076: CPU1.R3 163.33,94.96 163.57,94.96 163.64,94.88 163.64,94.79 163.55,94.7 163.55,93.12 166.15,90.52 166.15,90.08 165.55,89.48 v2(165.13,89.48)
  BOTTOM w0.107: 168.85,56.8 v2(169.02,56.98)
  BOTTOM w0.114: JDIMM1.221 168.69,58.99 168.59,58.89 168.59,58.05 168.1,57.56 168.1,56.92 168.22,56.8 168.85,56.8
DDR_A_DQS7: length 50
  IN6 w0.081: v2(167.86,92.36) 167.86,92.7 167.98,92.82 169.05,92.82 174.01,87.86 174.01,55.49 174.28,55.23 174.52,55.23 v2(174.74,55.01)
  BOTTOM w0.076: v2(167.86,92.36) 167.79,92.42 166.84,92.42 166.06,93.2 166.06,94.59 CPU1.M3
  BOTTOM w0.107: JDIMM1.242 173.94,52.79
  BOTTOM w0.114: 173.94,52.79 173.87,52.86 173.87,53.63 174.06,53.82 174.06,54.98 174.26,55.18 174.57,55.18 v2(174.74,55.01)
DDR_A_DQS#0: length 57.2
  IN6 w0.081: v2(131.14,95.22) 130.87,95.22 130.81,95.28 130.42,95.28 129.99,94.86 129.99,94.79 127.45,92.25 127.45,86.45 125.93,84.92 125.93,81.82 121.22,77.11 121.22,72.15 116.23,67.15 116.23,65.82 115.79,65.37 115.16,65.37 114.64,64.86 114.64,60.58 114.53,60.47 114.16,60.47 113.94,60.24 113.94,59.8 114.15,59.59 114.57,59.59 114.66,59.5 114.66,59.18 114.56,59.08 114.16,59.08 113.94,58.87 113.94,58.41 114.17,58.18 114.55,58.18 114.64,58.08 114.64,56.73 114.5,56.59 114.34,56.59 114.07,56.85 v2(114.07,56.86)
  BOTTOM w0.076: v2(131.14,95.22) 131.14,95.51 131.33,95.69 131.53,95.69 131.76,95.92 132.7,95.92 132.84,96.07 133.13,96.07 133.49,95.71 133.49,95.55 133.39,95.46 132.97,95.46 132.89,95.53 132.89,95.64 CPU1.BR5
  BOTTOM w0.107: 114.2,56.63 114.07,56.76 v2(114.07,56.86) ; 114.32,58.84 114.19,58.97 JDIMM1.11
  BOTTOM w0.114: 114.32,58.84 114.32,58.69 114.32,58.68 114.32,58.48 114.57,58.22 114.57,56.8 114.37,56.6 114.28,56.6 114.25,56.63 114.2,56.63
DDR_A_DQS#1: length 54.4
  IN6 w0.081: v2(132.72,90.98) 132.42,90.98 132.25,91.14 131.92,91.14 131.02,90.25 131.02,80.6 126.71,76.29 126.71,72.26 120.54,66.09 120.54,60.81 119.26,59.53 119.26,57.91 119.72,57.44 119.72,55.5 119.63,55.41 119.37,55.41 v2(119.19,55.59)
  BOTTOM w0.076: CPU1.BL3 135.76,94.89 135.9,94.75 135.9,94.07 136.28,93.69 136.28,93.38 133.6,90.7 132.87,90.7 132.72,90.84 v2(132.72,90.98)
  BOTTOM w0.107: JDIMM1.32 119.44,52.73
  BOTTOM w0.114: v2(119.19,55.59) 119.01,55.4 118.68,55.4 118.37,55.09 118.37,54.07 118.88,53.56 119.26,53.56 119.58,53.25 119.58,52.86 119.44,52.73
DDR_A_DQS#2: length 51.3
  IN6 w0.081: v2(135.08,89.31) 134.84,89.07 134.61,89.07 134.38,88.84 134.38,87.49 135.09,86.78 135.09,78.12 131.01,74.05 131.01,69.65 126.82,65.46 126.82,63.06 125.82,62.06 125.82,58.81 125.55,58.54 125.55,57.84 125.78,57.61 125.78,56.77 125.56,56.55 124.99,56.55 v2(124.69,56.86)
  BOTTOM w0.076: v2(135.08,89.31) 135.29,89.1 135.51,89.1 138.65,92.24 138.65,92.93 138.4,93.17 138.4,94.44 138.55,94.59 138.55,95 138.47,95.07 138.21,95.07 138.11,94.98 CPU1.BG3
  BOTTOM w0.107: JDIMM1.53 124.69,58.97
  BOTTOM w0.114: 124.69,58.97 124.85,58.82 124.85,58.1 125.3,57.65 125.3,56.84 125.13,56.67 124.87,56.67 v2(124.69,56.86)
DDR_A_DQS#3: length 49.8
  IN6 w0.081: v2(139.95,90.41) 139.95,90.3 139.62,89.97 139.62,89.96 139.28,89.62 139.28,86.33 139.52,86.1 139.52,76.42 134.98,71.88 134.98,66.45 132.04,63.5 132.04,58.72 131.51,58.19 131.51,55.8 131.3,55.59 v2(130.29,55.59)
  BOTTOM w0.076: v2(139.95,90.41) 140.03,90.33 140.75,90.33 141.04,90.63 141.04,91.98 140.92,92.1 140.92,94.59 CPU1.BD3
  BOTTOM w0.107: JDIMM1.74 129.94,52.83
  BOTTOM w0.114: 129.94,52.83 130.08,52.97 130.08,53.13 129.49,53.72 129.49,55 129.83,55.33 130.03,55.33 v2(130.29,55.59)
DDR_A_DQS#4: length 49.1
  IN6 w0.081: v2(158.69,88.44) 158.53,88.6 158.33,88.6 158.15,88.42 158.15,88.05 158.15,87.98 161.41,84.73 161.41,66.96 157.81,63.35 157.81,60.84 157.99,60.66 158.12,60.66 158.36,60.42 158.36,59.98 158.1,59.72 157.89,59.72 157.74,59.57 157.74,59.28 157.85,59.17 158.22,59.17 158.44,58.95 158.44,58.5 158.22,58.28 157.98,58.28 157.44,57.75 157.44,56.66 157.58,56.52 157.71,56.52 158.09,56.9 v2(158.09,56.96)
  BOTTOM w0.076: v2(158.69,88.44) 158.59,88.54 158.59,88.91 159.39,89.71 159.39,90.44 158.69,91.14 158.69,94.61 CPU1.AA3
  BOTTOM w0.107: 158.27,56.79 v2(158.09,56.96) ; JDIMM1.177 157.69,58.97
  BOTTOM w0.114: 158.27,56.79 158.33,56.79 158.5,56.95 158.5,57.77 158.45,57.82 158.45,58 157.93,58.52 157.93,58.74 157.69,58.97
DDR_A_DQS#5: length 49.7
  IN6 w0.081: v2(163.51,55.71) 163.27,55.47 162.87,55.47 162.72,55.62 162.72,56.22 163.06,56.56 163.06,57.17 163.22,57.33 163.51,57.33 163.69,57.51 163.69,57.94 163.4,58.22 163.13,58.22 162.95,58.4 162.95,59.07 163.16,59.29 163.16,63.18 165.66,65.68 165.66,84.52 161.69,88.49 161.69,88.61 161.77,88.69 v2(162.11,88.69)
  BOTTOM w0.076: v2(162.11,88.69) 162.11,89.04 162.31,89.24 162.31,91.53 161.2,92.64 161.2,94.61 CPU1.U3
  BOTTOM w0.107: 163.27,55.47 v2(163.51,55.71) ; JDIMM1.198 162.94,52.83
  BOTTOM w0.114: 162.94,52.83 163.08,52.96 163.08,53.25 162.71,53.61 162.71,55.2 162.97,55.46 163.26,55.46 163.27,55.47
DDR_A_DQS#6: length 50
  IN6 w0.081: v2(169.02,56.34) 168.82,56.54 168.81,56.54 168.81,56.54 168.02,56.54 167.73,56.83 167.73,57.3 167.95,57.52 168.31,57.52 168.43,57.64 168.43,57.93 168.31,58.05 168.11,58.05 167.9,58.26 167.9,62.14 169.58,63.82 169.58,85.39 167.94,87.04 167.94,87.31 165.77,89.48 165.65,89.48 165.58,89.4 v2(165.58,89.03)
  BOTTOM w0.076: CPU1.P3 163.71,94.61 163.71,93.19 166.32,90.59 166.32,90.01 165.58,89.27 v2(165.58,89.03)
  BOTTOM w0.114: v2(169.02,56.34) 168.81,56.55 168.11,56.55 167.85,56.81 167.85,57.66 168.35,58.15 168.35,58.9 168.19,59.05 JDIMM1.219
DDR_A_DQS#7: length 50
  IN6 w0.081: v2(167.41,92.81) 167.74,92.81 167.91,92.98 169.11,92.98 174.17,87.92 174.17,55.56 174.33,55.4 174.5,55.4 v2(174.74,55.65)
  BOTTOM w0.076: v2(167.41,92.81) 167.41,92.7 167.3,92.59 166.91,92.59 166.23,93.27 166.23,94.61 CPU1.L3
  BOTTOM w0.107: JDIMM1.240 173.44,52.82 173.58,52.96
  BOTTOM w0.114: v2(174.74,55.65) 174.52,55.43 174.16,55.43 173.82,55.08 173.82,53.92 173.63,53.73 173.63,53 173.58,52.96
DDR_A_MA0: length 48
  IN6 w0.089: v2(152.31,89.23) 152.01,89.23 151.77,89 151.77,88.49 152.04,88.22 152.04,85.94 152.41,85.57 152.41,84.8 152.65,84.57 152.65,83.85
  IN6 w0.13: v2(148.86,55.45) 147.74,56.57 147.74,59.18 147.88,59.32 147.88,66.17 152.65,70.93 152.65,83.85
  BOTTOM w0.076: v2(152.31,89.23) 153.15,89.23 153.48,89.56 153.48,94.61 CPU1.AH3
  BOTTOM w0.175: v2(148.86,55.45) 147.44,54.04 JDIMM1.144
DDR_A_MA1: length 43.4
  IN6 w0.13: v2(144.04,57.87) 144.04,60.05 144.91,60.92 144.91,62.5 144.79,62.63 144.79,67.42 148.94,71.57 148.94,83.85
  IN6 w0.152: 148.94,83.85 148.94,85.73 148.83,85.84 148.83,89.37 v2(147.3,90.91)
  BOTTOM w0.076: v2(147.3,90.91) 147.85,91.46 147.85,93.21 147.73,93.34 147.73,94.2 147.88,94.35 147.88,95.24 CPU1.AP4
  BOTTOM w0.175: v2(144.04,57.87) 144.69,58.52 JDIMM1.133
DDR_A_MA2: length 48
  IN6 w0.13: v2(145.62,55.58) 144.96,56.24 144.96,59.67 145.83,60.53 145.83,62.88 145.7,63.01 145.7,67.04 150.38,71.72 150.38,79.73 149.86,80.25 149.86,83.85
  IN6 w0.152: v2(149.4,95.21) 148.92,94.72 148.92,91.73 149.74,90.9 149.74,86.01 149.86,85.89 149.86,83.85
  BOTTOM w0.076: CPU1.AN4 149.08,95.54 v2(149.4,95.21)
  BOTTOM w0.175: JDIMM1.132 144.44,53.23 144.67,53.45 144.67,54.64 v2(145.62,55.58)
DDR_A_MA3: length 47.6
  IN6 w0.13: 149.4,83.85 149.4,80.06 149.92,79.54 149.92,71.9 145.25,67.23 145.25,62.82 145.37,62.69 145.37,60.72 144.5,59.86 144.5,57.06 v2(144.04,56.6)
  IN6 w0.152: 149.4,83.85 149.4,85.72 149.36,85.76 149.36,89.47 v2(147.3,91.54)
  BOTTOM w0.076: v2(147.3,91.54) 147.67,91.92 147.67,92.42 147.56,92.53 147.56,94.34 147.62,94.41 147.62,95.64 CPU1.AP5
  BOTTOM w0.175: JDIMM1.131 144.19,58.7 143.47,57.97 143.47,57.18 v2(144.04,56.6)
DDR_A_MA4: length 47.1
  IN6 w0.13: v2(144.05,54.11) 143.29,54.11 142.65,54.75 142.65,59.96 143.49,60.8 143.49,62.6 143.87,62.98 143.87,67.8 148.02,71.95 148.02,83.85
  IN6 w0.152: v2(147.3,89.51) 146.9,89.12 146.9,88.08 147.92,87.06 147.92,85.86 148.02,85.76 148.02,83.85
  BOTTOM w0.076: v2(147.3,89.51) 147.72,89.94 147.72,90.86 148.05,91.19 148.05,93.31 147.89,93.47 147.89,93.96 CPU1.AP2
  BOTTOM w0.175: v2(144.05,54.11) 143.44,53.5 JDIMM1.128
DDR_A_MA5: length 46.1
  IN6 w0.13: v2(144.05,55.33) 143.11,56.26 143.11,59.76 143.95,60.61 143.95,62.41 144.33,62.79 144.33,67.61 148.48,71.76 148.48,83.85
  IN6 w0.152: v2(147.33,88.88) 148.38,87.83 148.38,85.79 148.48,85.68 148.48,83.85
  BOTTOM w0.076: CPU1.AP1 148.26,93.5 148.26,90.94 147.97,90.65 147.97,89.47 147.38,88.88 v2(147.33,88.88)
  BOTTOM w0.175: JDIMM1.126 142.94,54.84 143.43,55.33 v2(144.05,55.33)
DDR_A_MA6: length 48.4
  IN6 w0.13: v2(141.72,56.52) 142.19,56.99 142.19,60.15 143.03,60.99 143.03,62.79 143.42,63.17 143.42,63.58 143.26,63.73 143.09,63.73 142.94,63.88 142.94,64.19 143.09,64.34 143.26,64.34 143.42,64.49 143.42,67.99 147.56,72.14 147.56,83.85
  IN6 w0.152: v2(146.16,88.13) 147.47,86.82 147.47,85.81 147.56,85.71 147.56,83.85
  BOTTOM w0.076: CPU1.AP3 148.45,94.61 148.45,93.29 148.49,93.26 148.49,90.66 148.28,90.45 148.28,88.73 147.44,87.89 146.4,87.89 v2(146.16,88.13)
  BOTTOM w0.175: JDIMM1.127 143.19,58.6 142.98,58.39 142.98,57.47 142.03,56.52 v2(141.72,56.52)
DDR_A_MA7: length 49
  IN6 w0.13: 146.64,83.85 146.64,73.54 143.06,69.95 143.06,69.73 143.33,69.45 143.33,69.23 143.11,69.02 142.9,69.02 142.62,69.29 142.4,69.29 142.02,68.92 142.02,68.61 142.15,68.49 142.35,68.49 142.5,68.33 142.5,68.03 142.38,67.9 142.19,67.9 142.02,67.74 142.02,63.12 141.27,62.37 141.27,62.15 141.43,61.99 141.59,61.99 141.74,61.84 141.74,61.53 141.59,61.38 141.41,61.38 141.26,61.23 141.26,55.33 141.42,55.17 v2(141.72,55.17)
  IN6 w0.152: 146.64,83.85 146.64,86 146.42,86.22 v2(146.16,86.22)
  BOTTOM w0.076: CPU1.AN1 148.91,88.45 146.68,86.22 v2(146.16,86.22)
  BOTTOM w0.175: v2(141.72,55.17) 142.07,55.17 142.26,54.98 142.26,53.39 141.94,53.07 JDIMM1.122
DDR_A_MA8: length 49.2
  IN6 w0.13: v2(141.73,57.88) 141.73,60.33 142.57,61.17 142.57,62.8 142.48,62.9 142.48,64.63 142.63,64.78 142.81,64.78 142.96,64.94 142.96,65.24 142.81,65.39 142.63,65.39 142.48,65.54 142.48,65.85 142.63,66 142.81,66 142.96,66.15 142.96,66.46 142.81,66.61 142.63,66.61 142.48,66.76 142.48,67.13 142.63,67.28 142.81,67.28 142.96,67.43 142.96,68.21 144.09,69.34 144.09,69.56 143.82,69.83 143.82,70.06 144.13,70.38 144.35,70.38 144.61,70.11 144.83,70.11 145.05,70.33 145.05,70.55 144.79,70.81 144.79,71.03 145.01,71.25 145.23,71.25 145.52,70.96 145.74,70.96 145.96,71.18 145.96,71.4 145.66,71.69 145.66,71.91 145.88,72.13 146.1,72.13 146.4,71.83 146.61,71.83 146.84,72.06 146.84,72.27 146.54,72.57 146.54,72.79 147.1,73.35 147.1,83.85
  IN6 w0.152: v2(146.16,86.86) 146.8,86.86 147.1,86.56 147.1,83.85
  BOTTOM w0.076: v2(146.16,86.86) 146.87,86.86 148.69,88.68 148.69,93.29 148.63,93.35 148.63,94.61 CPU1.AN3
  BOTTOM w0.175: v2(141.73,57.88) 142.26,57.88 142.5,58.12 142.5,58.65 142.69,58.84 JDIMM1.125
DDR_A_MA9: length 46.7
  IN6 w0.13: v2(139.85,56.39) 140.34,56.88 140.34,62.74 141.1,63.5 141.1,69.3 145.72,73.92 145.72,83.85
  IN6 w0.152: 145.72,83.85 145.72,94.1 v2(146.84,95.21)
  BOTTOM w0.076: v2(146.84,95.21) 146.51,95.54 CPU1.AT4
  BOTTOM w0.175: JDIMM1.121 141.69,58.9 141.29,58.5 141.29,57.83 v2(139.85,56.39)
DDR_A_MA10: length 46.5
  IN6 w0.089: 154.22,83.85 154.22,84.77 153.12,85.87 153.12,90.64 152.68,91.07 v2(152.31,91.07)
  IN6 w0.13: 154.22,83.85 154.22,70.28 150.46,66.52 150.46,63.18 149.47,62.18 149.47,54.54 v2(148.86,53.93)
  BOTTOM w0.076: CPU1.AH2 152.91,93.94 152.91,91.67 v2(152.31,91.07)
  BOTTOM w0.175: JDIMM1.146 149.94,52.84 v2(148.86,53.93)
DDR_A_MA11: length 50.3
  IN6 w0.13: 146.18,83.85 146.18,73.73 141.56,69.11 141.56,63.31 140.8,62.55 140.8,53.13 140.93,53 142.35,53 142.5,53.16 142.5,53.82 142.35,53.98 v2(141.73,53.98)
  IN6 w0.152: v2(146.16,84.95) 146.18,84.93 146.18,83.85
  BOTTOM w0.076: v2(146.16,84.95) 149.2,87.99 149.2,93.94 CPU1.AN2
  BOTTOM w0.175: v2(141.73,53.98) 141.44,53.69 JDIMM1.120
DDR_A_MA12: length 47.5
  IN6 w0.13: 145.26,83.85 145.26,74.11 140.64,69.49 140.64,63.69 140.09,63.13 139.79,63.13 139.45,62.79 139.45,60.89 139.6,60.73 139.73,60.73 139.88,60.58 139.88,60.27 139.73,60.11 139.6,60.11 139.45,59.96 139.45,59.65 139.6,59.49 139.73,59.49 139.88,59.34 139.88,59.03 139.73,58.87 139.6,58.87 139.45,58.72 139.45,57.9 139.6,57.74 v2(139.85,57.74)
  IN6 w0.152: 145.26,83.85 145.26,85.85 145.42,86.01 145.42,92.3 145.15,92.57 v2(144.46,92.57)
  BOTTOM w0.076: CPU1.AU4 145.42,95.54 145.21,95.32 145.21,92.4 144.98,92.17 144.75,92.17 144.46,92.45 v2(144.46,92.57)
  BOTTOM w0.175: v2(139.85,57.74) 140.03,57.56 140.34,57.56 140.81,58.03 140.81,58.53 141.19,58.92 JDIMM1.119
DDR_A_MA13: length 51.4
  IN6 w0.13: 159.1,83.85 159.1,67.95 154.87,63.73 154.87,58.99 154.71,58.83 154.71,55.45 155.46,54.71 155.46,53.27 155.3,53.11 154.83,53.11 154.67,53.27 154.67,53.79 154.52,53.94 154.21,53.94 154.05,53.79 154.05,53.27 153.9,53.11 v2(153.45,53.11)
  IN6 w0.152: v2(154.82,89.86) 155.41,89.86 155.71,89.57 155.71,87.73 159.1,84.34 159.1,83.85
  BOTTOM w0.076: CPU1.AE3 155.99,94.61 155.99,91.03 v2(154.82,89.86)
  BOTTOM w0.175: JDIMM1.158 152.94,52.64 153.41,53.11 v2(153.45,53.11)
DDR_A_PAR: length 50
  IN6 w0.089: v2(152.29,88.61) 152.6,88.61 152.76,88.45 152.76,85.06 153.2,84.62 153.2,83.85
  IN6 w0.13: v2(148.86,56.97) 148.3,57.53 148.3,58.78 148.44,58.93 148.44,65.94 153.2,70.7 153.2,83.85
  BOTTOM w0.076: v2(152.29,88.61) 151.9,88.61 151.65,88.36 151.65,87.66 151.84,87.47 152.6,87.47 153.64,88.52 153.64,94.59 CPU1.AG3
  BOTTOM w0.175: v2(148.86,56.97) 148.43,56.55 147.52,56.55 147.19,56.87 JDIMM1.143
DDR_A_RAS#: length 48.9
  IN6 w0.089: v2(154.38,95.74) 153.47,94.83 153.47,86.28 155.14,84.62 155.14,83.85
  IN6 w0.13: 155.14,83.85 155.14,69.89 151.38,66.14 151.38,62.8 150.92,62.34 150.92,61.97 150.38,61.43 150.38,55.72 v2(150.91,55.2)
  BOTTOM w0.076: CPU1.AH4 153.51,95.85 154.27,95.85 v2(154.38,95.74)
  BOTTOM w0.175: JDIMM1.152 151.44,53.24 151.66,53.45 151.66,54.45 v2(150.91,55.2)
DDR_A_WE#: length 50.5
  IN6 w0.089: 155.59,83.85 155.59,84.54 153.65,86.48 153.65,94.41 v2(154.38,95.14)
  IN6 w0.13: 155.59,83.85 155.59,68.63 155.39,68.42 155.16,68.42 154.85,68.73 154.63,68.73 154.41,68.51 154.41,68.3 154.73,67.97 154.73,67.76 154.51,67.54 154.29,67.54 153.98,67.85 153.74,67.85 153.53,67.64 153.53,67.42 153.85,67.1 153.85,66.88 153.63,66.66 153.41,66.66 153.11,66.96 152.85,66.96 152.65,66.76 152.65,66.54 152.97,66.22 152.97,66 152.75,65.78 152.54,65.78 152.28,66.04 152.06,66.04 151.84,65.82 151.84,65.6 152.09,65.35 152.09,65.12 151.84,64.87 151.84,62.61 151.38,62.15 151.38,60.83 151.22,60.67 151,60.67 150.84,60.52 150.84,60.21 151,60.05 151.22,60.05 151.38,59.9 151.38,59.62 151.22,59.46 151,59.46 150.84,59.31 150.84,59 151,58.84 151.22,58.84 151.38,58.69 151.38,58.4 151.22,58.24 v2(150.91,58.24)
  BOTTOM w0.076: v2(154.38,95.14) 154.35,95.17 153.56,95.17 153.49,95.24 153.49,95.46 153.56,95.54 CPU1.AG4
  BOTTOM w0.175: v2(150.91,58.24) 151.18,57.98 151.43,57.98 151.61,58.16 151.61,58.81 151.19,59.22 JDIMM1.151
DDR_B_ACT#: length 67.1
  IN1 w0.089: 141.91,83.85 141.91,84.46 143.9,86.46 143.9,90.01 145.34,91.45 145.34,97.72 v2(146.09,98.47)
  IN1 w0.13: 141.91,83.85 141.91,81.53 136.29,75.92 136.29,63.04 136.08,62.83 136.08,59.98 135.49,59.39 135.49,51.21 135.07,50.79 135.07,43.99 v2(136.66,42.4)
  BOTTOM w0.076: v2(146.09,98.47) CPU1.AT9
  BOTTOM w0.175: v2(136.66,42.4) 137.42,42.4 139.94,39.88 JDIMM2.114
DDR_B_ALERT#: length 65
  IN1 w0.089: v2(147.92,98.47) 147.73,98.28 147.73,97.31 147.57,97.15 147.47,97.05 147.47,92.95 146.31,91.79 146.31,89.13 145.04,87.86 145.04,86.01 144.18,85.14 144.18,83.85
  IN1 w0.13: v2(139.72,42.3) 138.68,43.34 138.68,46.19 138.15,46.72 138.15,58.63 138.66,59.14 138.66,75.08 144.18,80.59 144.18,83.85
  BOTTOM w0.076: v2(147.92,98.47) CPU1.AR8
  BOTTOM w0.175: JDIMM2.116 140.44,41.58 v2(139.72,42.3)
DDR_B_BG0: length 62.9
  IN1 w0.089: v2(147.02,98.48) 147.25,98.48 147.46,98.26 147.46,97.3 147.39,97.23 147.29,97.13 147.29,93.07 145.99,91.77 145.99,89.05 144.79,87.85 144.79,86.35 143.39,84.95 143.39,83.85
  IN1 w0.13: 143.39,83.85 143.39,80.92 137.77,75.3 137.77,62.42 137.56,62.22 137.56,59.36 136.97,58.78 136.97,46.08 v2(138.12,44.94)
  BOTTOM w0.076: v2(147.02,98.48) 147.34,98.8 CPU1.AR9
  BOTTOM w0.175: JDIMM2.115 140.19,46.14 139.09,45.03 138.2,45.03 v2(138.12,44.94)
DDR_B_BG1: length 64.6
  IN1 w0.089: v2(146.88,97.11) 145.81,96.04 145.81,89.26 144.53,87.98 144.53,86.35 142.93,84.74 142.93,83.85
  IN1 w0.13: v2(138.13,43.67) 136.51,45.29 136.51,58.97 137.1,59.55 137.1,62.41 137.31,62.62 137.31,75.49 142.93,81.11 142.93,83.85
  BOTTOM w0.076: CPU1.AR7 147.27,97.5 v2(146.88,97.11)
  BOTTOM w0.175: v2(138.13,43.67) 137.42,44.38 137.42,45.22 137.71,45.51 138.85,45.51 139.69,46.36 JDIMM2.113
DDR_B_BS0: length 67.7
  IN1 w0.089: v2(153.41,98.47) 153.81,98.07 153.81,97.68 153.66,97.54 153.66,94.13 154.07,93.72 154.07,86.82 155.24,85.65 155.24,83.85
  IN1 w0.13: 155.24,83.85 155.24,74.3 149.71,68.77 149.71,59.85 150.3,59.26 150.3,51.05 150.15,50.9 149.43,50.9 149.28,50.74 149.28,50.31 149.43,50.15 149.8,50.15 149.96,50 149.96,49.69 149.8,49.53 149.43,49.53 149.28,49.38 149.28,46.22 149.37,46.13 149.37,42.88 149.52,42.72 149.9,42.72 150.05,42.57 150.05,42.26 149.9,42.1 149.52,42.1 149.37,41.95 149.37,41.65 149.52,41.5 150.62,41.5 v2(150.99,41.13)
  BOTTOM w0.076: v2(153.41,98.47) CPU1.AH8
  BOTTOM w0.175: v2(150.99,41.13) 150.94,41.08 JDIMM2.150
DDR_B_BS1: length 67.5
  IN1 w0.089: v2(152.49,98.44) 152.93,98.44 153.04,98.33 153.04,96.99 153.31,96.73 153.31,93.98 153.68,93.61 153.68,86.14 154.32,85.5 154.32,83.85
  IN1 w0.13: 154.32,83.85 154.32,76.39 154.17,76.23 153.89,76.23 153.74,76.08 153.74,75.77 153.89,75.61 154.17,75.61 154.32,75.46 154.32,74.68 150,70.36 149.78,70.36 149.25,70.89 149.03,70.89 148.77,70.62 148.77,70.41 149.3,69.88 149.3,69.69 148.71,69.1 148.71,59.42 149.29,58.84 149.29,52.19 148.36,51.26 148.36,45.81 v2(148.47,45.7)
  BOTTOM w0.076: v2(152.49,98.44) 152.85,98.8 CPU1.AH9
  BOTTOM w0.175: v2(148.47,45.7) 148.15,45.7 148,45.85 148,47.99 148.18,48.17 148.67,48.17 148.85,47.99 148.85,46.14 149.03,45.96 149.52,45.96 149.69,46.14 JDIMM2.145
DDR_B_CAS#: length 70.4
  IN1 w0.089: 157.74,83.85 157.74,86.27 156.04,87.96 156.04,93.92 155.2,94.76 155.2,97.33 154.85,97.68 154.85,98.1 v2(155.24,98.48)
  IN1 w0.13: 157.74,83.85 157.74,73.25 152.21,67.72 152.21,62.71 152.86,62.07 152.86,61.17 153.31,60.72 153.31,60.5 153.05,60.25 153.05,60.03 153.27,59.81 153.49,59.81 153.75,60.07 153.97,60.07 154.39,59.64 154.39,58.13 154.24,57.97 153.94,57.97 153.78,57.82 153.78,57.51 153.94,57.35 154.24,57.35 154.39,57.2 154.39,56.89 154.24,56.73 153.94,56.73 153.78,56.58 153.78,56.27 153.94,56.12 154.24,56.12 154.39,55.96 154.39,52.32 153.13,51.05 153.13,49.32 152.29,48.48 152.29,41.81 152.64,41.45 153.18,41.45 v2(153.61,41.89)
  BOTTOM w0.076: v2(155.24,98.48) CPU1.AF8
  BOTTOM w0.175: v2(153.61,41.89) 153.52,41.89 152.44,40.82 JDIMM2.156
DDR_B_D0: length 73.2
  IN1 w0.081: v2(112.06,45.39) 112.06,48.57 111.72,48.91 111.72,50.52 112.27,51.07 112.27,51.48 112.37,51.58 112.97,51.58 113.06,51.68 113.06,51.87 112.97,51.97 112.37,51.97 112.27,52.07 112.27,52.27 112.37,52.37 112.97,52.37 113.06,52.47 113.06,52.67 112.97,52.76 112.37,52.76 112.27,52.86 112.27,53.06 112.37,53.16 112.97,53.16 113.06,53.26 113.06,53.46 112.97,53.56 112.37,53.56 112.27,53.66 112.27,59.01 112.37,59.11 112.97,59.11 113.06,59.21 113.06,59.41 112.97,59.51 112.37,59.51 112.27,59.61 112.27,59.81 112.37,59.91 112.97,59.91 113.06,60.01 113.06,60.2 112.97,60.3 112.37,60.3 112.27,60.4 112.27,63.48 118.61,69.82 118.61,81.62 126.92,89.93 126.92,96.49 129.74,99.31 129.74,99.52 130.17,99.95 130.44,99.95 v2(130.45,99.94)
  BOTTOM w0.076: CPU1.BT11 131.62,100.04 131.46,99.88 130.52,99.88 130.46,99.94 v2(130.45,99.94)
  BOTTOM w0.114: JDIMM2.3 112.19,45.53 v2(112.06,45.39)
DDR_B_D1: length 73.2
  IN1 w0.081: v2(112.06,42.85) 112.53,43.33 112.53,50.63 113.37,51.47 113.37,58.45 113.47,58.55 113.65,58.55 113.75,58.65 113.75,58.84 113.65,58.94 113.47,58.94 113.37,59.04 113.37,59.24 113.47,59.34 113.65,59.34 113.75,59.44 113.75,59.64 113.65,59.74 113.47,59.74 113.37,59.84 113.37,60.03 113.47,60.13 113.65,60.13 113.75,60.23 113.75,60.43 113.65,60.53 113.47,60.53 113.37,60.63 113.37,62.98 118.91,68.52 118.91,81.49 127.22,89.8 127.22,96.39 129.74,98.91 v2(129.95,98.91)
  BOTTOM w0.076: CPU1.BR11 132.77,100.04 132.47,99.73 131.54,99.73 131.44,99.63 131.16,99.63 130.43,98.91 v2(129.95,98.91)
  BOTTOM w0.114: JDIMM2.8 113.44,41.47 v2(112.06,42.85)
DDR_B_D2: length 72.9
  IN1 w0.081: v2(130.17,97.31) 130.35,97.13 130.35,96.58 129.29,95.52 129.29,89.75 120.6,81.05 120.6,67.55 116.34,63.3 116.34,61.04 116.05,60.75 115.54,60.75 115.44,60.65 115.44,60.39 115.54,60.29 115.97,60.29 116.06,60.19 116.06,59.96 115.97,59.86 115.54,59.86 115.44,59.76 115.44,59.57 115.54,59.47 115.97,59.47 116.06,59.37 116.06,59.17 115.97,59.07 115.54,59.07 115.44,58.97 115.44,58.77 115.54,58.68 115.97,58.68 116.06,58.58 116.06,53.67 115.97,53.57 115.54,53.57 115.44,53.47 115.44,53.27 115.54,53.17 115.97,53.17 116.06,53.07 116.06,52.87 115.97,52.78 115.54,52.78 115.44,52.68 115.44,52.48 115.54,52.38 115.97,52.38 116.06,52.28 116.06,52 115.07,51 115.07,50.35 114.94,50.23 114.94,46.3 114.64,46 114.64,41.9 v2(115.34,41.2)
  BOTTOM w0.076: v2(130.17,97.31) 130.21,97.27 130.44,97.27 130.62,97.45 130.84,97.45 130.91,97.53 131.03,97.53 131.5,97.99 132.11,97.99 CPU1.BT8
  BOTTOM w0.114: JDIMM2.16 115.45,41.1 v2(115.34,41.2)
DDR_B_D3: length 73.2
  IN1 w0.081: v2(115.34,43.74) 114.94,44.14 114.94,45.87 115.24,46.18 115.24,46.77 115.37,46.9 115.91,46.9 116,46.99 116,47.22 115.9,47.31 115.34,47.31 115.24,47.41 115.24,47.61 115.34,47.71 115.56,47.71 115.66,47.81 115.66,48.01 115.56,48.11 115.34,48.11 115.24,48.21 115.24,48.4 115.34,48.5 115.56,48.5 115.66,48.6 115.66,49.02 115.76,49.12 116.27,49.12 116.37,49.22 116.37,49.46 116.27,49.55 115.34,49.55 115.24,49.65 115.24,49.92 115.34,50.01 116.27,50.01 116.37,50.11 116.37,50.75 116.27,50.85 115.8,50.85 115.71,50.95 115.71,51.15 115.8,51.25 116.27,51.25 116.37,51.35 116.37,59.29 116.64,59.57 116.64,63.17 120.9,67.43 120.9,79.52 122.52,81.14 122.52,82.55 129.63,89.66 129.63,95.53 130.64,96.54 130.64,97.59 v2(130.45,97.78)
  BOTTOM w0.076: v2(130.45,97.78) 130.5,97.73 131.01,97.73 131.43,98.16 131.88,98.16 132.29,98.57 132.9,98.57 CPU1.BR8
  BOTTOM w0.114: v2(115.34,43.74) 116.69,45.09 JDIMM2.21
DDR_B_D4: length 73.4
  IN1 w0.081: v2(130.78,100.37) 130.75,100.4 130.36,100.4 129.64,99.68 129.64,99.67 126.62,96.65 126.62,90.05 118.31,81.75 118.31,69.95 111.97,63.61 111.97,51.2 111.42,50.65 111.42,48.64 111.52,48.55 111.66,48.55 111.76,48.45 111.76,48.25 111.66,48.15 111.52,48.15 111.42,48.05 111.42,47.85 111.52,47.75 111.66,47.75 111.76,47.65 111.76,47.46 111.66,47.36 111.52,47.36 111.42,47.26 111.42,47.06 111.52,46.96 111.66,46.96 111.76,46.86 111.76,46.66 111.66,46.56 111.52,46.56 111.42,46.46 111.42,46.27 111.52,46.17 111.66,46.17 111.76,46.07 111.76,45.87 111.66,45.77 111.52,45.77 111.42,45.67 111.42,44.76 v2(112.06,44.12)
  BOTTOM w0.076: v2(130.78,100.37) 130.85,100.37 131.14,100.08 131.43,100.08 131.68,100.33 133.36,100.33 CPU1.BP11
  BOTTOM w0.114: JDIMM2.7 113.19,46.02 112.59,45.41 112.59,44.65 v2(112.06,44.12)
DDR_B_D5: length 73.3
  IN1 w0.081: v2(112.06,41.58) 112.83,42.36 112.83,50.5 113.67,51.34 113.67,57.66 114.05,58.04 114.05,60.74 113.71,61.08 113.71,62.9 119.21,68.4 119.21,81.37 127.52,89.68 127.52,95.8 128.25,96.53 128.25,97.02 129.73,98.5 130.06,98.5 130.55,98.99 130.55,99.51 131.32,100.28 v2(131.32,100.47)
  BOTTOM w0.076: v2(131.32,100.47) 131.38,100.53 133.57,100.53 134.07,100.04 CPU1.BN11
  BOTTOM w0.114: JDIMM2.4 112.44,41.2 v2(112.06,41.58)
DDR_B_D6: length 73.2
  IN1 w0.081: v2(131.2,98.59) 131.27,98.53 131.27,98.33 132.21,97.39 132.21,92.74 130.45,90.98 130.45,90.05 122.82,82.43 122.82,81.02 121.63,79.82 121.63,77.2 121.53,77.11 121.29,77.11 121.2,77.01 121.2,76.82 121.29,76.72 121.53,76.72 121.63,76.62 121.63,76.43 121.53,76.33 121.29,76.33 121.2,76.24 121.2,76.04 121.29,75.95 121.53,75.95 121.63,75.85 121.63,75.66 121.53,75.56 121.29,75.56 121.2,75.46 121.2,75.27 121.29,75.18 121.53,75.18 121.63,75.08 121.63,74.89 121.53,74.79 121.29,74.79 121.2,74.69 121.2,74.5 121.29,74.4 121.53,74.4 121.63,74.31 121.63,74.11 121.53,74.02 121.29,74.02 121.2,73.92 121.2,70.59 121.3,70.49 121.61,70.49 121.71,70.39 121.71,70.19 121.61,70.09 121.3,70.09 121.2,70 121.2,69.8 121.3,69.7 121.61,69.7 121.71,69.6 121.71,69.4 121.61,69.3 121.3,69.3 121.2,69.2 121.2,69 121.3,68.91 121.61,68.91 121.71,68.81 121.71,68.61 121.61,68.51 121.3,68.51 121.2,68.41 121.2,68.21 121.3,68.11 121.61,68.11 121.71,68.01 121.71,67.82 121.61,67.72 121.3,67.72 121.2,67.62 121.2,67.3 116.94,63.05 116.94,59.44 116.67,59.17 116.67,48.07 116.57,47.97 116.06,47.97 115.96,47.87 115.96,47.67 116.06,47.57 116.57,47.57 116.67,47.48 116.67,47.12 115.34,45.8 v2(115.34,45.01)
  BOTTOM w0.076: v2(131.2,98.59) 131.47,98.32 131.82,98.32 132.25,98.75 133.36,98.75 CPU1.BP8
  BOTTOM w0.114: v2(115.34,45.01) 115.69,45.36 JDIMM2.17
DDR_B_D7: length 73.4
  IN1 w0.081: v2(115.34,42.47) 116.16,43.28 116.16,46.19 116.97,47 116.97,59.04 117.24,59.31 117.24,62.92 122.01,67.69 122.01,70.78 121.91,70.88 121.6,70.88 121.5,70.98 121.5,71.18 121.6,71.28 121.91,71.28 122.01,71.38 122.01,71.58 121.91,71.68 121.6,71.68 121.5,71.77 121.5,71.97 121.6,72.07 121.91,72.07 122.01,72.17 122.01,72.37 121.91,72.47 121.6,72.47 121.5,72.57 121.5,72.77 121.6,72.86 121.83,72.86 121.93,72.96 121.93,73.24 121.83,73.34 121.59,73.34 121.5,73.43 121.5,73.63 121.59,73.72 121.83,73.72 121.93,73.82 121.93,79.7 123.12,80.89 123.12,82.25 130.7,89.83 130.7,90.91 132.41,92.61 132.41,97.57 131.78,98.2 131.78,98.76 v2(131.74,98.81)
  BOTTOM w0.076: v2(131.74,98.81) 131.82,98.89 131.84,98.89 131.87,98.92 133.49,98.92 133.66,98.75 134.01,98.75 CPU1.BN8
  BOTTOM w0.114: v2(115.34,42.47) 116.28,41.53 116.28,40.29 116.45,40.12 JDIMM2.20
DDR_B_D8: length 71.4
  IN1 w0.081: v2(135.28,100.43) 135.28,100.06 134.41,99.19 134.41,98.23 132.99,96.8 132.99,92.87 130.89,90.77 130.89,88.99 123.85,81.95 123.85,80.59 122.66,79.39 122.66,73.1 122.87,72.9 123.12,72.9 123.21,72.8 123.21,72.61 123.12,72.51 122.87,72.51 122.77,72.41 122.77,72.15 123.21,71.71 123.21,67.86 118.52,63.17 118.52,59.55 117.88,58.91 117.88,53.78 118.33,53.33 118.33,47.32 116.92,45.91 116.92,41.9 v2(117.63,41.2)
  BOTTOM w0.076: CPU1.BL12 135.61,100.76 v2(135.28,100.43)
  BOTTOM w0.114: v2(117.63,41.2) 117.45,41.01 JDIMM2.24
DDR_B_D9: length 71.5
  IN1 w0.081: v2(136.08,100.42) 136.08,100.31 134.64,98.87 134.64,98.19 133.17,96.73 133.17,92.61 131.13,90.57 131.13,88.81 124.15,81.82 124.15,80.46 122.96,79.26 122.96,74.55 123.51,74 123.51,73.77 123.42,73.68 123.34,73.68 123.26,73.6 123.26,73.37 123.34,73.29 123.42,73.29 123.51,73.19 123.51,67.74 118.82,63.05 118.82,59.42 118.2,58.8 118.2,53.88 118.63,53.45 118.63,47.19 117.23,45.79 117.23,42.87 v2(117.63,42.47)
  BOTTOM w0.076: v2(136.08,100.42) CPU1.BL11
  BOTTOM w0.114: v2(117.63,42.47) 118.45,41.65 JDIMM2.28
DDR_B_D10: length 71.6
  IN1 w0.081: v2(135.28,98.86) 134.87,98.44 134.87,98.15 133.36,96.65 133.36,92.48 131.32,90.44 131.32,88.57 124.45,81.7 124.45,80.33 123.31,79.19 123.31,78.28 123.54,78.05 123.72,78.05 123.81,77.95 123.81,77.76 123.72,77.66 123.35,77.66 123.26,77.56 123.26,77.37 123.35,77.27 123.72,77.27 123.81,77.18 123.81,76.98 123.72,76.89 123.35,76.89 123.26,76.79 123.26,76.6 123.35,76.5 123.72,76.5 123.81,76.41 123.81,76.21 123.72,76.12 123.35,76.12 123.26,76.02 123.26,75.83 123.35,75.73 123.72,75.73 123.81,75.63 123.81,75.44 123.72,75.34 123.35,75.34 123.26,75.25 123.26,74.68 123.81,74.12 123.81,67.61 119.12,62.92 119.12,60.9 119.22,60.81 119.58,60.81 119.68,60.71 119.68,60.52 119.58,60.42 119.22,60.42 119.12,60.32 119.12,60.13 119.22,60.03 119.58,60.03 119.68,59.94 119.68,59.74 119.58,59.65 119.22,59.65 119.12,59.55 119.12,59.3 118.48,58.66 118.48,58.34 118.58,58.24 118.93,58.24 119.03,58.14 119.03,57.95 118.93,57.85 118.58,57.85 118.48,57.75 118.48,57.55 118.58,57.45 118.93,57.45 119.03,57.35 119.03,57.15 118.93,57.05 118.58,57.05 118.48,56.95 118.48,54.02 118.93,53.58 118.93,47.07 117.63,45.76 v2(117.63,45.01)
  BOTTOM w0.076: v2(135.28,98.86) CPU1.BL8
  BOTTOM w0.114: JDIMM2.25 117.69,45.07 v2(117.63,45.01)
DDR_B_D11: length 71.8
  IN1 w0.081: v2(120.59,42.47) 120.99,42.06 120.99,41.66 121.09,41.56 121.7,41.56 121.8,41.66 121.8,41.87 121.7,41.97 121.52,41.97 121.42,42.07 121.42,42.26 121.53,42.37 121.75,42.37 121.85,42.47 121.85,42.69 121.75,42.79 121.52,42.79 121.42,42.89 121.42,43.09 121.52,43.19 121.64,43.19 121.8,43.35 121.8,45.97 122.05,46.21 122.05,58.41 122.24,58.6 122.24,63.06 126.71,67.52 126.71,79.43 132.14,84.86 132.36,84.86 135.47,87.98 135.47,90.34 137.24,92.1 137.24,92.12 137.55,92.43 137.55,96.55 136.54,97.56 136.54,98.07 v2(136.95,98.47)
  BOTTOM w0.076: v2(136.95,98.47) CPU1.BJ8
  BOTTOM w0.114: JDIMM2.42 121.94,41.33 120.81,42.47 v2(120.59,42.47)
DDR_B_D12: length 71.1
  IN1 w0.081: v2(136.95,99.77) 136.53,99.36 136.53,99 136.16,98.63 136.16,96.93 135.59,96.36 135.59,94.77 136.48,93.88 136.48,92.88 133.55,89.95 133.55,87.12 125.32,78.89 125.32,72.18 125.42,72.08 125.76,72.08 125.86,71.99 125.86,71.79 125.76,71.69 125.42,71.69 125.32,71.59 125.32,71.39 125.42,71.29 125.76,71.29 125.86,71.19 125.86,70.99 125.76,70.9 125.42,70.9 125.32,70.8 125.32,70.6 125.42,70.5 125.76,70.5 125.86,70.4 125.86,70.2 125.76,70.1 125.42,70.1 125.32,70 125.32,69.81 125.42,69.71 125.76,69.71 125.86,69.61 125.86,69.41 125.76,69.31 125.42,69.31 125.32,69.21 125.32,69.01 125.42,68.91 125.76,68.91 125.86,68.82 125.86,68.62 125.76,68.52 125.42,68.52 125.32,68.42 125.32,68.22 125.42,68.12 125.76,68.12 125.86,68.02 125.86,67.82 125.76,67.73 125.42,67.73 125.32,67.63 125.32,66.99 121.64,63.31 121.64,58.85 121.45,58.66 121.45,48.04 121.35,47.94 120.96,47.94 120.86,47.84 120.86,47.64 120.96,47.54 121.35,47.54 121.45,47.44 121.45,46.46 120.59,45.61 v2(120.59,45.01)
  BOTTOM w0.076: v2(136.95,99.77) CPU1.BJ11
  BOTTOM w0.114: JDIMM2.37 120.69,45.11 v2(120.59,45.01)
DDR_B_D13: length 71.3
  IN1 w0.081: v2(120.59,43.74) 120.93,43.74 121.23,44.04 121.23,45.82 121.75,46.34 121.75,58.54 121.94,58.73 121.94,63.19 126.16,67.4 126.16,72.45 126.06,72.55 125.72,72.55 125.62,72.65 125.62,72.85 125.72,72.95 126.06,72.95 126.16,73.05 126.16,73.25 126.06,73.34 125.72,73.34 125.62,73.44 125.62,73.64 125.72,73.74 126.06,73.74 126.16,73.84 126.16,74.04 126.06,74.14 125.72,74.14 125.62,74.24 125.62,77.17 125.71,77.27 126.09,77.27 126.18,77.36 126.18,77.55 126.09,77.65 125.71,77.65 125.62,77.75 125.62,77.94 125.71,78.04 126.09,78.04 126.18,78.13 126.18,78.33 126.09,78.42 125.71,78.42 125.62,78.52 125.62,78.77 126.72,79.87 133.87,87.02 133.87,90 136.67,92.8 136.67,93.96 136.38,94.24 136.38,96.26 136.35,96.3 136.35,98.53 v2(136.95,99.12)
  BOTTOM w0.076: v2(136.95,99.12) CPU1.BJ10
  BOTTOM w0.114: v2(120.59,43.74) 121.69,44.84 JDIMM2.41
DDR_B_D14: length 71.3
  IN1 w0.081: v2(117.63,43.74) 118.63,44.74 118.63,46.15 119.23,46.76 119.23,49.5 119.33,49.6 119.5,49.6 119.6,49.7 119.6,49.9 119.5,50 119.33,50 119.23,50.09 119.23,51.1 119.36,51.23 119.5,51.23 119.6,51.33 119.6,51.53 119.5,51.62 119.33,51.62 119.23,51.72 119.23,51.9 119.36,52.02 119.5,52.02 119.6,52.12 119.6,52.32 119.5,52.42 119.33,52.42 119.23,52.51 119.23,52.69 119.36,52.81 119.5,52.81 119.6,52.91 119.6,53.11 119.5,53.21 119.33,53.21 119.23,53.31 119.23,53.7 118.79,54.15 118.79,56.39 119.33,56.93 119.33,58.71 120.04,59.42 120.04,61.6 119.94,61.7 119.52,61.7 119.42,61.8 119.42,61.99 119.52,62.09 119.94,62.09 120.04,62.18 120.04,62.38 119.94,62.47 119.52,62.47 119.42,62.57 119.42,62.76 119.52,62.86 119.94,62.86 120.04,62.96 120.04,63.42 124.11,67.49 124.11,79.45 124.75,80.09 124.75,81.58 132.15,88.97 132.15,89.52 135.28,92.66 135.28,93.74 134.22,94.81 134.22,96.3 135.32,97.41 v2(135.32,98.04)
  BOTTOM w0.076: v2(135.32,98.04) CPU1.BL7
  BOTTOM w0.114: v2(117.63,43.74) 118.69,44.8 JDIMM2.29
DDR_B_D15: length 71.5
  IN1 w0.081: v2(120.59,41.2) 121.76,41.2 122.33,41.77 122.33,50.6 122.45,50.72 122.68,50.72 122.78,50.82 122.78,51.02 122.68,51.11 122.45,51.11 122.35,51.21 122.35,51.41 122.45,51.51 122.68,51.51 122.78,51.61 122.78,51.81 122.68,51.91 122.45,51.91 122.35,52.01 122.35,52.2 122.45,52.3 122.68,52.3 122.78,52.4 122.78,52.6 122.68,52.7 122.45,52.7 122.35,52.8 122.35,53 122.45,53.1 122.47,53.1 122.55,53.18 122.55,58.96 122.64,59.06 122.98,59.06 123.07,59.16 123.07,59.35 122.98,59.45 122.64,59.45 122.55,59.54 122.55,59.74 122.64,59.83 122.98,59.83 123.07,59.93 123.07,60.12 122.98,60.22 122.64,60.22 122.55,60.32 122.55,62.94 127.01,67.4 127.01,79.3 132.33,84.63 132.66,84.63 135.7,87.67 135.7,90.3 137.81,92.41 137.81,96.96 v2(136.95,97.82)
  BOTTOM w0.076: v2(136.95,97.82) CPU1.BJ7
  BOTTOM w0.114: JDIMM2.38 120.94,40.84 v2(120.59,41.2)
DDR_B_D16: length 68.2
  IN1 w0.081: v2(122.95,45.01) 123.66,45.72 123.66,46.27 123.76,46.37 124.2,46.37 124.3,46.46 124.3,46.66 124.2,46.75 123.76,46.75 123.66,46.85 123.66,58.15 124.3,58.78 124.3,60.44 124.2,60.54 123.93,60.54 123.83,60.64 123.83,60.83 123.93,60.93 124.2,60.93 124.3,61.02 124.3,61.25 124.2,61.34 123.93,61.34 123.83,61.44 123.83,61.63 123.93,61.73 124.2,61.73 124.3,61.83 124.3,62.02 124.2,62.11 123.93,62.11 123.83,62.21 123.83,62.4 123.93,62.5 124.2,62.5 124.3,62.6 124.3,63.65 127.74,67.09 127.74,78.87 133.41,84.54 133.41,85.11 136.08,87.79 136.08,90.25 138.34,92.51 138.34,97.16 137.98,97.53 137.98,98.1 138.23,98.35 138.23,99.86 v2(138.78,100.41)
  BOTTOM w0.076: v2(138.78,100.41) CPU1.BG11
  BOTTOM w0.114: JDIMM2.45 122.69,45.26 v2(122.95,45.01)
DDR_B_D17: length 68.6
  IN1 w0.081: v2(138.78,99.77) 138.41,99.41 138.41,98.27 138.16,98.02 138.16,97.6 138.52,97.24 138.52,92.44 136.3,90.22 136.3,87.48 133.7,84.88 133.7,84.41 128.04,78.75 128.04,66.97 124.6,63.52 124.6,58.66 123.99,58.05 123.99,48.06 124.08,47.96 124.31,47.96 124.41,47.87 124.41,47.67 124.31,47.58 124.06,47.58 123.96,47.48 123.96,47.25 124.06,47.15 124.47,47.15 124.6,47.02 124.6,46.14 123.39,44.94 123.39,44.17 v2(122.95,43.74)
  BOTTOM w0.076: v2(138.78,99.77) CPU1.BG10
  BOTTOM w0.114: v2(122.95,43.74) 123.69,44.48 JDIMM2.49
DDR_B_D18: length 68.7
  IN1 w0.081: v2(122.95,42.47) 123.69,43.2 123.69,44.81 124.89,46.02 124.89,47.81 124.32,48.39 124.32,54.6 124.42,54.7 124.73,54.7 124.83,54.8 124.83,54.99 124.73,55.08 124.38,55.08 124.29,55.18 124.29,57.93 124.89,58.53 124.89,63.4 128.34,66.84 128.34,78.62 134.03,84.31 134.03,84.9 136.5,87.37 136.5,90.17 138.7,92.36 138.7,97.31 138.6,97.42 138.37,97.65 138.37,97.93 138.78,98.34 v2(138.78,98.47)
  BOTTOM w0.076: v2(138.78,98.47) CPU1.BG8
  BOTTOM w0.114: JDIMM2.50 123.94,41.63 123.11,42.47 v2(122.95,42.47)
DDR_B_D19: length 68.5
  IN1 w0.081: v2(139.69,98.48) 139.69,98.35 140.06,97.97 140.06,97.51 140.67,96.9 140.67,88.99 135.69,84.01 135.69,83.21 130.17,77.68 130.17,66.01 127.4,63.24 127.4,59.48 127.3,59.38 127.3,59.16 127.4,59.06 127.74,59.06 127.83,58.96 127.83,58.76 127.74,58.66 127.4,58.66 127.3,58.56 127.3,58.37 127.4,58.27 127.74,58.27 127.83,58.17 127.83,57.97 127.74,57.87 127.4,57.87 127.3,57.77 127.3,57.57 127.4,57.47 127.74,57.47 127.83,57.37 127.83,57.18 127.74,57.08 127.4,57.08 127.3,56.98 127.3,56.78 127.4,56.68 127.74,56.68 127.83,56.58 127.83,56.38 127.74,56.28 127.4,56.28 127.3,56.19 127.3,44.41 v2(126.63,43.74)
  BOTTOM w0.076: v2(139.69,98.48) 139.35,98.15 CPU1.BF8
  BOTTOM w0.114: v2(126.63,43.74) 126.19,44.18 JDIMM2.59
DDR_B_D20: length 68.6
  IN1 w0.081: v2(139.69,100.41) 140.24,99.86 140.24,98.37 140.47,98.14 140.47,97.61 141.03,97.05 141.03,88.78 136.3,84.05 136.3,82.95 130.77,77.43 130.77,65.76 128.64,63.63 128.64,59.7 128.44,59.5 128.44,55.04 127.91,54.51 127.91,42.47 v2(126.63,41.2)
  BOTTOM w0.076: v2(139.69,100.41) CPU1.BF11
  BOTTOM w0.114: v2(126.63,41.2) 126.94,40.89 JDIMM2.62
DDR_B_D21: length 68.7
  IN1 w0.081: v2(139.69,99.77) 140.07,99.4 140.07,98.26 140.26,98.06 140.26,97.56 140.85,96.97 140.85,88.92 136,84.06 136,83.08 130.47,77.55 130.47,65.89 128.34,63.76 128.34,59.83 128.14,59.63 128.14,56.26 127.61,55.73 127.61,55.5 127.71,55.4 127.97,55.4 128.07,55.3 128.07,55.11 127.97,55.01 127.71,55.01 127.61,54.91 127.61,43.44 v2(126.63,42.47)
  BOTTOM w0.076: v2(139.69,99.77) CPU1.BF10
  BOTTOM w0.114: JDIMM2.58 125.94,41.78 v2(126.63,42.47)
DDR_B_D22: length 68.2
  IN1 w0.081: v2(122.95,41.2) 124.22,41.2 124.34,41.32 124.34,41.6 124.24,41.69 123.87,41.69 123.77,41.79 123.77,41.99 123.87,42.09 124.29,42.09 124.39,42.19 124.39,42.39 124.29,42.49 124.09,42.49 123.99,42.59 123.99,44.69 125.19,45.9 125.19,63.27 128.64,66.72 128.64,78.5 134.34,84.19 134.34,84.82 136.7,87.19 136.7,90.12 138.89,92.3 138.89,97.71 v2(138.78,97.82)
  BOTTOM w0.076: v2(138.78,97.82) CPU1.BG7
  BOTTOM w0.114: v2(122.95,41.2) 122.94,41.19 JDIMM2.46
DDR_B_D23: length 68.3
  IN1 w0.081: v2(139.69,97.82) 139.69,97.58 140.49,96.78 140.49,89.14 135.39,84.04 135.39,83.33 129.87,77.81 129.87,66.14 127.1,63.37 127.1,60.97 127,60.87 126.6,60.87 126.5,60.77 126.5,60.58 126.6,60.48 127,60.48 127.1,60.39 127.1,60.16 127,60.07 126.6,60.07 126.5,59.97 126.5,59.78 126.6,59.68 126.91,59.68 127,59.59 127,59.39 126.9,59.29 126.6,59.29 126.5,59.19 126.5,58.99 126.6,58.89 126.9,58.89 127,58.79 127,53.51 126.9,53.41 126.71,53.41 126.61,53.31 126.61,53.11 126.71,53.01 126.9,53.01 127,52.92 127,52.72 126.9,52.62 126.71,52.62 126.61,52.52 126.61,52.32 126.71,52.22 126.9,52.22 127,52.12 127,51.92 126.9,51.83 126.71,51.83 126.61,51.73 126.61,51.53 126.71,51.43 126.9,51.43 127,51.33 127,49.91 126.9,49.81 126.71,49.81 126.61,49.72 126.61,49.52 126.71,49.42 126.9,49.42 127,49.32 127,48.1 126.9,48 126.71,48 126.61,47.9 126.61,47.7 126.71,47.6 126.9,47.6 127,47.51 127,47.31 126.9,47.21 126.71,47.21 126.61,47.11 126.61,46.91 126.71,46.81 126.9,46.81 127,46.71 127,46.52 126.9,46.42 126.71,46.42 126.61,46.32 126.61,46.12 126.71,46.02 126.9,46.02 127,45.92 127,45.38 v2(126.63,45.01)
  BOTTOM w0.076: v2(139.69,97.82) CPU1.BF7
  BOTTOM w0.114: JDIMM2.63 127.19,45.57 v2(126.63,45.01)
DDR_B_D24: length 67.9
  IN1 w0.081: v2(132.17,41.2) 133.65,42.68 133.65,53.86 134.27,54.48 134.27,59.9 134.86,60.48 134.86,63.34 135.08,63.56 135.08,76.43 140.17,81.52 140.17,84.25 141.36,85.44 141.87,85.44 143.43,87 143.43,90.12 143.96,90.65 143.96,97.32 142.98,98.3 142.98,99.88 v2(142.43,100.42)
  BOTTOM w0.076: v2(142.43,100.42) CPU1.BB11
  BOTTOM w0.114: JDIMM2.84 132.44,40.92 v2(132.17,41.2)
DDR_B_D25: length 67.6
  IN1 w0.081: v2(129.02,45.01) 129.43,45.42 129.43,51.37 129.53,51.46 130.05,51.46 130.14,51.56 130.14,51.76 130.05,51.86 129.53,51.86 129.43,51.96 129.43,52.16 129.53,52.26 130.05,52.26 130.14,52.36 130.14,52.55 130.05,52.65 129.53,52.65 129.43,52.75 129.43,52.95 129.53,53.05 130.05,53.05 130.14,53.15 130.14,53.35 130.05,53.45 129.53,53.45 129.43,53.55 129.43,63.38 131.5,65.46 131.5,77.12 137.03,82.65 137.03,84.53 141.21,88.71 141.21,97.12 140.8,97.52 140.8,98.12 140.97,98.29 140.97,99.86 v2(141.52,100.41)
  BOTTOM w0.076: v2(141.52,100.41) CPU1.BC11
  BOTTOM w0.114: JDIMM2.67 128.19,45.84 v2(129.02,45.01)
DDR_B_D26: length 68.5
  IN1 w0.081: v2(132.17,43.74) 132.67,43.74 133.05,44.12 133.05,54.11 133.67,54.73 133.67,61.53 133.97,61.84 133.97,65.51 134.07,65.61 134.3,65.61 134.4,65.7 134.4,65.9 134.3,66 134.07,66 133.97,66.1 133.97,66.3 134.07,66.4 134.3,66.4 134.4,66.5 134.4,66.7 134.3,66.79 134.07,66.79 133.97,66.89 133.97,67.09 134.07,67.19 134.3,67.19 134.4,67.29 134.4,67.49 134.3,67.59 134.07,67.59 133.97,67.69 133.97,67.88 134.07,67.98 134.3,67.98 134.4,68.08 134.4,68.28 134.3,68.38 134.07,68.38 133.97,68.48 133.97,68.68 134.07,68.78 134.3,68.78 134.4,68.87 134.4,69.07 134.3,69.17 134.07,69.17 133.97,69.27 133.97,69.47 134.07,69.57 134.3,69.57 134.4,69.67 134.4,69.86 134.3,69.96 134.07,69.96 133.97,70.06 133.97,70.26 134.07,70.36 134.3,70.36 134.48,70.54 134.48,76.68 139.57,81.77 139.57,84.35 142.45,87.23 142.45,89.64 143.61,90.8 143.61,97.17 142.43,98.34 v2(142.43,98.47)
  BOTTOM w0.076: v2(142.43,98.47) CPU1.BB8
  BOTTOM w0.114: JDIMM2.79 131.19,46.14 131.39,45.94 131.39,44.51 v2(132.17,43.74)
DDR_B_D27: length 68.4
  IN1 w0.081: v2(129.02,42.47) 129.32,42.47 129.49,42.31 129.49,41.91 129.58,41.82 129.89,41.82 129.99,41.91 129.99,43.33 130.06,43.4 130.06,46.18 130.75,46.87 130.75,60.34 130.77,60.37 130.77,63.88 132.11,65.22 132.11,76.88 137.63,82.41 137.63,84.25 141.56,88.18 141.56,90.09 142.33,90.86 142.33,96.65 141.59,97.39 141.44,97.39 141.16,97.67 141.16,97.97 141.52,98.33 v2(141.52,98.47)
  BOTTOM w0.076: v2(141.52,98.47) CPU1.BC8
  BOTTOM w0.114: v2(129.02,42.47) 127.94,41.39 JDIMM2.66
DDR_B_D28: length 67.7
  IN1 w0.081: v2(129.02,43.74) 129.75,44.47 129.75,50.58 130.45,51.28 130.45,53.58 129.75,54.28 129.75,57.69 129.86,57.8 130.35,57.8 130.45,57.89 130.45,58.09 130.35,58.19 129.85,58.19 129.73,58.32 129.73,60.43 130.47,61.18 130.47,64 131.81,65.34 131.81,77 137.33,82.53 137.33,84.58 141.38,88.63 141.38,97.19 140.98,97.6 140.98,98.05 141.15,98.22 141.15,99.4 v2(141.52,99.77)
  BOTTOM w0.076: v2(141.52,99.77) CPU1.BC10
  BOTTOM w0.114: JDIMM2.71 129.19,45.86 129.56,45.49 129.56,44.27 v2(129.02,43.74)
DDR_B_D29: length 68.3
  IN1 w0.081: v2(142.43,99.77) 142.8,99.4 142.8,98.22 143.78,97.24 143.78,90.73 142.63,89.57 142.63,87.09 139.87,84.33 139.87,81.65 134.78,76.55 134.78,63.68 134.56,63.46 134.56,61.99 133.97,61.4 133.97,60.97 134.07,60.87 134.4,60.87 134.5,60.77 134.5,60.57 134.4,60.47 134.07,60.47 133.97,60.38 133.97,54.6 133.35,53.98 133.35,42.81 133.01,42.47 v2(132.17,42.47)
  BOTTOM w0.076: v2(142.43,99.77) CPU1.BB10
  BOTTOM w0.114: JDIMM2.80 131.44,41.75 v2(132.17,42.47)
DDR_B_D30: length 68.2
  IN1 w0.081: v2(129.02,41.2) 128.85,41.02 128.85,40.47 129.15,40.16 130.06,40.16 130.29,40.4 130.29,42.81 130.36,42.88 130.36,46.05 131.05,46.74 131.05,60.21 131.07,60.24 131.07,63.66 132.47,65.06 132.47,76.8 137.94,82.27 137.94,84.17 141.74,87.98 141.74,90.01 142.51,90.78 142.51,96.72 141.52,97.71 v2(141.52,97.82)
  BOTTOM w0.076: v2(141.52,97.82) CPU1.BC7
  BOTTOM w0.114: JDIMM2.70 128.94,41.12 v2(129.02,41.2)
DDR_B_D31: length 68
  IN1 w0.081: v2(142.43,97.82) 143.43,96.83 143.43,90.87 142.27,89.72 142.27,87.43 139.27,84.42 139.27,81.9 133.76,76.39 133.76,75.74 133.86,75.64 134.08,75.64 134.18,75.54 134.18,75.34 134.08,75.24 133.86,75.24 133.76,75.14 133.76,74.94 133.86,74.84 134.08,74.84 134.18,74.75 134.18,74.55 134.08,74.45 133.86,74.45 133.76,74.35 133.76,74.15 133.86,74.05 134.08,74.05 134.18,73.95 134.18,73.75 134.08,73.66 133.86,73.66 133.76,73.56 133.76,73.36 133.86,73.26 134.08,73.26 134.18,73.16 134.18,72.96 134.08,72.86 133.86,72.86 133.76,72.76 133.76,72.57 133.86,72.47 134.08,72.47 134.18,72.37 134.18,72.17 134.08,72.07 133.86,72.07 133.76,71.97 133.76,71.77 133.86,71.67 134.08,71.67 134.18,71.58 134.18,71.38 134.08,71.28 133.86,71.28 133.68,71.1 133.68,62.64 133.36,62.33 133.36,54.85 132.75,54.23 132.75,53.61 132.65,53.51 132.42,53.51 132.28,53.37 132.28,53.21 132.38,53.11 132.65,53.11 132.75,53.01 132.75,52.82 132.65,52.72 132.38,52.72 132.28,52.62 132.28,52.42 132.38,52.32 132.65,52.32 132.75,52.22 132.75,52.02 132.65,51.92 132.44,51.92 132.34,51.83 132.34,51.62 132.44,51.53 132.65,51.53 132.75,51.43 132.75,48.2 132.65,48.1 132.35,48.1 132.25,48.01 132.25,47.81 132.35,47.71 132.65,47.71 132.75,47.61 132.75,47.41 132.65,47.31 132.35,47.31 132.25,47.22 132.25,47.01 132.35,46.92 132.65,46.92 132.75,46.82 132.75,45.27 132.49,45.01 v2(132.17,45.01)
  BOTTOM w0.076: v2(142.43,97.82) CPU1.BB7
  BOTTOM w0.114: v2(132.17,45.01) 132.19,45.03 JDIMM2.83
DDR_B_D32: length 65.6
  IN1 w0.081: v2(158.89,100.42) 159.36,99.96 159.36,99.62 159.44,99.54 159.44,98.38 159.76,98.06 159.76,97.07 160.19,96.64 160.19,91.73 163.51,88.41 163.51,71.18 160.15,67.83 160.15,58.83 160.73,58.25 160.73,50.27 159.55,49.09 159.55,48.55 159.65,48.45 159.96,48.45 160.05,48.35 160.05,48.15 159.96,48.05 159.65,48.05 159.55,47.95 159.55,47.51 159.45,47.41 159.3,47.41 159.2,47.31 159.2,47.11 159.3,47.01 159.7,47.01 159.8,46.91 159.8,46.71 159.7,46.61 159.3,46.61 159.2,46.52 159.2,46.32 159.3,46.22 159.7,46.22 159.8,46.12 159.8,45.93 159.69,45.82 159.27,45.82 159.2,45.75 159.2,45.5 159.3,45.4 159.55,45.4 159.63,45.32 v2(159.63,45.07)
  BOTTOM w0.076: v2(158.89,100.42) CPU1.AA11
  BOTTOM w0.114: JDIMM2.187 160.2,45.63 v2(159.63,45.07)
DDR_B_D33: length 66.1
  IN1 w0.081: v2(158.89,99.77) 159.26,99.4 159.26,98.27 159.59,97.95 159.59,96.99 159.98,96.59 159.98,91.65 163.05,88.58 163.05,86.32 163.17,86.19 163.17,71.27 159.85,67.95 159.85,58.71 160.4,58.16 160.4,53.76 159.89,53.25 159.89,52.96 159.99,52.87 160.2,52.87 160.3,52.77 160.3,52.57 160.2,52.47 159.99,52.47 159.89,52.37 159.89,52.17 159.99,52.07 160.2,52.07 160.3,51.97 160.3,51.78 160.2,51.68 159.99,51.68 159.89,51.58 159.89,51.38 159.99,51.28 160.18,51.28 160.28,51.18 160.28,50.98 160.18,50.88 160.02,50.88 159.92,50.79 159.92,49.88 159.25,49.21 159.25,47.79 158.9,47.43 158.9,44.53 v2(159.63,43.8)
  BOTTOM w0.076: v2(158.89,99.77) CPU1.AA10
  BOTTOM w0.114: JDIMM2.183 159.2,44.23 v2(159.63,43.8)
DDR_B_D34: length 66.2
  IN1 w0.081: v2(156.46,41.24) 155.21,42.49 155.21,47.54 156.08,48.4 156.08,50.83 156.76,51.52 156.76,69.09 159.99,72.32 159.99,88.37 157.76,90.6 157.76,96.95 157.2,97.5 157.2,99.36 157.53,99.69 157.53,99.97 v2(157.98,100.42)
  BOTTOM w0.076: v2(157.98,100.42) CPU1.AC11
  BOTTOM w0.114: JDIMM2.174 156.94,40.74 156.46,41.22 v2(156.46,41.24)
DDR_B_D35: length 66.2
  IN1 w0.081: v2(157.98,99.77) 157.41,99.2 157.41,97.59 157.99,97.01 157.99,90.75 160.29,88.45 160.29,81.25 160.39,81.15 160.52,81.15 160.62,81.06 160.62,80.86 160.52,80.76 160.39,80.76 160.29,80.66 160.29,80.46 160.39,80.36 160.52,80.36 160.62,80.26 160.62,80.06 160.52,79.97 160.39,79.97 160.29,79.87 160.29,72.19 157.06,68.97 157.06,51.39 156.38,50.71 156.38,48.28 155.51,47.41 155.51,43.46 v2(156.46,42.51)
  BOTTOM w0.076: CPU1.AC10 157.65,99.45 v2(157.98,99.77)
  BOTTOM w0.114: JDIMM2.170 155.94,39.66 156.05,39.77 156.05,42.1 v2(156.46,42.51)
DDR_B_D36: length 66.2
  IN1 w0.081: v2(159.63,41.26) 158.75,41.26 158.29,41.71 158.29,47.68 158.65,48.04 158.65,49.46 159.29,50.1 159.29,52.99 159.23,53.05 159.23,58.13 159.25,58.15 159.25,62.43 159.15,62.53 158.97,62.53 158.87,62.62 158.87,62.82 158.97,62.91 159.15,62.91 159.25,63.01 159.25,63.2 159.15,63.3 158.97,63.3 158.87,63.4 158.87,63.59 158.97,63.69 159.15,63.69 159.25,63.78 159.25,63.98 159.15,64.07 158.97,64.07 158.87,64.17 158.87,64.36 158.97,64.46 159.15,64.46 159.25,64.55 159.25,64.75 159.15,64.84 158.97,64.84 158.87,64.94 158.87,65.13 158.97,65.23 159.15,65.23 159.25,65.33 159.25,68.2 162.57,71.52 162.57,82.46 162.57,82.46 162.57,87.6 158.96,91.2 158.96,97.62 158.89,97.69 v2(158.89,97.82)
  BOTTOM w0.076: v2(158.89,97.82) CPU1.AA7
  BOTTOM w0.114: JDIMM2.182 158.94,40.1 159.34,40.5 159.34,40.97 v2(159.63,41.26)
DDR_B_D37: length 66.2
  IN1 w0.081: v2(158.89,98.47) 158.95,98.41 158.95,98.3 159.38,97.86 159.38,96.94 159.78,96.55 159.78,91.53 162.87,88.44 162.87,71.39 159.55,68.07 159.55,58.59 160.1,58.03 160.1,53.89 159.59,53.38 159.59,49.98 158.95,49.34 158.95,47.91 158.59,47.56 158.59,42.01 158.69,41.91 159.01,41.91 159.14,42.03 159.14,42.39 159.28,42.53 v2(159.63,42.53)
  BOTTOM w0.076: v2(158.89,98.47) CPU1.AA8
  BOTTOM w0.114: JDIMM2.186 159.95,39 159.95,40.7 160.09,40.84 160.09,42.07 v2(159.63,42.53)
