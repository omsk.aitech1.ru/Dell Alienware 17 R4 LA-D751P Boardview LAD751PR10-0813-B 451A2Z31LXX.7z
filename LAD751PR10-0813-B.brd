# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.2V_VCCPLL_OC: length 11.1
  TOP w0.508: RH530.1 v2(160.75,100.5) ; v2(131.25,102.79) 131.58,102.79 v4(131.9,102.46) 132.29,102.07 133.49,102.07 134.19,102.77 134.83,102.77 135.53,102.07 136.29,102.07 137.26,101.1 v2(137.86,101.1)
  BOTTOM w0.203: CPU1.BH13 137.73,101.1 v2(137.86,101.1)
  BOTTOM w0.305: v2(168.76,99.87) 169.08,100.21 CPU1.G11
  BOTTOM w0.508: C11.1 130.64,102.79 v2(131.25,102.79)
+1.2VP: length 49.6
  IN3 w0.254: v2(95.83,48.6) 95.14,48.6 93.58,47.04 v2(93.58,46.41) 93.58,46.22 93.93,45.88 95.14,45.88 96.21,44.81 96.21,41.79 99.83,38.17 99.83,35.97 98.12,34.26 98.12,31.46 97.29,30.64 v2(96.47,30.64)
  IN3 w0.508: v2(90.31,44.48) 91.39,44.48 92.15,45.24 94.08,45.24 95.55,43.77 95.55,41.73 99.3,37.98 99.3,36.2 97.61,34.51 97.61,31.91 v2(96.85,31.15)
  BOTTOM w0.203: PU201.19 90.39,44.4 v2(90.31,44.48) ; PU201.5 93.49,46.32 v2(93.58,46.41)
  BOTTOM w0.254: PR205.2 94.66,48.6 v2(95.83,48.6)
  vias: v1(94.53,23.98) v2(94.08,27.39) v2(94.08,26.75) v2(94.08,26.12) v2(94.08,25.48) v2(94.71,27.39) v2(94.71,26.75) v2(94.71,26.12) v2(94.71,25.48) v2(95.35,27.39) v2(95.35,26.75) v2(95.35,26.12) v2(95.35,25.48) v2(95.98,27.39) v2(95.98,26.75) v2(95.98,26.12) v2(95.98,25.48) v2(96.62,27.39) v2(96.62,26.75) v2(96.62,26.12) v2(96.62,25.48)
+1.8VA_TBTA_LDO: length 3.1
  TOP w0.203: v2(197.34,165.58) 197,165.23 v1(196.86,165.23)
  TOP w0.508: CT100.1 197.79,165.13 v2(197.34,165.58)
  BOTTOM w0.203: UT4.K1 197.34,165.38 v2(197.34,165.58)
+1.8VD_TBTA_LDO: length 2.5
  BOTTOM w0.254: 198.38,159.53 198.41,159.56 198.41,159.82 UT4.A2
  BOTTOM w0.508: CT99.1 197.56,158.7 198.38,159.53
+1.8VS: length 791
  TOP w0.254: v2(326.59,12.41) 326.15,12.85 JIO.7
  TOP w0.381: v2(221.64,160.57) 221.33,160.88 UX1.5
  TOP w0.457: v2(194.89,112.86) 194.24,112.86 194.04,113.06 193.13,113.06 193.11,113.08
  TOP w0.508: v2(274.49,153.17) v1(274.49,152.46) 274.49,151.2 273.94,150.64 273.94,148.03 272.63,146.72 272.63,145.09 273.77,143.95 276.37,143.95 PR6037.2 ; v2(221.45,46.71) 220.95,46.21 215.01,46.21 207.21,54.01 206.15,54.01 202.81,57.35 202.81,58.4 200.45,60.76 200.45,61.88 198.57,63.76 195.98,63.76 191.76,67.98 191.76,69.24 189.96,71.05 189.43,71.57 189.43,93.63 187.22,95.83 187.22,96.44 186.32,97.34 186.32,111.2 187.58,112.46 189.13,112.46 189.75,113.08 193.11,113.08 ; v2(310.31,58.51) 310.56,58.25 310.56,56.39 310.26,56.08 PR6406.2
  IN2 w0.508: v2(34.62,14.26) 34.62,16.22 34.55,16.29 34.55,18.32 33.28,19.59 33.28,20.42 v2(33.38,20.51) ; v2(221.64,160.57) 221.67,160.53 222.4,160.53 222.92,161.05 222.92,169.53 v2(222.97,169.58)
  IN2 w1.016: 271.92,14.64 271.94,14.66 273.04,14.66 274.25,13.46 277.45,13.46 280.81,10.09 288.18,10.09 288.38,9.9 292.55,9.9 292.97,10.32 295.32,10.32 297.07,8.57 300.95,8.57 302.61,10.23 315.41,10.23 319.15,13.96 324.75,13.96 325.8,12.91 ; 54.53,11.49 54.89,11.13 83.73,11.13 85.26,12.67 97.48,12.67 99.12,14.31 110.11,14.31 111.58,15.78 126.74,15.78 128.35,17.39 169.77,17.39 170.3,17.93 179.54,17.93 185.58,11.88 186.61,11.88 187.74,10.76 191.59,10.76 193.65,8.7 206.4,8.7 207.84,10.14 214.21,10.14 216.47,12.4 231.57,12.4 232.16,13 243.13,13 243.76,12.36 250.89,12.36 251.61,13.09 258.67,13.09 259.29,13.71 264.88,13.71 265.83,14.66 269.1,14.66
  IN3 w0.508: v2(211.96,157.32) 212.29,157.32 212.86,157.89 212.86,158.79 213.14,159.07 213.14,159.96 214.51,161.33 218.18,161.33 218.79,161.94 220.76,161.94 221.14,161.56 221.14,161.07 v2(221.64,160.57)
  IN3 w1.016: 307.89,58.58 307.63,58.31 300.96,58.31 300.44,57.79 297.77,57.79 297,57.02 ; 223.63,47.43 223.63,47.82 225.5,49.69 232.79,49.69 233.74,48.74 235.64,48.74 237.97,46.41 245.22,46.41 246.1,47.29 246.1,48.42 246.73,49.05 252.97,49.05 253.46,48.56 260.05,48.56 261.01,49.52 273.73,49.52 274.79,48.46 278.1,48.46 ; 328.16,12.39 331.37,12.39 336.6,17.62 336.6,46.33 334.07,48.86 ; 320.11,50.22 320.11,49.21 321.05,48.27 322.32,48.27 323.4,49.35 327.87,49.35
  IN4 w0.508: v2(274.49,153.17) 273.35,154.31 264.65,154.31 263.76,155.2 242.84,155.2 241.05,156.98 241.05,161.13 239.11,163.07 239.11,165.97 238.07,167.01 235.85,167.01 235.58,166.74 229.04,166.74 226.2,169.58 v2(222.97,169.58) 220.1,169.58 218.94,170.73 216.31,170.73 214.58,169.01 209.96,169.01 207.7,166.74 207.7,165.85 205.05,163.21 205.05,161.2 204.54,160.69 203.69,160.69 203.06,160.05 200.97,160.05 198.45,157.53 197.15,157.53 194.73,155.11 194.73,150.05 197.84,146.93 197.84,141.02 198.98,139.89 198.98,130.09 198.62,129.73 198.62,126.83 198.24,126.46 198.24,122.36 195.14,119.26 195.14,117.44 195.53,117.06 195.53,115.09
  IN4 w1.016: 200.01,65.31 200.01,65.34 198.83,66.52 191.93,66.52 189.27,69.17 189.27,73.35 188.85,73.77 188.85,79.97 189.77,80.89 189.77,93.79 189.18,94.39 189.18,101.83 189,102.01 189,103.45 189.15,103.6 189.15,109.42 193.05,113.31 193.05,113.48 ; 40.85,31.53 41.66,30.72 41.66,26.33 41.03,25.7 41.03,20 44.52,16.5 49.02,16.5 52.65,12.87
  BOTTOM w0.356: v2(211.96,157.32) 211.78,157.14 211.5,157.14 UX2.5 211.22,156.65 211.41,156.46 CV1056.1
  BOTTOM w0.508: CV20.1 222.17,160.04 v2(221.64,160.57)
  BOTTOM w2.54: 204.74,62.89 209.64,57.99
  vias: v2(40.09,31.97) v2(40.6,32.34) v2(53.23,12.09) v2(53.83,12.11) v2(194.27,114.5) v2(194.42,113.87) v2(194.88,113.46) v2(195.18,113.98) v2(195.6,113.56) v2(200.3,64.48) v2(200.8,64) v2(201.29,64.41) v2(201.3,63.51) v2(201.81,63.98) v2(202.23,63.53) v2(221.52,47.33) v2(222.07,47.61) v2(222.06,46.96) v2(222.67,46.95) v2(222.68,47.58) v2(327.17,12.41)
+1.8VSP:
  vias: v1(220.34,43.22)
+1.35VS_B+: length 24
  IN4 w0.508: v2(258.33,26.59) 256.95,27.97 248.86,27.97 247.59,29.24 243.88,29.24 242.79,30.32 242.79,31.04 243.49,31.74 243.49,34.6 v2(242.69,35.4)
  BOTTOM w0.508: v2(242.69,35.4) PR8201.2
  vias: v1(258.7,31.07) v2(258.43,24.83) v2(258.43,24.25) v2(258.43,23.66) v2(259.01,24.83) v2(259.01,24.25) v2(259.01,23.66) v2(259.6,24.83) v2(259.6,24.25) v2(259.6,23.66)
+1.35VS_VGA: length 497.7
  IN1 w0.305: v2(194.63,81.45) v2(194.63,82.1)
  IN1 w0.381: v2(245.19,60.91) v2(244.39,60.91) 243.64,60.91 v2(243.61,60.88)
  IN1 w0.4: v2(197.03,78.25) v2(196.23,77.45) ; v2(261.19,56.11) v2(261.79,56.11) ; v2(274.55,116.96) v2(274.55,116.16) v2(274.55,115.36) ; v2(226.19,55.31) v2(226.79,55.31) ; v2(280.15,98.56) v2(280.15,97.96) ; v2(223.79,60.91) v2(224.59,60.91) ; v2(224.59,60.91) v2(224.59,60.11) ; v2(224.59,60.91) v2(225.39,60.91) v2(226.19,60.91) ; v2(226.19,53.71) v2(226.79,53.71) ; v2(224.59,53.71) v2(223.79,54.51) ; v2(196.23,82.1) v2(196.23,81.45) ; v2(275.35,96.36) v2(274.55,96.36) ; v2(274.55,96.36) v2(274.55,97.16) v2(274.55,97.96) ; v2(274.55,96.36) v2(274.55,95.56) ; v2(243.6,56.92) 243.28,57.24 243.25,57.24 v2(242.79,57.71) ; v2(193.83,79.05) v2(194.63,79.05) v2(194.63,78.25) ; v2(201.83,79.85) v2(201.03,79.85) v2(201.03,79.05) ; v2(226.19,56.11) v2(226.79,56.11) ; v2(281.75,96.36) v2(280.95,95.56) ; 281.75,98.36 v2(281.75,97.96) ; v2(259.59,60.91) v2(260.39,60.91) v2(261.19,60.91) ; v2(259.59,60.91) v2(258.79,60.91) ; v2(259.59,60.91) v2(259.59,60.11) ; v2(279.35,97.96) v2(279.35,98.56) ; v2(277.75,79.56) v2(276.95,79.56) v2(276.15,79.56) ; v2(274.55,80.36) v2(274.55,81.16) v2(274.55,81.96) ; v2(261.19,53.71) v2(261.79,53.71) ; v2(261.79,55.31) v2(261.19,55.31)
  IN1 w0.508: v2(281.75,98.56) 281.75,98.36
  IN6 w0.4: v2(274.55,108.16) v2(274.55,107.36) v2(273.75,107.36) ; v2(252.39,57.71) v2(252.39,58.51) v2(252.39,59.31) v2(252.39,60.11) ; v2(275.35,89.16) 276.12,89.16 v2(276.13,89.15) 276.15,89.16 v2(276.95,89.16) v2(277.75,89.16) ; v2(279.35,70.11) v2(279.35,70.76) ; v2(200.23,72.65) v2(199.43,72.65) v2(198.63,72.65) ; v2(280.95,105.76) v2(280.95,105.11) ; v2(282.55,105.11) v2(282.55,105.76) ; v2(274.55,73.16) v2(274.55,72.36) v2(273.75,72.36) ; v2(217.39,60.11) v2(217.39,59.31) v2(217.39,58.51) v2(217.39,57.71) ; v2(201.03,70.25) v2(201.03,71.05) v2(201.03,71.85) ; v2(280.95,70.11) v2(280.95,70.76) ; v2(274.55,86.76) v2(274.55,87.56) v2(274.55,88.36) ; v2(216.59,61.71) v2(216.59,60.91) v2(215.79,60.91) v2(214.99,60.91) ; v2(279.35,105.76) v2(279.35,105.11) ; v2(249.99,60.91) v2(250.79,60.91) v2(251.59,60.91) ; v2(282.55,70.11) v2(282.55,70.76) ; v2(272.15,72.36) v2(272.15,73.16) ; v2(197.03,71.85) v2(197.83,72.65)
  BOTTOM w0.25: UG9.K12 v2(226.97,87.35)
  BOTTOM w0.254: RG155.1 194.64,86.02 CG391.1 194.64,89.24 v2(194.63,89.25) ; CG392.1 CG390.1 CG208.1 ; UG3.F1 v2(249.99,56.91) 250.39,57.31
  BOTTOM w0.3: UG9.M43 v2(248.07,88.75) ; UG9.AN43 v2(248.07,103.45) ; UG9.AM43 v2(248.07,102.15) ; UG9.AJ43 v2(248.07,100.05) ; UG9.K41 v2(246.67,87.35) ; UG9.M10 v2(225.57,88.75) ; UG9.AK43 v2(248.07,101.35)
  BOTTOM w0.305: v2(202.63,90.85) 203.03,91.25 UG7.P12 v2(203.43,91.65) UG7.P11 v2(202.63,92.45) UG7.N10 ; UG6.B1 v2(245.19,64.91) ; UG4.R10 281.75,74.76 v2(281.75,74.76) ; UG4.R10 v2(280.95,74.76) ; UG4.R10 v2(280.95,73.96) ; CG280.1 262.36,64.48 v2(261.19,63.31) UG3.P14 ; v2(281.75,77.96) 281.53,78.18 UG4.R5 ; CG87.1 270.66,98.55 270.55,98.44 v2(270.55,97.96) UG1.T14 ; UG4.P12 v2(280.95,73.16) UG4.P11 v2(280.15,73.96) UG4.N10 v2(279.35,74.76) ; v2(281.75,88.36) 282.15,88.76 UG1.B3 ; UG5.B1 v2(214.99,52.91) v2(214.39,52.91) ; UG5.D11 v2(223.79,54.51) 224.19,54.91 UG5.D12 ; CG226.1 262.84,52.8 261.93,53.71 v2(261.79,53.71) v2(261.19,53.71) 260.96,53.48 260.96,53.48 UG3.B14 ; UG8.M1 v2(196.23,70.25) v2(196.23,69.6) 196.23,69.1 196.36,68.96 CG285.1 ; v2(200.83,100.66) 200.83,100.58 200.63,100.37 UG7.L1 v2(201.03,99.65) UG7.L2 v2(201.03,98.85) 201.43,98.45 UG7.M3 v2(201.83,98.85) ; UG2.M14 v2(279.35,105.76) v2(279.35,105.11) ; UG2.R5 v2(281.75,112.96) ; UG8.F12 v2(201.03,79.05) UG8.G11 ; UG8.F12 v2(201.83,79.85) ; UG8.F12 201.43,79.45 v2(201.03,79.85) UG8.G13 v2(200.23,79.85) UG8.H12 ; UG6.B14 234.19,64.51 v2(233.79,64.91) 233.3,64.91 233.18,64.79 CG172.1 ; UG7.K12 v2(200.23,90.85) 200.63,90.45 ; v2(252.39,62.51) UG3.P3 ; UG7.B3 v2(193.83,98.05) ; UG2.F14 274.15,106.16 v2(274.15,105.56) ; v2(257.99,56.91) 258.39,57.31 UG3.G11 ; 202.94,82.65 202.94,81.74 v2(203.03,81.65) UG8.D14 ; UG2.B14 270.95,105.56 v2(270.95,105.56) v2(270.95,104.91) 270.85,104.81 CG102.1 ; CG121.1 272.31,69.84 272.55,70.08 v2(272.55,70.56) 272.55,70.56 UG4.D14 ; v2(241.19,53.71) 241.59,54.11 UG6.R5 ; v2(273.75,88.36) 274.15,88.76 UG1.M3 v2(274.55,88.36) 274.95,87.96 UG1.L2 v2(274.55,87.56) ; UG1.N5 273.75,89.96 v2(273.75,89.96) ; CG86.1 278.72,118.29 278.55,118.12 v2(278.55,117.61) v2(278.55,116.96) UG2.L1 278.1,116.52 278.1,116.4 278.07,116.36 278.07,115.96 278.1,115.92 278.1,115.81 UG2.L2 v2(278.55,115.36) UG2.M3 ; UG4.P1 v2(280.95,81.96) v2(280.95,82.61) 280.95,83.12 281.05,83.22 CG118.1 ; UG7.P3 202.8,98.23 v2(202.63,98.05) ; v2(198.63,79.05) UG8.K12 UG8.L13 ; v2(271.35,113.76) 271.54,113.57 271.54,113.57 UG2.C5 ; UG7.T1 v2(204.63,100.65) ; v2(235.59,64.91) UG6.B12 ; UG2.L4 v2(277.75,114.56) UG2.K3 v2(276.95,114.56) ; v2(204.23,89.25) 204.23,88.77 204.11,88.65 CG209.1 ; v2(214.99,61.71) UG5.M1 ; v2(272.95,115.36) 272.55,114.96 UG2.D3 ; UG4.D1 272.38,81.73 v2(272.15,81.96) ; v2(271.35,114.56) 270.95,114.96 UG2.B3 ; UG2.E10 v2(272.95,108.96) 272.55,108.56 UG2.D11 272.55,108.56 v2(272.15,108.16) UG2.D12 v2(272.15,107.36) ; UG1.B14 281.95,97.76 281.95,97.76 v2(281.75,97.96) v2(281.75,98.56) ; UG3.M1 v2(249.99,61.71) ; CG101.1 281.36,118.03 v2(280.95,117.61) v2(280.95,116.96) UG2.P1 ; v2(201.83,73.45) 202.23,73.85 UG8.E5 ; v2(270.55,107.36) 270.78,107.59 UG2.B12 ; UG7.E5 v2(196.23,96.45) ; v2(237.99,53.71) 237.59,54.11 UG6.R10 ; UG4.F12 v2(274.55,73.16) UG4.G11 ; UG4.F12 v2(274.55,72.36) 274.95,71.96 ; UG4.F12 v2(273.75,72.36) ; v2(196.23,77.45) 196.23,77.45 UG8.N10 v2(195.43,78.25) UG8.P11 ; v2(201.83,78.25) 202.23,77.85 UG8.E10 v2(202.63,78.25) UG8.D11 v2(203.43,79.05) UG8.D12 ; UG3.M14 v2(261.19,61.71) ; UG4.B12 270.95,72.76 v2(270.55,72.36) ; v2(257.19,53.71) 257.59,54.11 UG3.C10 ; v2(216.59,60.91) UG5.M3 v2(216.59,61.71) ; UG5.M14 v2(226.19,61.71) ; v2(198.63,72.65) UG8.K3 v2(197.83,72.65) 197.43,73.05 UG8.L4 ; UG6.G4 UG6.H3 v2(242.79,59.31) ; CG382.1 231.78,55.23 CG278.1 232.51,54.39 v2(233.99,52.91) 234.39,53.31 UG6.T14 ; UG5.T3 v2(216.59,64.91) ; UG5.D14 v2(226.19,55.31) v2(226.79,55.31) 227.27,55.31 227.3,55.28 CG266.1 ; UG8.F3 201.43,72.25 v2(201.03,71.85) 200.63,71.45 UG8.G2 v2(201.03,71.05) 200.63,70.65 UG8.G1 v2(201.03,70.25) ; UG6.C5 v2(241.99,64.11) ; UG4.N5 279.53,78.58 279.53,78.58 v2(279.35,78.76) ; UG7.P1 v2(203.03,100.65) ; UG4.C5 271.6,78.51 271.6,78.52 v2(271.35,78.76) ; UG7.G13 197.43,90.45 v2(197.03,90.85) 196.63,91.25 UG7.F12 v2(196.23,90.85) ; UG7.G13 197.55,90.33 197.55,89.77 UG7.G14 v2(197.03,89.25) 196.63,89.65 UG7.F14 v2(196.23,89.25) ; UG7.G13 UG7.H12 v2(198.63,91.65) ; UG6.P12 235.99,54.91 v2(236.39,54.51) UG6.P11 ; UG8.M14 v2(196.23,81.45) v2(196.23,82.1) 196.23,82.76 196.17,82.81 CG203.1 ; UG1.F3 v2(278.55,89.16) UG1.G4 v2(277.75,89.16) UG1.H3 v2(276.95,89.16) ; UG4.F1 v2(273.75,81.96) ; UG4.B3 271.11,79.8 v2(271.33,79.58) ; UG2.M1 v2(279.35,116.96) v2(279.35,117.61) 279.59,117.85 CG100.1 ; UG6.E5 v2(241.99,61.71) ; v2(276.95,95.56) UG1.H12 UG1.G13 v2(278.55,96.36) UG1.F12 v2(279.35,96.36) ; UG5.E10 v2(222.04,55.71) ; UG8.F1 v2(201.83,70.25) ; RG121.1 CG123.1 262.47,56.79 ; v2(274.55,87.56) 274.95,87.16 UG1.L1 v2(274.55,86.76) ; v2(274.55,87.56) 274.15,87.16 UG1.M1 274.15,87.16 v2(273.75,86.76) ; v2(236.39,58.51) UG6.K12 UG6.L13 ; UG6.E10 v2(237.18,62.52) UG6.D11 v2(236.39,63.31) 235.99,62.91 UG6.D12 ; v2(193.83,96.45) 194.03,96.65 UG7.C5 ; v2(280.95,109.76) 281.2,109.52 UG2.R10 ; UG2.E5 v2(273.75,113.76) ; v2(282.55,105.11) v2(282.55,105.76) UG2.T14 ; UG3.P1 v2(249.99,63.31) ; UG3.P12 259.19,62.91 v2(258.79,63.31) UG3.P11 v2(257.99,62.51) UG3.N10 ; UG6.H12 UG6.G13 UG6.F12 ; UG7.R5 v2(204.23,97.25) ; UG5.M12 v2(224.59,60.91) 224.99,60.51 UG5.L13 ; UG3.C5 253.59,54.11 v2(253.99,53.71) ; UG1.T12 v2(270.55,96.36) ; UG1.E10 v2(279.75,93.81) ; v2(200.23,72.65) 200.63,73.05 UG8.G4 ; UG7.K3 v2(200.23,98.05) 200.63,97.65 UG7.L4 ; UG1.G14 v2(278.55,97.96) ; UG7.F3 v2(197.03,98.05) UG7.G4 197.43,97.65 v2(197.83,98.05) UG7.H3 ; CG122.1 270.53,70.14 v2(270.95,70.56) 270.95,70.56 UG4.B14 ; v2(214.38,54.64) 214.52,54.51 v2(214.99,54.51) UG5.D1 ; v2(194.63,69.6) v2(194.63,70.25) UG8.P1 ; UG1.F14 v2(279.35,97.96) v2(279.35,98.56) 278.66,99.25 CG84.1 RG110.1 ; UG8.R10 194.23,77.85 v2(194.63,78.25) UG8.P11 ; UG8.R10 194.63,77.45 v2(194.63,77.45) ; UG8.R10 v2(193.83,77.45) ; v2(235.59,56.11) UG6.M12 v2(235.55,56.95) 235.55,56.95 UG6.L13 ; UG1.P1 v2(272.15,86.76) ; UG6.F14 234.21,61.31 v2(233.81,61.71) ; v2(274.81,70.53) 274.81,71.02 UG4.G14 ; v2(272.15,116.96) UG2.D1 ; v2(281.75,73.16) UG4.T12 ; v2(253.99,51.31) 254.33,50.97 CG282.1 ; UG6.T3 v2(243.59,52.91) ; UG6.P1 v2(245.19,54.51) ; v2(196.23,101.1) v2(196.23,100.45) UG7.F1 ; v2(225.39,60.91) 225.79,60.51 UG5.L14 ; v2(245.19,63.31) UG6.D1 ; UG1.P14 v2(272.15,97.96) 272.15,98.44 272.44,98.73 CG83.1 ; v2(250.78,51.31) 251.09,51.01 CG132.1 ; UG1.G11 v2(278.55,94.76) ; v2(223.79,56.91) UG5.F12 v2(224.59,56.91) 224.99,57.31 UG5.G13 ; UG2.T1 v2(282.55,116.96) v2(282.55,117.61) 283.14,118.2 CG103.1 ; v2(258.79,52.91) 259.19,53.31 UG3.B12 ; UG5.T14 v2(226.19,64.91) 226.31,64.79 227.08,64.79 ; UG8.C5 v2(204.23,73.45) ; CG119.1 279.27,83.2 279.35,83.12 v2(279.35,82.61) v2(279.35,81.96) UG4.M1 ; v2(197.03,92.45) 197.03,92.45 UG7.G11 ; v2(261.19,60.91) UG3.L14 260.79,60.51 v2(260.39,60.91) UG3.L13 259.99,60.51 v2(259.59,60.91) UG3.M12 v2(258.79,60.91) UG3.L11 ; UG3.D3 251.99,54.91 v2(252.39,54.51) ; UG3.R5 v2(253.19,64.11) ; UG2.P11 v2(280.15,108.96) UG2.N10 v2(279.35,109.76) ; UG2.P11 v2(280.95,108.16) UG2.P12 ; UG2.P11 v2(280.95,108.96) UG2.R10 ; UG5.D3 216.99,54.91 v2(217.39,54.51) ; UG5.L11 v2(223.79,60.91) ; UG4.T3 282.33,79.79 282.33,79.78 v2(282.55,79.56) ; UG6.P3 243.19,54.91 v2(242.79,54.51) ; UG6.L13 235,57.5 234.58,57.5 UG6.L14 234.27,57.19 234.27,56.63 UG6.M14 ; v2(253.99,56.11) UG3.E5 ; UG1.G2 v2(278.55,87.56) 278.15,87.16 UG1.G1 v2(278.55,86.76) v2(278.55,86.16) 278.55,84.85 CG82.1 ; v2(274.55,116.96) UG2.G1 v2(274.55,116.16) UG2.G2 v2(274.55,115.36) UG2.F3 ; v2(216.59,56.11) UG5.F3 v2(217.39,56.91) UG5.G4 217.79,57.31 v2(217.39,57.71) UG5.H3 ; UG1.D12 v2(280.95,95.56) UG1.D11 ; UG7.R10 203.83,92.85 v2(204.23,92.45) ; UG8.L11 v2(197.03,78.25) ; UG7.T14 v2(205.03,89.25) 205.03,87.93 204.97,87.88 CG207.1 ; UG5.G13 225.11,57.43 225.67,57.43 UG5.G14 ; UG5.G13 UG5.H12 ; UG3.K12 v2(259.59,60.11) ; UG2.L14 v2(278.55,105.76) v2(278.55,105.11) ; UG4.F3 v2(274.55,80.36) UG4.G2 v2(274.55,81.16) UG4.G1 v2(274.55,81.96) ; CG134.1 248.95,54.07 v2(249.39,54.51) v2(249.99,54.51) 250.39,54.91 UG3.D1 ; 251.99,59.71 v2(252.39,60.11) 252.59,60.32 UG3.L4 ; 251.99,59.71 v2(252.39,59.31) ; 251.99,59.71 UG3.K3 ; v2(276.15,79.56) UG4.H3 v2(275.35,79.56) UG4.G4 ; UG1.L13 v2(274.55,97.16) UG1.L14 v2(274.55,97.96) ; UG1.L13 v2(274.55,96.36) UG1.M12 v2(274.55,95.56) UG1.L11 ; UG1.L13 v2(275.35,96.36) UG1.K12 ; 250.39,57.31 UG3.G1 UG3.G2 ; UG8.P11 v2(194.63,79.05) UG8.P12 ; UG5.K12 v2(224.59,60.11) ; v2(280.95,70.11) v2(280.95,70.76) 280.76,70.95 UG4.P14 ; UG2.P14 v2(280.95,105.76) v2(280.95,105.11) 280.95,104.63 280.93,104.61 CG98.1 ; v2(272.95,80.36) 272.75,80.16 272.75,80.16 UG4.D3 ; UG7.B12 193.43,91.25 v2(193.83,90.85) ; v2(274.95,105.56) 274.95,106.16 UG2.G14 ; v2(278.55,81.16) UG4.L2 v2(278.55,80.36) UG4.M3 ; UG1.F1 v2(279.35,86.76) v2(279.35,86.16) 279.35,85.65 279.4,85.61 CG104.1 ; v2(218.99,53.71) 218.59,54.11 UG5.C5 ; v2(196.23,73.45) 195.83,73.85 UG8.N5 ; UG4.L4 v2(277.75,79.56) UG4.K3 v2(276.95,79.56) ; UG8.H3 v2(199.43,72.65) ; UG3.T14 v2(261.19,64.91) 261.78,65.5 CG279.1 ; UG1.R10 v2(271.35,94.76) ; UG5.L4 v2(217.39,60.11) ; UG3.F14 260.79,56.51 v2(261.19,56.11) v2(261.79,56.11) 262.47,56.79 ; CG274.1 192.97,69.04 193.03,69.1 v2(193.03,69.6) v2(193.03,70.25) UG8.T1 ; UG3.B1 v2(249.99,52.91) v2(249.39,52.91) 248.88,52.91 248.66,53.13 CG136.1 ; UG1.C10 v2(281.75,93.96) ; v2(245.19,60.91) UG6.G1 v2(244.39,60.91) UG6.G2 243.99,60.51 v2(243.61,60.88) UG6.F3 ; UG5.L2 v2(215.79,60.91) ; UG6.N5 v2(241.99,56.11) ; UG5.K3 v2(217.39,59.31) ; UG3.R10 v2(257.99,64.11) ; UG1.C5 v2(281.75,90.76) ; UG6.T1 v2(245.19,52.91) ; v2(276.13,89.15) UG1.K3 275.35,89.16 v2(275.35,89.16) UG1.L4 ; UG7.L11 v2(201.03,91.65) UG7.M12 201.43,91.25 v2(201.03,90.85) 200.63,90.45 ; CG277.1 193.32,83.1 193.03,82.81 v2(193.03,82.1) v2(193.03,81.45) UG8.T14 ; v2(204.23,91.65) 204.38,91.5 UG7.T12 ; 200.63,90.45 UG7.L13 ; 200.63,90.45 v2(201.03,90.05) 200.63,89.65 UG7.L14 v2(201.03,89.25) 201.43,89.65 UG7.M14 v2(201.83,89.25) ; UG7.B1 v2(193.03,100.45) v2(193.03,101.1) v2(192.23,101.1) ; UG6.D14 234.19,62.91 v2(233.79,63.31) 233.3,63.31 233.01,63.01 CG155.1 ; UG6.P11 UG6.R10 ; UG6.P11 v2(237.19,55.31) UG6.N10 v2(237.99,56.11) ; UG4.K12 v2(276.95,73.16) ; v2(278.55,82.61) v2(278.55,81.96) UG4.L1 ; UG4.M14 v2(279.35,70.76) v2(279.35,70.11) 279.35,69.63 279.4,69.58 CG120.1 ; v2(222.19,53.71) 222.59,54.11 UG5.C10 ; v2(271.35,108.96) 271.56,109.17 UG2.C10 ; v2(257.04,55.71) UG3.E10 v2(257.99,55.31) UG3.D11 v2(258.79,54.51) 259.04,54.76 UG3.D12 ; UG4.B1 270.8,81.72 v2(270.55,81.96) ; UG7.D3 v2(194.63,98.05) ; UG3.G13 260.11,57.43 260.67,57.43 UG3.G14 260.79,57.31 v2(261.19,56.91) 261.67,56.91 261.79,56.79 262.47,56.79 ; UG3.G13 259.99,57.31 v2(259.59,56.91) UG3.F12 v2(258.78,56.92) ; UG3.G13 UG3.H12 v2(258.79,58.51) ; CG80.1 283.54,84.93 282.91,85.56 282.91,85.8 v2(282.55,86.16) v2(282.55,86.76) UG1.B1 v2(281.75,87.56) ; CG224.1 282.27,69.25 282.55,69.53 v2(282.55,70.11) v2(282.55,70.76) UG4.T14 ; v2(278.55,70.76) UG4.L14 278.03,71.28 278.03,71.84 UG4.L13 278.15,71.96 v2(278.55,72.36) UG4.M12 v2(279.35,72.36) ; UG6.G14 234.21,60.51 v2(233.81,60.91) ; UG7.D14 v2(194.63,89.25) ; v2(276.95,108.16) UG2.K12 UG2.L13 v2(278.55,107.36) UG2.M12 v2(279.35,107.36) ; v2(282.55,82.61) v2(282.55,81.96) UG4.T1 ; UG1.D3 v2(280.95,89.16) ; v2(226.79,53.71) v2(226.19,53.71) UG5.B14 ; UG1.D1 v2(280.95,86.76) v2(280.95,86.16) ; v2(245.19,61.71) UG6.F1 ; CG126.1 248.64,57.26 248.83,57.07 249.23,57.07 v2(249.39,56.91) v2(249.99,56.91) ; v2(195.43,100.45) v2(195.43,101.1) ; v2(270.55,116.96) UG2.B1 ; CG85.1 280.16,99.32 280.15,99.31 v2(280.15,98.56) v2(280.15,97.96) UG1.D14 ; UG6.C10 v2(237.19,64.11) ; UG1.M14 v2(273.75,97.96) ; v2(281.75,108.16) 282.01,107.9 UG2.T12 ; UG8.B3 v2(204.23,72.65) ; v2(197.03,69.6) v2(197.03,70.25) UG8.L1 197.43,70.65 v2(197.03,71.05) UG8.L2 197.43,71.45 v2(197.03,71.85) 196.63,72.25 UG8.M3 ; v2(276.15,114.56) UG2.H3 v2(275.35,114.56) 275.35,114.56 UG2.G4 ; UG6.R10 v2(237.99,54.51) ; UG7.B14 v2(193.03,89.25) ; v2(252.39,53.71) UG3.B3 ; UG5.P14 v2(226.19,63.31) ; v2(193.03,71.85) 193.43,72.25 UG8.T3 ; UG3.N5 v2(253.19,61.71) ; UG6.P14 234.39,54.91 v2(233.99,54.51) ; UG6.F12 v2(235.59,61.71) ; UG6.F12 UG6.G11 ; UG1.P12 272.55,95.96 v2(272.15,95.56) UG1.P11 272.55,95.16 v2(272.95,94.76) UG1.N10 273.75,94.76 v2(273.75,94.76) ; UG7.T3 204.81,98.63 204.81,98.64 v2(205.03,98.85) ; v2(197.03,100.45) UG7.G1 v2(197.03,99.65) UG7.G2 ; UG4.H12 v2(275.35,72.36) 274.95,71.96 ; UG4.F14 v2(274.15,70.56) ; v2(242.79,58.51) UG6.K3 v2(242.79,57.71) UG6.L4 ; v2(201.83,97.25) 201.83,97.25 UG7.N5 ; UG6.L11 236.79,57.31 v2(237.19,56.91) ; UG1.E5 v2(279.35,90.76) ; v2(196.23,79.85) UG8.M12 196.63,79.45 v2(197.03,79.85) UG8.L13 ; v2(245.19,56.91) UG6.L1 v2(244.39,56.91) UG6.L2 243.99,57.31 v2(243.6,56.92) UG6.M3 ; UG8.C10 v2(204.23,78.25) ; v2(280.95,79.56) 280.68,79.83 280.68,79.83 UG4.P3 ; UG8.B14 204.63,81.65 v2(204.63,81.65) 204.63,82.78 205.23,83.38 CG208.1 ; UG5.B12 v2(224.59,53.71) ; v2(271.35,88.36) 270.95,88.76 UG1.T3 ; UG8.T12 v2(193.83,79.05) ; UG5.R5 v2(218.19,64.11) ; CG268.1 262.52,55.21 262.42,55.31 v2(261.79,55.31) v2(261.19,55.31) UG3.D14 ; UG4.E5 273.54,78.55 v2(273.75,78.76) ; UG7.E10 v2(195.83,93.4) ; CG88.1 272.63,104.24 272.55,104.31 v2(272.55,104.91) v2(272.55,105.56) 272.55,105.56 UG2.D14 ; v2(271.35,89.96) 271.53,90.14 271.53,90.14 UG1.R5 ; 274.95,71.96 UG4.G13 ; UG8.G14 v2(200.63,81.65) ; UG7.D12 v2(194.63,91.65) UG7.D11 ; UG8.L13 197.51,80.34 197.51,80.97 UG8.L14 v2(197.03,81.45) ; UG6.D3 v2(243.59,62.51) ; v2(236.39,53.71) UG6.T12 ; UG2.R10 v2(281.75,109.76) ; UG5.P3 v2(217.39,62.51) ; v2(250.79,60.91) UG3.L2 251.19,60.51 v2(251.59,60.91) UG3.M3 v2(251.59,61.71) ; UG7.C10 v2(193.83,93.25) ; v2(273.75,116.96) 273.96,116.75 UG2.F1 ; UG7.M1 v2(201.43,100.65) ; UG5.T1 215.28,64.62 v2(214.99,64.91) ; UG1.P3 v2(272.95,89.16) ; UG5.B3 v2(217.39,53.71) ; UG5.T12 v2(224.59,64.91) ; UG8.P3 v2(194.63,72.65) ; v2(245.19,56.11) UG6.M1 ; UG7.P14 v2(203.43,89.25) ; UG5.R10 v2(222.99,64.11) ; UG5.G2 v2(215.79,56.91) 215.39,57.31 UG5.G1 v2(214.99,56.91) ; UG5.N5 v2(218.19,61.71) ; v2(272.15,72.36) 272.55,72.76 UG4.D12 v2(272.15,73.16) UG4.D11 v2(272.95,73.96) UG4.E10 ; UG5.L1 v2(214.99,60.91) ; v2(279.35,113.76) 279.54,113.57 279.54,113.57 UG2.N5 ; UG2.P3 280.74,114.77 v2(280.95,114.56) ; UG8.B12 v2(204.23,79.05) ; v2(194.63,81.45) UG8.P14 ; UG2.T3 v2(282.55,115.36) ; v2(249.99,64.91) UG3.T1 ; UG5.P12 224.19,62.91 v2(223.79,63.31) UG5.P11 v2(222.99,62.51) UG5.N10 ; UG5.F1 v2(214.99,56.11) ; v2(273.75,107.36) UG2.F12 v2(274.55,107.36) UG2.G13 v2(275.35,107.36) UG2.H12 ; UG3.T12 v2(259.59,64.91) ; RG132.1 227.47,56.79 v2(226.79,56.11) v2(226.19,56.11) 225.79,56.51 UG5.F14 ; UG1.T1 v2(270.55,86.76) ; UG1.B12 v2(281.75,96.36) ; v2(218.99,56.11) UG5.E5 ; UG3.T3 v2(251.59,64.91) ; UG7.D1 v2(194.63,100.45) 194.63,101.03 v2(194.69,101.09) ; UG2.G11 v2(274.55,108.16) ; 251.99,58.11 v2(252.39,57.71) UG3.G4 v2(252.39,56.91) 252.16,56.68 UG3.F3 ; 251.99,58.11 v2(252.39,58.51) ; 251.99,58.11 UG3.H3 ; UG4.C10 v2(271.35,73.96) ; UG4.L11 v2(278.55,73.96) ; UG3.L1 v2(249.99,60.91) ; UG8.D1 v2(203.43,70.25) ; UG8.D3 v2(202.63,71.85) ; v2(205.03,70.25) UG8.B1 ; UG5.G11 v2(222.99,56.91) ; UG5.P1 v2(214.99,63.31) ; UG2.L11 v2(278.55,108.96) ; UG8.F14 v2(201.43,81.65) ; UG6.B3 v2(242.79,64.11) ; UG8.R5 v2(193.83,74.25)
  BOTTOM w0.381: v2(284.29,111.98) CG81.1 ; CG209.1 204.11,86.38 CG283.1 ; CG87.1 270.66,100.63 CG220.1 ; 202.94,82.65 202.94,83.48 CG243.1 ; 227.08,64.79 228.15,64.79 CG219.1 229.18,64.87 CG368.1 ; CG83.1 272.44,100.88 CG117.1 ; v2(284.45,115.73) CG97.1 ; v2(196.23,101.1) 196.23,102.26 CG287.1 ; CG271.1 v2(247.21,51.15)
  BOTTOM w0.508: v2(259.59,51.31) 259.85,51.05 CG133.1 CG228.1 ; CG276.1 190.57,77.89 v2(190.94,78.25) ; v2(245.17,50.96) CG273.1 ; CG284.1 193.67,102.37 193.03,101.72 v2(193.03,101.1) ; v2(224.3,51.31) 224.24,51.25 CG286.1 ; v2(219.7,50.53) 219.49,50.32 CG161.1 ; CG223.1 242.2,50.45 v2(241.5,51.15) ; v2(283.35,74.76) 283.94,74.76 284.33,75.15 CG115.1 ; CG160.1 235.16,51.1 v2(235.37,51.31) ; CG383.1 232,62.91 CG155.1 ; CG221.1 v2(284.22,109.57) ; CG116.1 285.25,71.98 v2(285.99,71.98) ; CG281.1 284.81,78.77 v2(284.81,79.09) 285.12,79.41 CG225.1 ; CG222.1 236.36,50.64 v2(236.99,51.28) ; CG227.1 v2(257.31,51.28) ; v2(244.24,50.96) CG159.1
  vias: v2(192.23,93.25) v2(192.23,90.85) v2(202.38,67.5) v2(204.13,67.5) v2(205.03,67.5) v2(205.83,78.25) v2(205.83,67.5) v2(214.39,56.91) v2(214.39,52.11) v2(222.99,65.71) v2(223.79,58.51) v2(225.57,101.35) v2(225.57,100.05) v2(225.57,99.25) v2(225.57,97.95) v2(225.57,97.15) v2(225.57,95.85) v2(225.57,95.05) v2(225.57,93.75) v2(225.57,92.95) v2(225.57,91.65) v2(225.57,90.85) v2(225.57,89.55) v2(226.32,101.3) v2(226.32,100.1) v2(226.32,99.2) v2(226.32,97.1) v2(226.32,95.9) v2(226.32,95) v2(226.32,93.8) v2(226.32,91.7) v2(226.32,90.8) v2(226.32,89.6) v2(227.72,88.2) v2(227.77,87.35) v2(229.07,87.35) v2(229.87,87.35) v2(231.12,88.1) v2(231.17,87.35) v2(231.97,87.35) v2(233.27,87.35) v2(234.12,88.1) v2(234.07,87.35) v2(235.37,87.35) v2(236.17,87.35) v2(236.37,88.16) v2(237.19,65.71) v2(237.42,88.1) v2(237.47,87.35) v2(238.27,87.35) v2(239.57,87.35) v2(240.37,87.35) v2(240.42,88.1) v2(241.62,88.1) v2(241.67,87.35) v2(242.47,87.35) v2(243.72,88.1) v2(243.77,87.35) v2(244.57,87.35) v2(245.82,88.1) v2(245.87,87.35) v2(247.32,104.3) v2(247.32,102.2) v2(247.32,101.3) v2(247.32,100.1) v2(247.32,99.2) v2(247.32,97.1) v2(247.32,95.9) v2(247.32,95) v2(247.32,93.8) v2(247.32,92.9) v2(247.32,90.8) v2(247.32,89.6) v2(248.07,104.25) v2(248.07,99.25) v2(248.07,97.95) v2(248.07,97.15) v2(248.07,95.85) v2(248.07,95.05) v2(248.07,93.75) v2(248.07,92.95) v2(248.07,91.65) v2(248.07,90.85) v2(248.07,89.55) v2(257.99,65.71) v2(261.63,48.27) v2(261.63,47.66) v2(261.63,47.02) v2(261.63,46.39) v2(262.26,48.27) v2(262.26,47.66) v2(262.26,47.02) v2(262.26,46.39) v2(262.9,48.27) v2(262.9,47.66) v2(262.9,47.02) v2(262.9,46.39) v2(263.53,48.27) v2(263.53,47.66) v2(263.53,47.02) v2(263.53,46.39) v2(264.17,48.27) v2(264.17,47.66) v2(264.17,47.02) v2(264.17,46.39) v2(264.8,48.27) v2(264.8,47.66) v2(264.8,47.02) v2(264.8,46.39) v2(265.44,48.27) v2(265.44,47.66) v2(265.44,47.02) v2(265.44,46.39) v2(266.07,48.27) v2(266.07,47.66) v2(266.07,47.02) v2(266.07,46.39) v2(266.71,48.27) v2(266.71,47.66) v2(266.71,47.02) v2(266.71,46.39) v2(267.34,48.27) v2(267.34,47.66) v2(267.34,47.02) v2(267.34,46.39) v2(267.98,48.27) v2(267.98,47.66) v2(267.98,47.02) v2(267.98,46.39) v2(268.61,48.27) v2(268.61,47.66) v2(268.61,47.02) v2(268.61,46.39) v2(269.25,48.27) v2(269.25,47.66) v2(269.25,47.02) v2(269.25,46.39) v2(269.75,94.76) v2(269.75,84.36) v2(269.88,48.27) v2(269.88,47.66) v2(269.88,47.02) v2(269.88,46.39) v2(270.52,48.27) v2(270.52,47.66) v2(270.52,47.02) v2(270.52,46.39) v2(270.65,62.52) v2(270.65,61.88) v2(270.65,61.25) v2(270.65,60.61) v2(271.05,84.36) v2(272.51,84.36) v2(275.6,104.41) v4(256.73,47.15)
+1.35VS_VGA_PGOOD: length 203.7
  TOP w0.381: v2(245.98,35.15) 246.77,35.93 246.77,39.81 250.01,43.05 250.01,46.95 248.13,48.83 246.8,48.83 245.98,48.01 v2(245.02,48.01) 241.54,48.01 v1(240.72,48.83)
  TOP w0.508: v2(280.82,144.93) 280.82,144.82 279.49,143.49 UG29.1
  IN1 w0.508: v2(297.88,70.19) 294.43,73.64 294.43,81.49 289.42,91.66 288.81,93.24 287.98,95.75 286.88,100.08 286.05,105 285.86,107.69 285.86,130.38 283.19,133.05 277.84,133.05 276.37,134.53 274.7,134.53 273.27,135.95 273.27,137.55 272.41,138.42 272.41,140.07 270.46,142.03 270.46,143.36 271.48,144.39 274.46,144.39 275.73,145.66 v2(276.37,145.66) 280.31,145.66 280.82,145.15 v2(280.82,144.93)
  IN3 w0.508: v2(245.02,48.01) 245.02,48.72 246.25,49.96 253.37,49.96 253.88,49.45 259.62,49.45 261.2,51.02 274.05,51.02 275.34,49.73 278.25,49.73 278.9,49.08 280.06,49.08 280.27,48.87 288.52,48.87 288.86,49.21 293.38,49.21 296.11,51.93 296.11,61.33 297.88,63.1 v2(297.88,70.19)
  BOTTOM w0.203: PR8203.1 244.69,36.1 244.69,34.98 244.73,34.94 PU8200.13
  BOTTOM w0.254: PR8203.1 245.75,35.65 245.75,35.49 245.98,35.25 v2(245.98,35.15)
+1.35VS_VGAP: length 24.3
  TOP w0.508: PC8218.1 244.24,37.81 244.12,37.93 v2(244.12,37.93)
  IN2 w0.254: v2(244.12,37.93) 244.12,37.96 244.61,38.45 245.77,38.45 246,38.22 264.96,38.22 v2(266.01,39.28)
  BOTTOM w0.203: v2(244.12,37.93) 244.1,37.92 PR8209.2
  vias: v1(270.32,42.67)
+1V8_AON: length 495.6
  TOP w0.254: QG511.2 311.25,52.84 v2(311.77,53.36) ; v2(244.99,37.94) 244.99,36.78 244.44,36.23 242.16,36.23 241.66,36.72 237.05,36.72 236.06,37.71 236.06,39.34 233.77,41.63 233.77,47.28 231.75,49.31 225.51,49.31 224.58,48.38 219.48,48.38 218.59,47.49 v2(218.59,46.98) ; UG26.5 277.07,154.87 CG478.1 277.64,155.16 277.92,155.44 277.92,156.15 278.22,156.45 278.96,156.45 v2(279.03,156.38) 279.55,156.89 279.55,158.52 280.29,159.25 UG28.5 280.29,161.27 CG479.1
  TOP w0.356: v2(281.46,144.95) 281.46,144.37 CG483.1 281,144.11 280.42,143.54 UG29.5 ; RG503.2 221.04,111.59 221.22,111.41 222.49,111.41 222.87,111.79 ; UG22.5 215.48,158.52 v2(215.9,158.93) 215.71,159.12 CG246.1 ; RG16.2 222.87,111.79 ; 222.87,111.79 223.38,111.28 223.78,111.28 v2(223.84,111.35) ; v2(211.38,159.39) 211.38,159.28 211.45,159.2 211.45,159.19 211.63,159.01 211.64,159.01 211.73,158.92 RG516.1
  TOP w0.381: v2(218.56,112.54) 218.79,112.77 RG504.2 ; UG27.5 314.05,60.58 CG476.1 314.75,60.32 v2(315.11,60.67) ; v2(224.97,109.05) 225.04,109.13 226.45,109.13 226.75,108.82 CG291.1 227.54,108.82 v2(227.82,109.1) 227.9,109.18 227.9,109.72 v2(227.77,109.85)
  TOP w0.457: RG85.2 199.65,110.17 v2(199.42,109.93)
  TOP w0.508: RG78.2 203.53,109.51 v2(203.46,109.57) 203.44,109.55 203.01,109.55 202.97,109.51 202.59,109.51 202.52,109.57 ; 202.52,109.57 RG81.2 ; 202.52,109.57 202.52,109.92 202.56,109.96 202.56,110 202.84,110.28 RG82.2 202.97,110.52 204.21,110.52 RG79.2 ; v2(193.48,110.56) 193.21,110.83 192.45,110.83 RG510.1 ; v2(221.38,158.96) 221.04,158.96 220.56,158.48 RX5.1 220.56,157.3 v4(219.46,156.2) 219.33,156.06 v2(219.33,155.61) ; RG83.2 217.88,113.05 218.39,112.54 v2(218.56,112.54)
  IN1 w0.508: v2(219.33,155.61) 219.33,156.32 218.7,156.94 217.9,156.94 ; 217.9,156.94 215.43,156.94 v2(214.7,156.22) 214.7,155.82 215.34,155.19 v2(215.34,153.39) ; 217.9,156.94 217.9,158.08 217.05,158.93 v2(215.9,158.93) 215.4,159.43 v2(215.4,162.35) ; v2(279.03,156.38) 276.96,154.3 274.31,154.3 273.55,153.54 271.29,153.54 270.57,154.26 265.31,154.26 264.29,155.28 246.64,155.28 244.87,157.05 v2(243.66,157.05)
  IN2 w0.254: v2(244.99,37.94) 245.48,37.94 245.58,37.84 268.17,37.84 273.05,32.96 273.05,31.71 274.02,30.73 275.28,30.73 275.93,30.08 279.32,30.08 283.13,26.27 288.18,26.27 293.22,21.23 297.06,21.23 297.47,21.63 297.99,21.63 298.7,20.93 301.46,20.93 303.36,22.83 306.22,22.83 v2(306.64,23.25) ; v2(311.77,53.36) 312.35,53.94 312.35,55.25 313.58,56.48 313.58,59.15 v2(315.11,60.67)
  IN2 w0.508: v2(215.9,158.93) 214.52,160.31 212.29,160.31 v2(211.38,159.39) ; v2(215.34,153.39) 214.74,152.79 211.75,152.79 211.25,152.28 211.25,151.65 211.92,150.97 214.7,150.97 216.58,149.09 216.58,147.71 214.65,145.78 213.42,145.78 206.81,139.16 206.81,136.44 207.91,135.34 207.91,124.31 v2(208.14,124.08)
  IN4 w0.254: v2(306.64,23.25) 307.34,23.25 310.84,26.75 318.7,26.75 322.08,30.13 324.57,30.13 326.03,31.59 331.14,31.59 333.9,34.34 333.9,44.88 331.58,47.2 322.09,47.2 319.43,49.87 319.43,53.04 320.86,54.48 320.86,57.26 318.26,59.86 315.57,59.86 315.11,60.32 v2(315.11,60.67) ; v2(208.66,108.5) 208.3,108.15 208.3,102.94 209.1,102.14 209.1,55.71 209.75,55.05 211.63,53.18 211.63,50.86 213.46,49.03 215.71,49.03 216.31,48.43 217.56,48.43 218.59,47.41 v2(218.59,46.98)
  IN4 w0.508: 227.97,110.42 227.97,110.59 228.47,111.08 228.47,114.97 230.67,117.16 232.55,117.16 234.77,119.39 234.77,119.58 ; v2(281.46,144.95) 281.46,152.69 278.96,155.19 278.96,156.31 v2(279.03,156.38)
  IN6 w0.508: v2(243.66,157.05) 241.2,157.05 237.65,160.6 235.15,160.6 234.65,160.1 232.58,160.1 230.26,157.78 226.11,157.78 222.87,154.54 215.97,154.54 215.34,153.91 v2(215.34,153.39) ; v2(198.21,104.16) 198.47,103.89 199.91,103.89 201.68,105.67 201.68,107.41 201.18,107.92 v2(200.92,107.92)
  BOTTOM w0.25: v2(227.82,109.1) 227.82,109.2 UG9.BB14 ; UG9.BC14 v2(227.77,109.85)
  BOTTOM w0.254: PR8203.2 244.99,37.93 v2(244.99,37.94)
  BOTTOM w0.3: UG9.BA10 v2(224.97,109.05)
  BOTTOM w0.305: RG530.1 207.77,124.45 v2(208.14,124.08)
  BOTTOM w0.356: UG10.5 200.56,119.85 200.97,119.44 RG14.2 201.55,119.03 v2(201.58,119.07) ; RG13.2 198.54,123.53 ; 198.54,123.53 198.54,123.59 198.93,123.98 v2(199.12,123.98) ; 198.54,123.53 RG9.2 ; RG21.2 196.67,118.94 v2(196.6,119) 196.6,119.13 196.25,119.49 RG522.2 ; v2(198.21,104.16) 198.12,104.07 CG1.1 ; RG502.1 211.91,123.1 v2(211.65,122.84)
  BOTTOM w0.381: RG8.2 214.07,111.67 213.65,111.25 RG15.2 v2(213.65,110.27) ; v2(221.38,158.96) 220.84,158.96 220.76,158.88 219.76,158.88 RV648.1 ; RG2.2 v2(235.3,120.28)
  BOTTOM w0.508: v2(213.32,113.93) 213.1,114.14 RG147.1 ; UG13.3 CG66.1 211.83,105.82 v2(212.23,106.22) ; RG19.2 v2(210.51,119.86) ; RG84.2 201.32,108.31 v2(200.92,107.92) ; v2(207.34,121.23) 207.73,120.83 RG11.1 RG12.1 ; UG15.3 211.6,111.6 CG241.1 v2(212.52,111.3) ; v2(215.4,162.35) 214.32,162.35 213.81,161.84 RV652.1 ; RG20.2 206.82,117.96 207.27,117.51 v2(207.28,117.51) ; RG80.2 v2(214.13,115.54) ; v2(214.7,156.22) 214.7,156.66 RX7.1 ; RG74.1 v2(213.5,108.11)
  vias: v2(192.95,110.22) v2(193.65,108.97) v2(193.82,109.56) v2(194.42,109.47) v2(194.59,110.09) v2(199.59,112.8) v2(199.82,113.39) v2(199.88,113.98) v2(200.45,114.51) v2(200.47,113.93) v2(200.95,114.87) v2(205.7,121.7) v2(206.13,122.14)
+1V8_MAIN: length 265.8
  TOP w0.381: v2(306.09,60.7) 306.23,60.84 RG533.1
  TOP w0.508: LG3.1 225.62,118.34 v2(225.51,118.46) 225.51,118.88 224.53,119.86 LG5.1 224.31,120.84 223.39,120.84 222.96,120.4 CG21.2 CG20.1 222.96,117.65 LG4.1 ; RG512.1 190.71,104.11 191.22,104.62 v2(191.96,104.62) 192.06,104.62 192.6,104.07 RG515.1
  IN2 w0.508: v2(226.32,107.7) 226.39,107.77 226.39,110.42 226.45,110.48 226.45,116.39 225.69,117.15 225.69,118.28 v2(225.51,118.46) ; v2(328.81,40.98) 329.14,41.31 329.14,47.09 326.16,50.07 319.96,50.07 319.25,50.78 313.07,50.78 310.33,53.51 310.33,57.42 309.6,58.16 308.02,58.16 306.09,60.09 v2(306.09,60.7)
  IN4 w0.508: v2(328.81,40.98) 327.03,40.98 325.6,39.54 320.81,39.54 320.14,40.21 318.97,40.21 318.39,40.79 312.79,40.79 310.4,38.4 302.45,38.4 301.24,37.19 299.72,37.19 297.58,35.06 293.24,35.06 291.97,36.33 291.2,36.33 290.92,36.05 277.94,36.05 277.36,35.47 273.27,35.47 266.2,42.54 259.93,42.54 259.36,43.11 248.82,43.11 247.48,41.76 241.22,41.76 240.98,41.52 238.48,41.52 237.26,42.74 235.67,42.74 235.11,42.18 233.89,42.18 233.18,41.47 229.17,41.47 228.06,40.37 226.46,40.37 222.98,43.85 217.68,43.85 217.16,43.33 215.02,43.33 212.71,45.64 211.52,45.64 208.61,48.55 208.61,50.3 205.72,53.19 203.59,53.19 202.69,54.1 202.69,59.65 202.52,59.81 202.52,60.84 203.41,61.73 203.41,63.3 199.31,67.41 192.3,67.41 190.16,69.54 190.16,73.72 189.73,74.14 189.73,79.6 190.66,80.52 190.66,94.16 190.18,94.65 190.18,101.6 190.98,102.4 190.98,104.25 191.35,104.62 v2(191.96,104.62)
  BOTTOM w0.254: UG9.BD21 233.17,110.65 v2(233.43,110.65)
  vias: v2(198.27,110.23) v2(198.28,109.65) v2(198.45,110.8) v2(198.85,110.23) v2(198.88,109.57) v2(199.03,110.8) v2(204.48,107.09) v2(205.11,107.09) v2(205.62,106.68) v2(216.23,106.3) v2(216.66,106.71) v2(217.46,109.25) v2(225.63,107.7) v2(225.57,106.35) v2(225.57,105.55) v2(225.57,104.25) v2(225.57,103.45) v2(225.57,102.15) v2(226.32,106.4) v2(226.32,105.5) v2(226.32,104.3) v2(226.32,103.4) v2(226.32,102.2) v2(236.17,109.85) v2(236.22,109.1) v2(237.42,109.1) v2(237.47,109.85) v2(238.27,109.85) v2(238.32,109.1) v2(239.57,110.55) v2(239.57,109.85) v2(240.37,109.85) v2(240.42,109.1) v4(215.79,102.9)
+1V_MPHY: length 2.7
  BOTTOM w0.152: UH1.U21 v2(202.86,28.99) ; v2(202.86,27.44) UH1.U25 ; UH1.V26 v2(203.63,26.66) ; UH1.U26 v2(202.86,26.66) ; UH1.U23 v2(202.86,28.21)
  vias: v1(195.4,26.42) v2(193.64,17.98) v2(194.19,18.07)
+1V_PCH: length 12.7
  TOP w0.508: CH185.1 206.03,31.24 v2(205.96,31.31)
  BOTTOM w0.152: UH1.K3 199.23,38.66 199.14,38.75 UH1.K2 199.35,39.24 v2(199.35,40.06) ; UH1.AD15 206.24,32.42 v2(206.73,32.66) ; UH1.V17 v2(203.63,31.31) ; v2(210.32,30.83) 210.67,30.37 UH1.AN19 ; v2(202.01,30.85) 201.76,31.1 UH1.R17 ; v2(205.96,31.31) UH1.AC17 ; UH1.U20 v2(202.86,29.76) ; UH1.N17 v2(201,32.45)
  BOTTOM w0.203: v2(209.58,28.57) 209.38,28.78 UH1.AL22
  BOTTOM w0.254: v2(201.88,29.81) 201.76,29.93 UH1.R19
  BOTTOM w0.508: CH178.1 199.93,41.92 199.46,41.92 CH179.1 199.34,41.21 199.35,41.19 v2(199.35,40.06) ; CH177.1 203.44,41.52 v2(203.97,40.99)
  vias: v1(192.07,40.32) v2(209.32,34.04) v2(209.32,33.15) v2(209.32,32.38) v2(210.01,33.91) v2(209.97,33.18) v2(210.21,37.08) v2(210.98,33.74)
+1V_PCH_PRIM: length 18.6
  TOP w0.508: RH196.1 215.53,24.91 v2(215.36,25.08)
  IN1 w0.508: v2(215.36,25.08) 215.36,25.12 215.02,25.46 210.16,25.46 208.94,26.69 208.94,27.59 208.32,28.21 v2(208.28,28.21)
  BOTTOM w0.152: UH1.AE23 v2(205.96,28.21) UH1.AC23 ; UH1.AE26 v2(205.96,27.44) ; UH1.AA28 v2(205.18,26.66) ; UH1.AA26 v2(204.41,27.44) UH1.Y25 ; UH1.AA23 v2(204.41,28.21) UH1.Y23 ; UH1.AC26 v2(205.18,27.44) ; UH1.AJ20 v2(208.28,29.76) UH1.AJ21 v2(208.28,28.99) UH1.AJ23 v2(208.28,28.21) UH1.AJ25 ; UH1.AC28 v2(205.96,26.66)
  vias: v1(203.29,39.48)
+1V_VCCDSW: length 3.9
  TOP w0.381: RH196.2 v1(215.12,25.83) 214.79,25.5 CH176.1 214.02,25.5 214.02,24.87 v2(213.99,24.85)
  BOTTOM w0.254: UH1.BA29 214.06,24.96 214.05,24.96 v2(213.99,24.85)
+1VALW: length 169.6
  TOP w0.356: JPCMC.22 116.71,155.31
  TOP w0.381: 116.71,155.31 v2(116.67,155.35)
  TOP w0.508: RC353.1 129.22,158.93 v2(129.22,159.8)
  IN3 w0.508: v2(129.22,159.8) 129.22,160.07 128.33,160.96 117.55,160.96 115.13,158.54 115.13,155.86 115.64,155.35 116.67,155.35 v2(116.67,155.35)
  IN4 w0.508: v2(178.49,74.26) 176.67,76.08 176.67,92.42 180.12,95.87 180.12,107.3 181.15,108.33 181.15,118.12 188.75,125.72 188.75,145.21 183.94,150.02 167.58,150.02 166.51,151.1 166.51,152.05 165.39,153.16 165.23,153.16 163.67,154.72 163.67,158.25 162.93,159 161.81,159 161.79,159.03 157.88,159.03 156.91,160 144.13,160 142.01,157.88 139.09,157.88 138.25,157.04 136.9,157.04 135.63,158.31 130,158.31 129.22,159.1 v2(129.22,159.8)
  vias: v2(181.29,77.86) v2(181.29,77.16) v2(181.29,76.52) v2(181.29,75.89) v2(181.29,75.25) v2(181.29,74.62) v2(181.99,77.86) v2(181.99,76.52) v2(181.99,75.89) v2(181.99,75.25) v2(187.65,32.29) v2(188.06,32.71) v2(188.22,32.1) v2(188.48,33.12) v2(233.94,33.98) v2(233.94,33.39) v2(234.53,33.98) v2(239.78,29.12) v2(239.78,28.48) v2(239.78,27.85) v2(239.78,27.21) v2(240.29,29.43) v2(240.29,28.8) v2(240.29,28.16) v2(240.29,27.53) v2(240.8,29.12) v2(240.8,28.48) v2(240.8,27.85) v2(241.39,28.48) v2(244.42,27.02) v2(244.85,27.44) v2(245.32,27.79) v2(245.37,27.02) v2(245.93,27.77) v2(246.52,27.77) v4(194.34,48.46)
+1VALWP: length 18.1
  TOP w0.508: v2(243.28,14.14) 243.28,14 242.77,13.49 241.18,13.49 240.92,13.76 PR307.2
  IN6 w0.254: v2(243.28,14.14) 243.28,14.7 243.66,15.08 247.66,15.08 248.23,14.51 v2(248.99,14.51)
  BOTTOM w0.254: 246.45,21.56 246.45,18.19 248.99,15.65 v2(248.99,14.51)
  vias: v1(238.63,25.25)
+1VALWP_B+: length 1.5
  TOP w0.203: PC303.1 v1(261.55,18.07)
+1VALWP_PGOOD: length 86.6
  TOP w0.254: PR301.2 243.2,20.29 242.71,19.79 242.71,19.25 242.96,18.99 PU300.1
  TOP w0.508: PR301.2 243.2,21.16 243.91,21.88 v1(245.18,21.88) 246.33,21.88 249.31,24.86 v2(249.31,26.38)
  IN4 w0.508: v2(306.27,31.08) 306.24,31.11 276.37,31.11 274.82,29.56 268.88,29.56 264.67,25.36 260.9,25.36 260.31,25.96 257.99,25.96 256.6,27.34 250.26,27.34 v2(249.31,26.38)
  BOTTOM w0.508: v2(305.38,18.89) 305.52,18.89 306.35,19.73 306.35,21.39 305.27,22.46 305.27,27.57 304.62,28.23 304.62,29.43 v2(306.27,31.08)
+2.5V_MEM: length 88.7
  IN6 w1.016: 110.18,46.9 169.49,46.9 170.7,48.1 170.7,51.02 171.4,51.72 178.89,51.72 179.71,50.9 179.71,48.48
  BOTTOM w1.016: 179.9,48.32 179.9,50.38 180.41,50.9 180.41,54.74 181.04,55.37 181.04,58.23 179.39,59.88
  vias: v2(109.93,45.63) v2(109.93,44.93) v2(178.77,58.83) v2(178.78,58.25) v2(179.08,46.96) v2(179.52,47.4) v4(178.18,58.35)
+2.5V_MEMP: length 1.6
  BOTTOM w0.254: PC1303.1 v1(101.1,37.03)
+2.5VOUT: length 12.7
  TOP w0.203: v2(130.35,151.47) v1(129.83,151.47)
  BOTTOM w0.254: v2(137.74,155.64) 137.7,155.68 UM8.51 ; UM8.36 131.61,159.53 CM36.1 ; UM8.41 134.11,160.39 CM9.1 ; UM8.9 132.11,152.83 131.12,151.85 CM32.1 ; CM35.1 129.6,153.37 UM8.14
  BOTTOM w0.508: CM36.1 131.15,160.39 v2(131.45,160.7) ; CM32.1 v2(130.35,151.47) CM35.1 ; CM9.1 134.29,160.39 v2(134.76,160.87) ; CM34.1 138.33,155.64 v2(137.74,155.64)
+2.5VSP_ON: length 4.6
  BOTTOM w0.254: PR1301.1 v1(97.27,50.71)
  BOTTOM w0.508: PR1301.1 PR1302.1 PC1301.1 100.25,50.59 PU1300.2
+2.5VSP_VIN: length 1.6
  BOTTOM w0.203: 103.12,53.87 103.83,53.87 v1(104.48,54.52)
+3.3V_1.8V_DVDD: length 45.5
  TOP w0.203: UA4.16 36.25,13.87 36.5,14.12 v2(36.5,14.25)
  TOP w0.381: RA70.1 37.9,16.41 37.9,17.29 37.63,17.56 v1(36.9,17.56) 36.51,17.18 v2(36.51,16.98)
  IN1 w0.508: v2(39.94,29.44) 40.07,29.44 40.47,29.05 40.47,28.26 40.05,27.85 40.05,23.31 36.51,19.77 v2(36.51,16.98)
  IN3 w0.508: v2(34.3,37.5) 34.3,36.88 36.12,35.06 36.84,35.06 37.41,34.49 37.41,31.38 38.09,30.69 v2(39.06,30.69)
  BOTTOM w0.203: CA12.1 37.38,30.45 36.43,30.45 36.18,30.71 UA1.7
  BOTTOM w0.356: v2(34.3,37.5) 34.2,37.5 RA21.1
  BOTTOM w0.457: CA12.1 CA13.1 38.92,30.56 v2(39.06,30.69) ; RA32.1 39.03,28.79 39.68,29.44 v2(39.94,29.44) ; CA65.1 36.45,15.91 35.65,15.91 RA66.1
  BOTTOM w0.508: RA53.1 RA50.1 40.15,13.04 39.38,13.81 38.23,13.81 38.05,13.63 37.12,13.63 v2(36.5,14.25) 36.51,14.26 CA64.1 CA65.1 v2(36.51,16.98)
+3.3V_1.8V_DVDD_IO: length 1.1
  BOTTOM w0.127: LA3.1 32.85,21.81 v1(32.76,21.72)
+3.3V_ANA_PCIE: length 1.4
  TOP w0.254: v2(183.25,165.76) UT1.L16
  BOTTOM w0.254: v2(183.25,165.76) 183.32,165.76 183.82,166.25 CT85.1
+3.3V_ANA_USB2: length 1
  TOP w0.254: UT1.J16 v2(182.6,165.76)
  BOTTOM w0.381: v2(182.6,165.76) 182.63,165.79 CT86.1
+3.3V_F383: length 571.4
  TOP w0.254: UE3.27 225.99,159.36 225.19,158.55 ; CE25.1 188.41,23.73 188.41,23.04 188.6,22.85 UE4.27 ; UE8.27 303.92,36.98 303.67,36.72 303.67,36.25 302.81,35.4 CE168.1
  TOP w0.508: RE15.1 v2(290.72,33.92) ; v2(313.97,21.28) 314.55,21.28 315.1,20.73 RE8.1 ; v2(316.8,28.24) 321.57,33.01 321.57,34.31 324.18,36.91 RE23.1 ; RE2.1 RE1.1 v2(311.56,21.24) ; RE652.1 144.98,164.6 v2(145.14,164.75) ; CE25.1 189.01,24.06 189.62,24.67 v2(189.62,25.75) ; v2(224.27,159.26) 224.68,159.26 225.19,158.76 CE24.1 ; v2(223.44,156.1) 223.68,155.86 RE40.1 RE43.1 ; v2(224.05,159.89) 224.05,160.81 224.47,161.23 RE25.1 ; v2(322.83,8.81) 323.67,9.65 RE7.1 ; CE168.1 301.7,35.6 v2(301.7,36.1) ; v2(300.78,38.03) RE166.1 ; v2(303.15,29.29) RE165.1
  IN2 w0.508: v2(311.56,21.24) 312.17,21.85 313.4,21.85 v2(313.97,21.28) ; v2(224.05,159.89) 222.92,159.89 222.77,159.73 221.38,159.73 221.24,159.59 221.13,159.59 220.86,159.33 220.86,159.28 220.77,159.19 220.77,159.12 220.47,158.82 217.52,158.82 215.4,160.94 210.42,160.94 206.92,164.44 206.92,172.4 205.72,173.6 200.4,173.6 v2(198.82,175.18)
  IN2 w1.016: 165.4,22.42 150.97,22.42 149.47,23.92 127.89,23.92 122.33,18.36 105.02,18.36 ; 310.66,47.28 307.5,50.44 307.5,56.49 305.82,58.16 299.7,58.16 299.01,58.84 299.01,60.51 299.59,61.09 299.59,62.52 298.41,63.71 298.41,68.08 294.28,72.21 294.28,78.23 294.32,78.27 294.64,80.4 288.91,92.18 287.54,96.5 286.62,100.15 285.84,104.72 285.61,107.68 285.61,143.14 282.47,146.27 278.51,146.27 270.6,154.18 267.09,154.18 264.85,151.95 257.29,151.95 255.98,153.26 252.13,153.26 250.58,151.71 243.72,151.71 242.19,153.24 238.35,153.24 236.89,151.79 230.12,151.79 228.89,153.02 225.27,153.02 ; 185.87,22.26 180.98,22.26 180.82,22.42 167.84,22.42
  IN3 w0.508: v2(145.14,164.75) 145.3,164.92 145.3,167.67 148.32,170.68 148.32,173.9 149,174.59 149,176.72 150.24,177.96 159.01,177.96 163.63,182.58 172.41,182.58 173.64,181.35 173.64,178.12 175.83,175.93 178.41,175.93 178.89,176.41 184.77,176.41 185.39,175.79 186.69,175.79 187.8,174.67 192.08,174.67 193.4,173.35 197.56,173.35 198.82,174.61 v2(198.82,175.18)
  IN4 w0.254: 221.76,11 223.5,11 223.73,11.23 241.59,11.23 241.85,11.5 ; 242.07,12.25 241.79,12.53 222.06,12.53 221.1,11.58 ; 221.8,11.5 222.18,11.88 241.91,11.88 ; 242.25,11.31 241.5,10.56 221.48,10.56
  IN4 w1.016: 220.76,10.74 201.03,10.74 200.29,11.48 198.15,11.48 197.59,10.92 188.56,10.92 187.46,12.02 187.46,12.54 ; 243.47,11.84 255.28,11.84 255.86,12.43 259.41,12.43 260.28,13.29 264.42,13.29 265.87,14.74 267.24,14.74
  BOTTOM w0.508: v2(103.89,18.45) 104.72,17.62 104.72,15.15 103.85,14.28 RE12.1 ; RE14.1 99.3,14.28 98.68,14.9 98.68,17.3 99.25,17.88 101.64,17.88 101.67,17.84 102.18,17.84 102.79,18.45 v2(103.26,18.45)
  vias: v2(102.36,27.13) v2(103.08,25.6) v2(166.31,22.45) v2(166.89,22.45) v2(185.97,25.75) v2(187.13,13.43) v2(187.72,13.43) v2(223.9,153.6) v2(224.48,153.6) v2(302.14,11.37) v2(302.66,11.11) v2(315.09,31.97) v2(315.74,31.97) v2(317.7,7.78) v2(318.33,7.78) v2(323.35,48.04) v2(324.11,48.04) v4(186.57,26.36)
+3.3V_FLASH: length 51.6
  TOP w0.381: RT67.1 RT66.1 198.62,159.47 198.11,158.95 197.39,158.95 196.88,159.46 196.88,160.26
  TOP w0.508: 195.14,161 189.3,155.16 v2(188.06,155.16)
  IN2 w0.508: v2(197.61,160.28) 197.9,160.28 198.64,159.53 200.88,159.53 202.08,158.34 205.05,158.34 205.3,158.59 206.88,158.59 208.24,159.95 208.24,162.14 v2(207.87,162.5)
  BOTTOM w0.203: v2(195.27,162.97) 195.42,163.13 197.64,163.13 197.7,163.07 UT4.G1
  BOTTOM w0.254: UT4.B1 197.89,160.57 v2(197.61,160.28)
  BOTTOM w0.381: RT74.1 208.2,162.88 207.87,162.55 v2(207.87,162.5)
  BOTTOM w0.508: CT103.1 195.6,162.64 v2(195.27,162.97) ; UT2.8 190.18,153.4 189.16,154.41 CT45.1 188.57,154.41 188.06,154.92 v2(188.06,155.16) 188.54,155.65 188.54,157.93 187.91,158.57 187.91,159.15 RT51.1 187.12,159.93 187.12,161.03 186.76,161.39 186.76,162.59 187.16,162.99 RT50.1 RT49.2 188.48,163.8 188.84,164.16 189.55,164.16 190,163.71 RT48.1
  vias: v4(195.17,162.05)
+3.3V_LC: length 25
  TOP w0.127: v4(171.82,155.03) v2(171.82,155.67)
  TOP w0.203: UT1.R6 v2(178.71,163.15)
  IN3 w0.508: v2(178.71,163.15) 178.71,162.51 179.31,161.92 179.31,160.94 178.45,160.09 176.98,160.09 176.44,160.64 176.44,162.28 175.45,163.27 v2(175.42,163.27) 175.42,163.27 175.21,163.49 173.94,163.49 173.74,163.29 173.74,162.4 173.3,161.96 173.3,159.23 172.15,158.08 172.15,156 v2(171.82,155.67)
  BOTTOM w0.381: v2(171.82,155.67) 171.84,155.67 172.25,155.26 RT9.1 172.56,155.26 172.93,155.63 RT6.1 ; RT8.1 RT7.1 175.65,163.04 v2(175.42,163.27) ; CT46.1 178.75,163.11 v2(178.71,163.15)
+3.3V_TBT_SX: length 53.8
  TOP w0.254: RT28.1 RT29.1 173.94,161.5 v2(173.98,161.45) ; RT31.1 171.78,162.65 v2(172.83,162.65) 172.87,162.69 173.51,162.69 RT26.1 RT27.1 ; RT32.1 170.02,164.85 v2(170.49,164.85) 170.61,164.85 171.17,165.41 RT33.1 ; RT30.1 171.15,167.23 170.58,166.66 v2(170.51,166.66) ; v2(178.71,167.69) 178.72,167.69 179.02,167.38 UT1.F8
  TOP w0.381: RT61.2 v2(197.11,169.16)
  IN3 w0.508: v2(197.11,169.16) 196.72,169.55 193.66,169.55 192.71,168.6 191.79,168.6 190.92,169.47 179.6,169.47 178.71,168.58 v2(178.71,167.69)
  IN6 w0.508: v2(170.51,166.66) 169.83,167.33 169.83,173.44 172.63,176.23 174.71,176.23 176.37,174.57 179.66,174.57 v2(179.89,174.34)
  BOTTOM w0.254: RT94.1 v1(169.91,164.27) 169.91,164.6 170.16,164.85 v2(170.49,164.85)
  BOTTOM w0.381: 177.36,168.93 177.36,168.94 177.8,168.94 178.11,168.62 CT47.1 178.7,167.68 v2(178.71,167.69) ; RT70.1 v2(197.11,169.16)
  BOTTOM w0.508: RT97.2 179.76,174.47 v2(179.89,174.34)
+3.3V_TBT_SX_R: length 7.9
  TOP w0.381: RT61.1 CT102.1 196.15,167.55 v2(195.6,167.55)
  BOTTOM w0.076: 198.41,163.82 198.05,163.82 198.05,163.82 197.96,163.82
  BOTTOM w0.089: UT4.H2 198.41,163.82
  BOTTOM w0.152: 196.54,164.78 197.29,164.03 197.69,164.03 197.89,163.82 197.96,163.82
  BOTTOM w0.508: 196.54,164.78 195.94,164.78 195.27,165.45 v1(195.27,166.59) 195.6,166.92 v2(195.6,167.55)
+3V3_SYS: length 319.3
  TOP w0.254: v2(240.34,38.45) PR821.2 240.34,39.52 240.86,40.04 244.31,40.04 v4(245.79,41.52) 247.42,43.15 v2(247.42,46.82) ; v2(298.2,53.75) PR6408.2 ; v2(308.84,56.3) 308.55,56.6 PR6436.2
  TOP w0.508: v2(198.21,106.14) 198.03,105.96 195,105.96 RG514.1
  IN1 w0.254: v2(298.2,53.75) 299.83,55.37 304.67,55.37 305.61,56.3 v2(308.84,56.3)
  IN2 w0.508: v2(198.21,106.14) 200.62,106.14 201.49,105.26 201.61,105.26 201.88,105 206.26,105 207.02,104.24 212.04,104.24 212.11,104.16 217.95,104.16 v2(218.19,103.92) ; v2(195.61,122.52) 194.48,122.52 v2(191.99,120.02) 192.53,119.49 194.84,119.49 195.28,119.04 195.28,118.35 v2(196.76,116.87)
  IN3 w0.254: v2(247.42,46.82) 247.42,47.12 247.99,47.68 260.26,47.68 261.33,48.75 272.69,48.75 273.88,47.56 293.37,47.56 298.2,52.4 v2(298.2,53.75) ; v2(212.02,57.69) 212.02,53.65 209.9,51.53 209.9,48.13 210.87,47.15 214.32,47.15 218.22,43.25 223.65,43.25 225.18,41.71 227.68,41.71 228.38,41.01 231.19,41.01 231.53,40.67 235.3,40.67 236.35,39.63 239.17,39.63 v2(240.34,38.45)
  IN4 w0.254: v2(218.19,103.92) 218.19,102.39 219.02,101.57 219.02,96.92 212.37,90.27 212.37,87.04 212.38,85.07 212.37,85.05 212.37,60.85 212.95,60.27 212.95,58.5 212.14,57.69 v2(212.02,57.69)
  IN4 w0.508: 199.01,116.55 199.01,113.55 197.66,112.21 197.66,111.86 196.16,110.37 196.16,109.06 195.25,108.15 195.25,107.02 196.12,106.14 v2(198.21,106.14) ; 198.69,117.33 199.01,117.33 200,118.32 200,119.25 199.75,119.49 199.75,120.67 201.81,122.73 201.81,123.73 200.62,124.93 200.62,127.21 200.16,127.67 200.16,129.72 200.75,130.32 200.75,139 200,139.75 200,141.92 201.11,143.03 201.11,146.11 199.48,147.75 197.93,147.75 195.41,150.26 195.41,154.36 197.31,156.25 202.2,156.25 204.67,158.72 205.2,158.72 206.89,160.41 207.73,160.41 209.74,162.42 v2(209.74,162.52) 211.67,164.45 211.67,165.04 213.03,166.4 222.43,166.4 224.68,164.15 225.63,164.15 v2(225.68,164.11)
  BOTTOM w0.457: CG323.1 195.82,106.75 195.56,107.01 UG14.6 ; UG11.4 192.16,119.16 192.99,119.98 CG61.1
  BOTTOM w0.508: QG5.2 196.17,121.95 v2(195.61,122.52) ; QX1.2 224.42,164.38 RX1.1 225.66,164.13 v2(225.68,164.11) ; v2(209.74,162.52) 209.54,162.32 209.54,161.54 RV655.1 ; CG61.1 192.45,120.48 v2(191.99,120.02) ; v2(198.21,106.14) 198.21,106.16 197.61,106.75 CG385.1 CG323.1
