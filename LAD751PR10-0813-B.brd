# Allegro board LAD751PR10-0813-B.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 198.03,184.56 198.03,177.63 197.7,177.3 196.69,177.3 195.86,178.13 195.86,179.33 196.27,179.73 196.7,179.73 197.07,180.1 197.07,180.89 197.07,180.89 197.07,181.07 196.87,181.26 195.92,181.26 195.7,181.48 195.7,184.44 196.02,184.75 197.84,184.75
GND on TOP (solid shape): 258.78,18.78 258.78,18.64 258.77,18.64 258.77,15.28 258.63,15.15 258.63,14.52 258.43,14.32 256.29,14.32 256.1,14.51 256.1,17.43 256.27,17.59 257.41,17.59 257.63,17.81 257.63,18.64 257.82,18.83 258.73,18.83
GND on TOP (solid shape): 301.32,35.72 301.32,35.45 301.32,35.08 301.44,34.96 301.76,34.96 301.89,34.83 301.89,34.51 301.82,34.45 301.44,34.45 301.32,34.32 301.32,32.73 301.25,32.67 300.24,32.67 299.86,33.05 299.86,35.85 299.98,35.97 301.06,35.97
GND on TOP (solid shape): 147.34,114.58 147.34,112.04 146.83,111.54 146.83,108.93 146.7,108.8 146.32,108.8 146.13,109 146.13,109.73 146.14,109.82 146.13,109.91 146.13,111.85 146.26,111.98 146.26,114.58 146.38,114.71 147.21,114.71
GND on TOP (solid shape): 158.32,105.38 158.32,104.11 158.26,104.04 157.24,104.04 157.05,103.85 157.05,102.45 156.92,102.33 156.1,102.33 156.04,102.39 156.04,103.72 156.16,103.85 156.48,103.85 156.54,103.91 156.57,103.91 156.57,103.94 156.73,104.11 156.73,105.44 156.86,105.57 158.13,105.57
GND on TOP (solid shape): 161.88,105.44 161.88,103.03 161.81,102.96 160.86,102.96 160.8,103.03 160.8,103.57 160.81,103.66 160.8,103.75 160.8,103.85 160.61,104.04 160.42,104.04 160.35,104.11 160.35,105.5 160.42,105.57 161.75,105.57
GND on TOP (solid shape): 206.05,104.05 206.05,103.55 205.67,103.16 203.31,103.16 203.08,102.93 201.57,102.93 201.46,103.04 201.46,103.6 201.6,103.74 202.31,103.74 202.45,103.88 202.45,104.17 202.69,104.41 205.68,104.41
GND on TOP (solid shape): 214.83,170.36 214.83,165.52 214.64,165.34 213.29,165.34 213.11,165.51 213.11,166.66 212.73,167.04 212.05,167.04 211.82,167.28 211.82,168.05 212.51,168.73 212.51,169.73 212.68,169.91 213.53,169.91 213.8,170.17 213.8,170.43 213.93,170.55 214.64,170.55
GND on TOP (solid shape): 154.7,105.44 154.7,103.75 154.69,103.66 154.7,103.57 154.7,102.3 154.73,102.3 155.08,101.95 155.08,101.57 155.02,101.5 154.13,101.5 154,101.63 154,105.38 154.13,105.5 154.64,105.5
GND on TOP (solid shape): 167.53,114.77 167.53,114.27 167.47,114.2 166.96,114.2 166.77,114.01 166.77,109.76 166.89,109.63 166.89,106.39 166.83,106.33 166.13,106.33 166.01,106.46 166.01,109.69 166.2,109.88 166.2,114.77 166.32,114.9 167.4,114.9
GND on TOP (solid shape): 177.68,52.48 177.68,51.91 177.62,51.85 176.98,51.85 176.44,51.31 176.44,50.42 177.11,49.75 177.49,49.75 177.81,49.44 177.81,47.59 177.3,47.09 177.3,46.51 176.92,46.13 176.92,45.63 176.73,45.43 175.52,45.43 175.01,45.94 175.01,51.66 175.9,52.55 177.62,52.55
GND on TOP (solid shape): 203.15,161.45 203.46,161.45 203.53,161.39 203.53,160.5 203.46,160.43 201.62,160.43 201.3,160.75 201.3,160.93 201.31,160.94 201.33,161.03 201.33,161.13 201.32,161.15 201.68,161.51 201.68,161.77 201.81,161.89 202.7,161.89
GND on TOP (solid shape): 172.93,146.48 172.93,145.75 172.84,145.66 172.23,145.66 171.84,145.27 171.84,145 171.68,144.84 171.04,144.84 170.78,145.1 168.44,145.1 168.28,145.26 168.28,146.42 168.51,146.65 172.75,146.65
GND on TOP (solid shape): 64.84,26.51 67.89,26.51 68.3,26.1 68.3,24.96 68.14,24.8 65.86,24.8 65.35,24.29 65.35,22.13 65.29,22.07 64.4,22.07 63.95,21.62 63.45,21.62 63.32,21.75 63.32,23.65 62.94,24.04 62.05,24.04 61.6,24.48 61.35,24.48 61.16,24.67 61.16,26.51 61.29,26.64 64.72,26.64
GND on TOP (solid shape): 296.17,59.85 296.17,57.47 296.16,57.38 296.17,57.3 296.17,50.64 298.08,48.74 298.08,46.33 297.62,45.88 294.21,45.88 291.79,48.3 291.79,50.51 289.96,52.34 289.96,59.51 291.5,61.04 294.98,61.04
GND on TOP (solid shape): 9.57,66.3 1.27,66.3 1.27,72.1 1.51,72.66 2.07,72.9 9.57,72.9
GND on TOP (solid shape): 139.91,114.58 139.91,108.87 139.78,108.74 139.34,108.74 139.08,109 139.08,109.73 139.09,109.82 139.08,109.91 139.08,111.73 138.83,111.98 138.83,113.22 138.84,113.31 138.83,113.41 138.83,114.58 138.89,114.65 139.84,114.65
GND on TOP (solid shape): 149.81,114.52 149.81,111.6 149.24,111.03 149.24,108.8 149.18,108.74 148.73,108.74 148.61,108.87 148.61,109.73 148.62,109.82 148.61,109.91 148.61,111.79 148.73,111.92 148.73,113.28 148.75,113.38 148.73,113.47 148.73,114.65 149.69,114.65
GND on TOP (solid shape): 158.95,127.6 158.95,125.81 156.93,123.79 154.81,123.79 154.5,123.96 154.2,123.79 153.99,123.79 153.99,126.61 154.54,127.16 156.03,127.16 156.6,127.73 158.82,127.73
GND on TOP (solid shape): 180.55,183.6 180.87,183.45 181.22,183.4 183.56,183.4 184.34,183.4 184.69,183.45 185.01,183.6 186.22,183.6 186.22,176.7 180.22,176.7 180.22,183.6
GND on TOP (solid shape): 144.86,114.58 144.86,111.98 144.48,111.6 144.48,108.8 144.35,108.68 143.91,108.68 143.72,108.87 143.72,109.73 143.73,109.82 143.72,109.91 143.72,111.73 143.78,111.79 143.78,113.22 143.79,113.31 143.78,113.41 143.78,114.58 143.84,114.65 144.8,114.65
GND on TOP (solid shape): 95.26,35.8 95.26,34.96 95.13,34.83 95.13,33.43 95.26,33.31 96.02,33.31 96.08,33.37 96.08,34.64 96.15,34.7 96.53,34.7 96.66,34.58 96.66,31.75 94.5,29.59 90.46,29.59 90.24,29.81 90.24,31.27 90.37,31.4 93.48,31.4 93.73,31.66 93.73,32.8 93.35,33.18 93.35,35.72 93.54,35.91 95.15,35.91
GND on TOP (solid shape): 142.38,114.58 142.38,111.92 142.19,111.73 142.19,108.87 142.13,108.8 141.56,108.8 141.3,109.06 141.3,109.61 141.38,109.82 141.3,110.03 141.3,113.22 141.32,113.31 141.3,113.41 141.3,114.58 141.37,114.65 142.32,114.65
GND on TOP (solid shape): 285.45,46.18 285.45,41.08 285.57,40.97 285.57,40.19 285.59,40.19 285.59,39.3 285.66,39.3 285.66,37.66 285.44,37.45 285.44,37.29 285.43,37.18 285.44,37.08 285.44,36.21 285.33,36.09 284.84,36.09 284.63,36.31 284.63,37.99 284.15,38.48 284.15,42.73 283.41,43.47 283.41,46.26 283.6,46.45 285.19,46.45
GND on TOP (solid shape): 148.4,146.19 148.4,145.62 148.66,145.36 148.66,139.42 148.09,138.85 146.37,138.85 146.12,139.1 146.12,142.28 145.48,142.91 141.1,142.91 140.91,143.1 140.91,144.12 141.04,144.24 141.63,144.24 141.8,144.41 141.8,144.95 142.1,145.25 142.53,145.25 142.6,145.33 142.6,145.74 142.82,145.95 146.33,145.95 146.84,145.45 147.63,145.45 147.7,145.52 147.7,146.14 147.79,146.24 148.35,146.24
GND on TOP (solid shape): 241.97,35.16 242.36,35.16 242.59,34.94 242.59,34.64 242.42,34.47 242.18,34.47 241.96,34.69 241.96,34.84 241.19,34.84 241.19,34.83 241.13,34.83 241.01,34.71 241.01,31.49 240.9,31.38 240.37,31.38 240.28,31.47 240.28,32.07 240.09,32.26 239.78,32.26 239.65,32.39 239.65,32.6 239.8,32.75 240.07,32.75 240.25,32.93 240.25,34.69 240.26,34.69 240.26,35.05 240.39,35.18 241.96,35.18
GND on TOP (solid shape): 161.69,115.35 161.69,115.12 161.69,115.09 161.62,115.03 161.62,112.36 161.69,112.3 162.07,112.3 162.26,112.11 162.26,109.57 161.97,109.28 161.94,109.28 161.94,109.25 161.88,109.19 161.88,108.36 161.81,108.3 160.93,108.3 160.86,108.36 160.86,109.25 160.54,109.57 160.54,113.67 160.56,113.76 160.54,113.85 160.54,115.03 160.48,115.09 160.48,115.12 160.45,115.12 160.29,115.28 160.29,115.47 160.42,115.6 161.43,115.6
GND on TOP (solid shape): 146.48,149.39 147.37,149.39 147.49,149.26 147.49,148.16 147.4,148.07 146,148.07 146,148.6 145.78,148.83 144.6,148.83 144.34,148.56 144.34,147.37 144.14,147.17 143.41,147.17 143.41,147.17 143.21,147.17 143.06,147.02 143.06,146.81 142.83,146.58 142.26,146.58 141.86,146.97 141.86,148.12 141.99,148.24 142.79,148.24 143.26,148.72 143.26,148.86 143.29,148.98 143.26,149.11 143.26,149.21 143.45,149.39 143.45,149.39 143.84,149.77 146.1,149.77
GND on TOP (solid shape): 163.91,115.45 163.91,115.15 164.07,115 164.45,115 164.48,114.96 164.48,112.61 164.23,112.36 164.23,108.55 163.97,108.3 163.27,108.3 163.21,108.36 163.21,108.4 163.22,108.48 163.21,108.58 163.21,112.23 162.96,112.49 162.96,113.67 162.97,113.76 162.96,113.85 162.96,115 162.7,115.26 162.7,115.47 162.77,115.54 162.77,115.54 162.83,115.59 163.76,115.59
GND on TOP (solid shape): 268.22,10 270.69,8.97 271.72,6.5 271.72,3.2 258.57,3.2 258.57,10
GND on TOP (solid shape): 154.58,115.41 154.58,115.28 154.38,115.09 154.38,112.42 154.51,112.3 154.83,112.3 155.02,112.11 155.02,109.69 154.64,109.31 154.64,108.42 154.51,108.3 154.26,108.3 154.19,108.36 154.19,109.42 154.27,109.63 154.19,109.84 154.19,109.99 154.27,110.2 154.19,110.41 154.19,110.46 153.81,110.84 153.81,115.41 153.94,115.54 154.45,115.54
GND on TOP (solid shape): 156.86,149.42 156.86,148.72 156.64,148.49 156.2,148.49 156.05,148.34 155.29,148.34 155.11,148.16 154.59,148.16 154.54,148.2 154.54,148.73 154.4,148.87 153.29,148.87 153.29,148.86 153.18,148.86 152.92,148.6 152.92,147.5 152.63,147.22 151.61,147.22 151.42,147.02 151.42,146.66 151.16,146.4 150.63,146.4 150.25,146.78 150.25,148.18 150.31,148.24 150.98,148.24 151.42,148.69 151.51,148.75 151.58,148.85 151.62,148.88 151.62,149.03 151.62,149.2 151.93,149.51 156.78,149.51
GND on TOP (solid shape): 322.89,24.17 322.89,23.99 322.89,23.98 322.89,22.26 322.7,21.97 322.84,21.66 322.88,21.62 322.83,21.57 322.82,21.56 322.72,21.49 322.64,21.39 322.64,21.38 321.24,21.38 321.14,21.48 321.14,22.1 320.91,22.33 319.73,22.33 319.56,22.5 319.56,23 319.66,23.1 320.29,23.1 320.73,23.54 320.73,24.17 321.05,24.49 322.56,24.49
GND on TOP (solid shape): 33.17,13.78 33.17,12.26 33.3,12.13 34.38,12.13 34.5,12.26 34.5,13.72 34.57,13.78 35.08,13.78 35.14,13.72 35.14,12.26 35.27,12.13 36.35,12.13 36.35,7.49 36.09,7.49 35.96,7.37 35.96,5.88 35.89,5.8 35.42,5.8 35.33,5.89 35.33,7.37 35.2,7.49 32.98,7.49 32.79,7.3 32.79,5.88 32.69,5.78 32.22,5.78 32.14,5.85 32.14,7.1 31.73,7.51 31.73,10.07 31.5,10.31 30.1,10.31 30.05,10.36 30.05,10.86 30.12,10.93 31.59,10.93 31.77,11.11 31.77,12.13 32.79,12.13 32.92,12.26 32.92,13.78 32.98,13.84 33.11,13.84
GND on TOP (solid shape): 151.84,106.74 151.84,106.42 151.78,106.36 151.46,106.36 151.34,106.23 151.34,106.22 151.32,106.21 151.26,106.01 151.32,105.81 151.34,105.8 151.34,105.79 151.46,105.66 151.72,105.66 151.84,105.53 151.84,105.15 151.78,105.09 151.46,105.09 151.34,104.96 151.34,104.95 151.32,104.94 151.26,104.75 151.31,104.56 151.34,104.52 151.27,104.46 150.77,104.46 150.7,104.52 150.7,106.87 150.77,106.93 151.65,106.93
GND on TOP (solid shape): 140.35,106.71 140.35,106.39 140.29,106.33 140.25,106.33 140.16,106.34 140.07,106.33 139.97,106.33 139.84,106.2 139.84,106.1 139.83,106.01 139.84,105.92 139.84,105.76 139.97,105.63 140.22,105.63 140.35,105.5 140.35,105.12 140.29,105.06 140.25,105.06 140.16,105.07 140.07,105.06 139.97,105.06 139.84,104.93 139.84,104.83 139.83,104.74 139.84,104.65 139.84,104.49 139.78,104.42 139.27,104.42 139.21,104.49 139.21,106.84 139.27,106.9 140.16,106.9
GND on TOP (solid shape): 165.48,105.9 165.49,105.84 165.5,105.79 165.5,104.58 165.49,104.53 165.48,104.47 165.31,104.3 164.8,104.3 164.46,103.96 164.45,103.95 164.37,103.9 164.31,103.81 164.23,103.72 164.23,102.45 164.16,102.39 163.85,102.39 163.78,102.46 163.75,102.53 163.72,102.59 163.72,102.71 163.59,102.84 163.4,102.84 163.21,103.03 163.21,103.72 163.34,103.85 163.66,103.85 163.91,104.11 163.91,105.88 164.1,106.07 165.31,106.07
GND on TOP (solid shape): 163.52,146.3 163.52,145.38 163.28,145.14 159.76,145.14 159.36,144.74 158.79,144.74 158.65,144.61 158.65,144.09 158.65,144.09 158.65,143.96 158.73,143.88 158.86,143.88 159.03,143.71 159.03,143.47 158.93,143.36 158.66,143.36 158.39,143.63 157.88,143.63 157.75,143.76 157.75,144.53 157.75,145.29 157.85,145.39 158.53,145.39 158.82,145.68 158.89,145.69 158.95,145.71 159.03,145.76 159.1,145.84 159.14,145.94 159.15,146.05 159.14,146.12 159.54,146.52 163.3,146.52
GND on TOP (solid shape): 142.64,106.74 142.64,106.42 142.59,106.38 142.55,106.39 142.42,106.4 142.29,106.37 142.28,106.36 142.26,106.36 142.13,106.23 142.13,106.17 142.12,106.07 142.13,105.98 142.13,105.79 142.26,105.66 142.51,105.66 142.64,105.53 142.64,105.15 142.59,105.11 142.55,105.12 142.42,105.13 142.29,105.1 142.28,105.09 142.26,105.09 142.13,104.96 142.13,104.9 142.12,104.8 142.13,104.71 142.13,104.52 142.07,104.46 141.56,104.46 141.49,104.52 141.49,106.87 141.56,106.93 142.45,106.93
GND on TOP (solid shape): 147.21,106.74 147.21,106.42 147.16,106.38 147.12,106.39 146.99,106.4 146.87,106.37 146.85,106.36 146.83,106.36 146.7,106.23 146.7,106.17 146.69,106.07 146.7,105.98 146.7,105.79 146.83,105.66 147.08,105.66 147.21,105.53 147.21,105.15 147.16,105.11 147.12,105.12 146.99,105.13 146.87,105.1 146.85,105.09 146.83,105.09 146.7,104.96 146.7,104.9 146.69,104.8 146.7,104.71 146.7,104.52 146.64,104.46 146.13,104.46 146.07,104.52 146.07,106.87 146.13,106.93 147.02,106.93
GND on TOP (solid shape): 149.56,106.74 149.56,106.42 149.51,106.38 149.47,106.39 149.34,106.4 149.21,106.37 149.2,106.36 149.18,106.36 149.05,106.23 149.05,106.17 149.04,106.07 149.05,105.98 149.05,105.79 149.18,105.66 149.43,105.66 149.56,105.53 149.56,105.15 149.51,105.11 149.47,105.12 149.34,105.13 149.21,105.1 149.2,105.09 149.18,105.09 149.05,104.96 149.05,104.9 149.04,104.8 149.05,104.71 149.05,104.52 148.99,104.46 148.48,104.46 148.42,104.52 148.42,106.87 148.48,106.93 149.37,106.93
GND on TOP (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on TOP (solid shape): 144.92,106.74 144.92,106.42 144.86,106.36 144.84,106.36 144.42,106.3 144.4,105.88 144.42,105.86 144.42,105.79 144.54,105.66 144.8,105.66 144.92,105.53 144.92,105.15 144.86,105.09 144.84,105.09 144.42,105.03 144.4,104.61 144.42,104.59 144.42,104.52 144.35,104.46 143.84,104.46 143.78,104.52 143.78,106.87 143.84,106.93 144.73,106.93
GND on TOP (solid shape): 234.2,115.35 234.2,112.81 234.32,112.68 234.32,111.22 234.13,111.03 233.18,111.03 233.05,111.16 233.05,112 233.59,112 233.59,111.94 233.6,111.89 233.62,111.84 233.65,111.79 233.68,111.75 233.72,111.72 233.76,111.69 233.81,111.66 233.86,111.65 233.92,111.64 233.97,111.64 234.02,111.65 234.07,111.66 234.12,111.69 234.17,111.72 234.2,111.75 234.24,111.79 234.26,111.84 234.28,111.89 234.3,111.94 234.3,112 234.3,112.05 234.28,112.1 234.26,112.15 234.24,112.2 234.2,112.24 234.17,112.27 234.12,112.3 234.07,112.33 234.02,112.34 233.97,112.35 233.92,112.35 233.86,112.34 233.81,112.33 233.76,112.3 233.72,112.27 233.68,112.24 233.65,112.2 233.62,112.15 233.6,112.1 233.59,112.05 233.59,112 233.05,112 233.19,112.13 233.19,112.14 233.19,115.42 233.35,115.58 233.97,115.58
GND on TOP (solid shape): 222.94,43.65 222.94,41.64 223.15,41.43 224.68,41.43 224.89,41.23 224.89,40.41 224.77,40.29 224.34,40.29 224.22,40.41 221.04,40.41 220.25,41.2 220.25,41.69 220.26,41.72 220.31,41.74 220.35,41.71 220.76,41.55 221.01,41.92 220.94,42.11 220.77,42.23 220.53,42.23 220.36,42.08 220.31,42.06 220.27,42.08 220.25,42.12 220.25,43.66 220.53,43.94 222.66,43.94
GND on TOP (solid shape): 51.15,37.2 51.15,33.17 51.05,33.06 50.82,33.06 50.24,32.48 50.22,32.48 49.54,31.79 49.54,31.53 49.03,31.02 47.33,31.02 47.23,31.11 47.23,32.05 47.04,32.25 46.44,32.25 46.42,32.23 46.4,32.23 45.79,31.62 45.79,31.6 45.62,31.43 45.62,30.56 45.62,30.56 45.62,30.41 45.55,30.33 44.8,30.33 44.71,30.42 44.71,32.54 45.28,33.12 46.49,33.12 46.81,33.43 46.81,34.83 47.06,35.08 48.71,35.08 48.87,35.24 48.9,35.24 49.18,35.51 48.93,35.8 48.87,35.84 48.84,35.9 48.84,36.29 48.59,36.54 47.63,36.54 47.57,36.61 47.57,37.43 47.76,37.62 50.73,37.62
GND on TOP (solid shape): 221.92,120.64 221.92,118.33 221.86,118.26 221.17,118.26 220.97,118.46 218.04,118.46 217.97,118.53 217.98,118.56 217.99,118.61 217.99,118.67 217.99,118.72 217.97,118.77 217.95,118.83 217.92,118.87 217.88,118.91 217.84,118.95 217.81,118.96 217.81,120.31 220.37,120.31 220.37,120.26 220.38,120.21 220.4,120.16 220.43,120.11 220.46,120.07 220.5,120.03 220.54,120 220.59,119.98 220.64,119.97 220.7,119.96 220.75,119.96 220.8,119.97 220.85,119.98 220.9,120 220.94,120.03 220.98,120.07 221.02,120.11 221.04,120.16 221.06,120.21 221.08,120.26 221.08,120.31 221.08,120.37 221.06,120.42 221.04,120.47 221.02,120.51 220.98,120.56 220.94,120.59 220.9,120.62 220.85,120.65 220.8,120.66 220.75,120.67 220.7,120.67 220.64,120.66 220.59,120.65 220.54,120.62 220.5,120.59 220.46,120.56 220.43,120.51 220.4,120.47 220.38,120.42 220.37,120.37 220.37,120.31 217.81,120.31 217.81,120.59 218.01,120.79 221.77,120.79
GND on TOP (solid shape): 152.23,114.58 152.23,113.19 152.48,112.93 152.48,111.34 152.35,111.22 152.35,107.73 152.23,107.6 151.65,107.6 151.59,107.66 151.59,107.7 151.6,107.79 151.59,107.88 151.59,107.98 151.4,108.17 151.15,108.17 151.02,108.3 151.02,108.55 151.08,108.61 151.4,108.61 151.59,108.8 151.59,108.97 151.6,109.06 151.59,109.15 151.59,109.25 151.46,109.38 151.37,109.38 151.27,109.39 151.18,109.38 151.15,109.38 151.02,109.5 151.02,109.82 151.15,109.95 151.46,109.95 151.59,110.07 151.59,110.3 151.6,110.39 151.59,110.49 151.59,110.58 151.4,110.77 151.15,110.77 151.02,110.9 151.02,111.09 151.15,111.22 151.15,111.63 151.16,111.73 151.15,111.82 151.15,114.58 151.21,114.65 152.16,114.65
GND on TOP (solid shape): 172.82,142.86 172.82,142.79 172.82,142.63 172.9,142.49 172.9,141.98 173.11,141.77 173.11,135.83 172.88,135.61 170.82,135.61 170.57,135.86 170.57,139.04 169.93,139.67 167.37,139.67 167.36,139.67 166.45,139.67 166.33,139.79 166.33,141.9 166.57,142.14 166.93,142.14 167.24,142.45 167.24,142.55 167.37,142.68 167.77,142.68 167.77,142.67 167.8,142.67 167.81,142.66 168.1,142.66 168.14,142.67 168.18,142.66 168.74,142.66 168.78,142.67 168.82,142.66 169.39,142.66 169.43,142.67 169.47,142.66 170.04,142.66 170.08,142.67 170.12,142.66 170.6,142.66 171.13,142.14 171.26,142.13 171.9,142.13 171.9,142.14 172.04,142.14 172.13,142.23 172.13,142.79 172.24,142.9 172.78,142.9
GND on TOP (solid shape): 228.21,104.71 228.35,104.64 228.49,104.64 228.58,104.62 228.62,104.54 228.62,103.96 228.58,103.88 228.49,103.86 228.1,103.55 228.49,103.24 228.58,103.22 228.62,103.14 228.62,102.6 228.22,102.6 228.02,102.4 228.02,101.95 228.22,101.75 228.62,101.75 228.62,101.3 228.52,101.2 227.45,101.2 226.7,101.95 226.7,102.58 226.77,102.65 227.47,102.65 227.72,102.9 227.72,104.2 228.04,104.2 228.04,104.57 228.18,104.71
GND on TOP (solid shape): 179.52,174.91 179.52,173.26 179.48,172.81 179.9,172.67 179.99,172.66 180.03,172.57 180.03,172.14 179.9,171.87 180.02,171.6 180.03,171.59 180.03,171.55 180.07,171.51 180.26,171.51 180.46,171.51 180.58,171.39 180.58,170.41 180.36,170.19 178.9,170.19 178.85,170.23 178.85,170.95 178.86,170.96 178.88,171.05 178.86,171.15 178.85,171.18 179.14,171.47 179.14,171.48 179.33,171.67 179.33,172.31 179.21,172.43 178.19,172.43 178.13,172.5 178.13,173.26 178.38,173.51 178.38,174.96 178.46,175.04 179.39,175.04
GND on TOP (solid shape): 9.57,47.5 1.31,47.5 1.6,47.9 2.07,48.05 2.27,48.05 3.12,48.4 3.47,49.25 3.47,51.75 3.12,52.6 2.27,52.95 2.07,52.95 1.51,53.19 1.27,53.75 1.27,54.3 9.57,54.3
GND on TOP (solid shape): 253.8,113.64 253.8,113.24 254.88,112.17 255.63,112.17 255.84,111.96 255.84,109.7 255.53,109.39 255.09,109.39 254.88,109.6 254.02,109.6 253.89,109.74 253.89,109.78 253.88,109.83 253.86,109.88 253.84,109.92 253.81,109.96 253.78,109.99 253.74,110.02 253.7,110.04 253.65,110.06 253.6,110.07 253.56,110.07 253.35,110.27 254.53,110.27 254.53,110.22 254.54,110.18 254.56,110.13 254.58,110.08 254.61,110.04 254.64,110.01 254.68,109.98 254.73,109.96 254.78,109.94 254.82,109.93 254.87,109.93 254.92,109.94 254.97,109.96 255.02,109.98 255.06,110.01 255.09,110.04 255.12,110.08 255.14,110.13 255.16,110.18 255.17,110.22 255.17,110.27 255.16,110.32 255.14,110.37 255.12,110.42 255.09,110.46 255.06,110.49 255.02,110.52 254.97,110.54 254.92,110.56 254.87,110.57 254.82,110.57 254.78,110.56 254.73,110.54 254.68,110.52 254.64,110.49 254.61,110.46 254.58,110.42 254.56,110.37 254.54,110.32 254.53,110.27 253.35,110.27 252.7,110.93 252.7,113.59 252.83,113.72 253.72,113.72
GND on TOP (solid shape): 128.34,143.93 128.34,143.39 128.31,143.38 128.09,143.05 128.31,142.72 128.34,142.71 128.34,141.43 128.31,141.41 128.09,141.08 128.31,140.75 128.42,140.64 129.1,140.64 129.23,140.51 129.23,139.63 129.09,139.39 129.23,139.15 129.23,137.07 129.09,136.94 128.49,136.94 128.31,137.12 128.31,138.29 128.19,138.4 127.04,138.4 126.8,138.16 124.17,138.16 124.09,138.24 124.09,138.69 123.47,139.3 123.47,141.8 123.36,141.92 123.09,141.92 122.67,142.34 122.67,143.13 122.84,143.3 124.61,143.3 124.72,143.18 124.72,142.96 124.68,142.92 124.63,142.92 124.63,142.87 124.61,142.85 124.61,142.12 124.69,142.04 126.37,142.04 126.42,142.1 126.42,142.83 126.33,142.92 126.26,143 126.26,143.77 126.55,144.05 128.21,144.05
GND on TOP (solid shape): 159.21,115.95 159.21,112.49 159.08,112.36 158.96,112.36 158.89,112.3 158.87,112.3 158.87,112.27 158.77,112.17 158.77,109.44 158.89,109.31 159.4,109.31 159.53,109.19 159.53,108.72 159.53,108.58 159.52,108.51 159.52,108.45 159.52,108.42 159.4,108.3 158.58,108.3 158.4,108.47 158.39,108.54 158.39,108.58 158.39,109.25 158.26,109.38 157.18,109.38 157.05,109.25 157.05,108.36 156.99,108.3 156.1,108.3 155.98,108.42 155.98,108.45 155.98,108.51 155.97,108.58 155.97,109.19 156.04,109.25 156.67,109.25 156.8,109.38 156.8,110.52 156.92,110.65 156.92,112.11 156.54,112.49 155.72,112.49 155.72,113.67 155.73,113.76 155.72,113.85 155.72,114.96 155.78,115.03 155.87,115.03 156.16,115.03 156.35,115.22 156.35,115.47 156.48,115.6 156.73,115.6 156.83,115.5 156.83,113.54 156.8,113.5 156.8,112.49 156.86,112.42 156.86,112.4 156.89,112.4 156.92,112.36 158,112.36 158.04,112.4 158.07,112.4 158.07,112.42 158.13,112.49 158.13,113.67 158.14,113.76 158.13,113.85 158.13,115.09 157.94,115.28 157.94,115.47 158.07,115.6 158.48,115.6 158.58,115.71 158.58,116.01 158.84,116.27 158.89,116.27
GND on TOP (solid shape): outline of 97 points within 176.6,144.86 180.45,147.37
GND on TOP (solid shape): outline of 104 points within 241.93,116.06 246.14,121.86
GND on TOP (solid shape): 242.4,108.8 242.52,108.78 242.64,108.8 242.65,108.81 243.59,108.81 243.6,108.8 243.72,108.78 243.84,108.8 243.85,108.81 244.04,108.81 244.1,108.74 244.1,107.35 243.51,106.75 242.4,106.75 242.33,106.83 238.02,106.83 237.91,106.94 237.18,106.94 237.07,106.83 234.63,106.83 234.55,106.75 230.87,106.75 228.42,106.75 228.28,106.61 228.27,106.61 228.19,106.55 228.14,106.47 228.12,106.45 228.12,106.42 228.1,106.32 228.12,106.23 228.12,106.2 228.14,106.18 228.19,106.1 228.27,106.04 228.28,106.04 228.62,105.7 228.62,105.36 228.58,105.28 228.49,105.26 228.35,105.26 228.21,105.19 227.98,105.19 227.72,104.93 227.4,105.25 227.4,107.1 226.86,107.65 226.86,108.17 226.92,108.24 229.62,108.24 229.69,108.17 229.69,107.54 229.82,107.41 231.53,107.41 231.72,107.6 231.72,108.17 231.78,108.24 233.12,108.24 233.18,108.17 233.18,107.66 233.37,107.47 234.18,107.47 234.65,107.94 234.71,107.94 234.72,107.94 239.39,107.94 239.47,108.02 239.93,108.02 240.04,107.91 240.04,107.43 240.26,107.22 241.94,107.22 242.01,107.28 242.01,108.68 242.13,108.81 242.39,108.81
GND on TOP (solid shape): 143.77,176.87 144.21,175.62 145.33,174.92 147.24,169.23 141.32,170.19 141.32,173.3 141.32,173.3 141.32,183 143.77,183
GND on TOP (solid shape): 181.3,162.08 181.4,162.08 181.42,162.05 181.47,162.02 181.54,161.93 181.6,161.9 181.62,161.84 181.66,161.71 181.74,161.61 181.77,161.53 181.74,161.45 181.65,161.07 182,160.88 182.03,160.87 182.05,160.84 182.06,160.8 182.08,160.77 182.09,160.73 182.08,160.69 182.08,160.16 182,160.08 181.83,160.08 181.77,160.14 181.77,160.34 181.78,160.35 181.78,160.62 181.65,160.7 181.5,160.74 181.43,160.77 181.41,160.85 181.39,161.02 181.3,161.17 181.29,161.21 181.3,161.24 181.41,161.54 181.29,161.84 181.12,162 181.23,162.08
GND on TOP (solid shape): outline of 107 points within 174,169.21 176.53,175.87
GND on TOP (solid shape): 181.27,162.08 181.3,162.08 181.4,162.08 181.54,161.93 181.6,161.9 181.62,161.84 181.66,161.71 181.74,161.61 181.77,161.53 181.74,161.45 181.65,161.08 181.98,160.88 182,160.88 182.05,160.84 182.08,160.77 182.09,160.7 182.04,160.64 182.01,160.61 181.97,160.58 181.9,160.55 181.83,160.58 181.68,160.69 181.5,160.74 181.43,160.77 181.41,160.85 181.39,161.02 181.31,161.17 181.3,161.17 181.29,161.21 181.3,161.24 181.31,161.25 181.41,161.55 181.29,161.84 181.16,161.96 181.15,162 181.17,162.04 181.22,162.07
GND on TOP (solid shape): outline of 122 points within 250.2,19.15 262.71,29.37
GND on TOP (solid shape): 235.08,120.51 235.05,120.47 234.99,120.21 235.16,119.99 235.21,119.91 235.18,119.82 235.19,119.31 235.67,119.47 235.75,119.54 235.84,119.52 235.91,119.45 235.91,114.71 235.88,114.68 235.88,114.64 235.75,114.52 235.25,114.52 235.15,114.62 235.15,116.15 234.64,116.65 234.64,118.02 234.45,118.21 234.45,118.9 234.07,119.29 233.89,119.29 233.87,119.31 233.6,119.49 233.31,119.33 233.3,119.3 233.26,119.3 233.19,119.33 233.16,119.41 232.67,119.66 232.76,119.12 232.8,119.11 232.8,117.76 232.74,117.7 230.95,117.7 230.6,117.35 229.85,117.35 229.76,117.44 229.76,119.8 229.52,120.04 228.08,120.04 227.93,120.19 227.93,121.22 228.05,121.34 234.25,121.34
GND on TOP (solid shape): outline of 84 points within 173.61,135.67 188.21,144.32
GND on TOP (solid shape): 228.16,91.22 228.16,91.04 228.1,90.85 228.16,90.66 228.16,90.5 228.23,90.44 230.54,90.44 230.73,90.25 231.72,90.25 232.12,90.25 233.12,90.25 233.52,90.25 234.26,90.25 234.32,90.25 234.53,90.46 235.71,90.46 235.9,90.27 236.39,90.27 236.58,90.46 244.36,90.46 244.37,90.45 245.22,90.45 245.22,90.45 245.51,90.45 246.93,89.02 246.93,89 246.31,88.37 246.24,88.37 245.31,89.3 243.61,89.3 243.53,89.33 243.51,89.41 243.42,89.64 243.2,89.75 243.18,89.75 243.06,89.86 242.82,89.86 242.82,89.99 242.08,89.99 242.08,89.3 240.73,89.3 240.65,89.34 240.63,89.42 240.32,89.81 240.01,89.42 239.99,89.34 239.91,89.3 233.74,89.3 233.66,89.33 233.64,89.41 233.32,89.77 233,89.41 232.98,89.33 232.9,89.3 230.47,89.3 230.42,89.35 228.37,89.35 227.42,88.4 227.42,88.39 227.3,88.27 227.26,88.27 226.67,88.86 226.67,90.27 226.83,90.44 227.34,90.44 227.4,90.5 227.4,91.22 227.53,91.35 228.04,91.35
GND on TOP (solid shape): outline of 110 points within 149.29,135.78 165.01,145.99
GND on TOP (solid shape): 176.75,166.86 176.82,166.83 176.85,166.76 176.89,166.61 177.01,166.51 177.04,166.5 177.04,166.31 177.01,166.3 176.85,166.08 177.01,165.86 177.04,165.85 177.04,165.66 177.01,165.65 176.85,165.43 177.01,165.21 177.04,165.2 177.04,165.01 177.01,165 176.85,164.78 177.01,164.56 177.04,164.55 177.04,164.36 177.01,164.35 176.85,164.13 177.01,163.91 177.04,163.9 177.04,163.71 177.01,163.7 176.85,163.48 177.01,163.26 177.04,163.25 177.04,163.06 177.01,163.05 176.91,162.98 176.86,162.88 176.85,162.83 176.82,162.76 176.75,162.74 176.34,162.74 176.28,162.8 176.28,163.09 176.37,163.17 176.39,163.17 176.61,163.41 176.37,163.63 176.31,163.66 176.28,163.73 176.28,164.01 176.37,164.09 176.39,164.09 176.61,164.33 176.37,164.55 176.31,164.58 176.28,164.65 176.28,164.93 176.37,165.01 176.39,165.01 176.61,165.25 176.37,165.47 176.31,165.5 176.28,165.57 176.28,165.85 176.37,165.93 176.39,165.93 176.61,166.17 176.37,166.39 176.31,166.42 176.28,166.49 176.28,166.75 176.39,166.85 176.42,166.85 176.45,166.86
GND on TOP (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 241.53,172.72 241.53,171.07 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95
GND on TOP (solid shape): outline of 632 points within 209.5,138.91 264.3,154.8
GND on TOP (solid shape): outline of 119 points within 16.02,0.2 338.22,183.4
GND on TOP (solid shape): outline of 261 points within 0.2,34.2 211.24,185.55
GND on TOP (solid shape): outline of 1402 points within 177.59,160.04 186.2,169.55
GND on BOTTOM (solid shape): 15.06,49.88 15.06,47.09 14.74,46.77 11.69,46.77 11.12,47.34 11.12,49.88 11.5,50.26 14.68,50.26
GND on BOTTOM (solid shape): 39.7,50.71 39.7,48.7 39.57,48.58 38.59,48.58 38.36,48.8 38.36,50.77 38.55,50.96 39.44,50.96
GND on BOTTOM (solid shape): 67.38,5.62 67.38,4.29 67.26,4.17 64.71,4.17 64.59,4.29 64.59,5.62 64.78,5.81 67.19,5.81
GND on BOTTOM (solid shape): 146.92,132.91 146.92,129.14 146.63,128.86 145.79,128.86 145.71,128.94 145.71,132.91 145.84,133.03 146.79,133.03
GND on BOTTOM (solid shape): 171.85,127.52 171.85,124.11 171.66,123.92 169.16,123.92 169.01,124.07 169.01,127.61 169.26,127.86 171.52,127.86
GND on BOTTOM (solid shape): 230.61,129.03 230.61,128.08 230.55,128.02 229.47,128.02 229.29,128.19 229.29,128.98 229.4,129.1 230.55,129.1
GND on BOTTOM (solid shape): 231.2,7.51 231.2,5.34 230.87,5.01 229.97,5.01 229.55,5.43 229.55,7.37 229.88,7.7 231.01,7.7
GND on BOTTOM (solid shape): 232.42,128.94 232.42,128.11 232.32,128.02 231.18,128.02 231.12,128.08 231.12,129.03 231.18,129.1 232.26,129.1
GND on BOTTOM (solid shape): 235.56,128.97 235.56,128.02 235.5,127.95 234.42,127.95 234.26,128.11 234.26,128.94 234.36,129.03 235.5,129.03
GND on BOTTOM (solid shape): 236.69,15.59 236.69,11.58 235.85,10.74 233.85,10.74 233.72,10.87 233.72,14.4 235.21,15.9 236.39,15.9
GND on BOTTOM (solid shape): 237.37,128.87 237.37,128.05 237.28,127.95 236.13,127.95 236.07,128.02 236.07,128.97 236.13,129.03 237.21,129.03
GND on BOTTOM (solid shape): 240.8,128.94 240.8,127.98 240.74,127.92 239.66,127.92 239.47,128.11 239.47,128.87 239.59,129 240.74,129
GND on BOTTOM (solid shape): 253.18,45.5 253.18,42.39 252.87,42.07 250.24,42.07 249.82,42.49 249.82,45.33 250.3,45.82 252.87,45.82
GND on BOTTOM (solid shape): 256.14,124.27 256.14,119.84 255.8,119.5 254.42,119.5 254.2,119.73 254.2,124.06 254.69,124.55 255.85,124.55
GND on BOTTOM (solid shape): 261.26,124.17 261.26,118.23 261.12,118.09 259.17,118.09 258.87,118.39 258.87,124.39 258.92,124.44 260.99,124.44
GND on BOTTOM (solid shape): 264.59,159.69 264.59,158.21 264.34,157.96 261.57,157.96 261.47,158.07 261.47,159.83 261.61,159.98 264.29,159.98
GND on BOTTOM (solid shape): 266.92,128.77 266.92,120.25 266.56,119.89 263.34,119.89 263.11,120.12 263.11,129.19 263.27,129.35 266.33,129.35
GND on BOTTOM (solid shape): 270.77,58.13 270.77,54.52 270.33,54.07 267.41,54.07 267.09,54.39 267.09,58.01 267.47,58.39 270.52,58.39
GND on BOTTOM (solid shape): 296.36,68.55 296.36,65.54 296.14,65.32 293.44,65.32 293.19,65.56 293.19,68.49 293.57,68.87 296.05,68.87
GND on BOTTOM (solid shape): 221.14,18.63 221.14,17.65 221.04,17.55 219.58,17.55 219.4,17.73 219.4,18.68 219.62,18.9 220.87,18.9
GND on BOTTOM (solid shape): 241.09,48.41 241.09,47.21 240.92,47.03 236.27,47.03 236.09,47.21 236.09,48.51 236.23,48.65 240.85,48.65
GND on BOTTOM (solid shape): 265.57,8.02 265.07,7.53 265.07,5.56 265.57,5.07 265.57,3.2 258.57,3.2 258.57,10 265.57,10
GND on BOTTOM (solid shape): 90.18,50.01 90.18,46.77 89.99,46.58 88.15,46.58 87.83,46.9 87.83,49.88 88.08,50.13 90.05,50.13
GND on BOTTOM (solid shape): 148.83,12.17 148.83,4.27 148.73,4.17 147.1,4.17 147.01,4.26 147.01,12.15 147.16,12.3 148.7,12.3
GND on BOTTOM (solid shape): 155.9,132.87 155.9,131.53 155.9,131.53 155.9,128.93 155.77,128.81 154.17,128.81 154.03,128.95 154.03,132.28 154.76,133 155.77,133
GND on BOTTOM (solid shape): 173.99,175.82 173.99,174.4 173.55,173.96 169.97,173.96 169.74,174.18 169.74,174.66 170.19,175.1 171.05,175.1 171.92,175.97 173.85,175.97
GND on BOTTOM (solid shape): 129.28,110.65 129.28,105.05 129.19,104.96 127.9,104.96 127.6,105.26 127.6,106.09 128.56,107.05 128.56,110.64 128.64,110.72 129.21,110.72
GND on BOTTOM (solid shape): 43.44,30.7 43.44,26.45 43.19,26.19 41.41,26.19 41.22,26.38 41.22,27.85 40.9,28.16 40.52,28.16 40.33,28.35 40.33,30.77 40.59,31.02 43.13,31.02
GND on BOTTOM (solid shape): 118,119.45 118,116.23 118.27,115.96 118.85,115.96 118.95,115.86 118.95,115.39 118.81,115.25 117.5,115.25 117.42,115.33 117.42,119.48 117.47,119.53 117.92,119.53
GND on BOTTOM (solid shape): 292.37,70.73 292.37,69.67 292.14,69.44 290.3,69.44 290.2,69.53 290.2,70.87 290.28,70.94 292.16,70.94
GND on BOTTOM (solid shape): 57.37,11.13 57.37,11.12 57.45,11.04 57.45,9.4 57.26,9.21 56.04,9.21 55.92,9.33 55.92,11.07 56.14,11.29 57.2,11.29
GND on BOTTOM (solid shape): 76.02,50.58 76.02,47.86 75.76,47.61 75.76,40.61 75.75,40.6 68.88,40.6 68.3,40.6 67.38,40.6 67.37,40.61 67.37,50.43 67.71,50.77 75.83,50.77
GND on BOTTOM (solid shape): 143.74,149.1 143.74,146.5 143.54,146.3 142.09,146.3 142.03,146.36 142.03,147.42 142.12,147.5 143.28,147.5 143.36,147.58 143.36,149.1 143.42,149.17 143.67,149.17
GND on BOTTOM (solid shape): 126.94,99.36 129.14,99.36 129.19,99.31 129.19,98.47 129.11,98.39 127.39,98.39 127,98 126.16,98 125.85,98.31 125.85,99.01 126.44,99.6 126.69,99.6
GND on BOTTOM (solid shape): 93.29,27.05 93.29,24.8 93.8,24.29 97.52,24.29 97.68,24.12 97.68,21.5 97.56,21.38 94.76,21.38 94.58,21.56 89.99,21.56 89.8,21.75 89.8,26.96 90.18,27.34 93,27.34
GND on BOTTOM (solid shape): 144.63,127.7 144.63,124.61 145.39,123.84 145.39,122.95 145.22,122.78 142.31,122.78 141.88,123.21 141.88,127.56 142.07,127.75 144.58,127.75
GND on BOTTOM (solid shape): 156.84,115.42 156.84,115.23 156.46,114.85 156.46,114.22 156.8,113.88 156.8,113.63 156.67,113.5 155.91,113.5 155.78,113.63 155.78,113.92 156.02,114.15 156.02,114.98 156.4,115.36 156.4,115.42 156.53,115.55 156.72,115.55
GND on BOTTOM (solid shape): 213.88,152.2 213.88,152.05 213.75,151.92 213.75,150.58 213.75,149.57 213.56,149.38 212.1,149.38 212.04,149.45 212.04,150.53 212.1,150.59 213.18,150.59 213.37,150.78 213.37,152.24 213.5,152.37 213.71,152.37
GND on BOTTOM (solid shape): 236.85,154.08 236.85,151.19 236.51,150.84 232.74,150.84 232.42,151.16 231.4,151.16 229.85,152.72 229.85,153.73 230.07,153.96 231.58,153.96 232.07,154.44 236.49,154.44
GND on BOTTOM (solid shape): 241.09,151.7 241.09,150.72 241.12,150.69 241.12,150.65 241.12,150.64 241.12,149.57 240.96,149.42 239.5,149.42 239.44,149.48 239.44,150.56 239.5,150.62 240.58,150.62 240.77,150.81 240.77,151.67 240.87,151.77 241.02,151.77
GND on BOTTOM (solid shape): 250.28,153.61 250.28,151.23 249.96,150.91 246.45,150.91 246.13,151.23 244.86,151.23 243.39,152.7 243.39,153.75 243.66,154.02 245.53,154.02 245.67,154.16 249.74,154.16
GND on BOTTOM (solid shape): 252.62,128.88 252.62,124.19 253.24,123.56 253.24,120.77 253.18,120.71 250.34,120.71 250.2,120.84 250.19,120.84 250.03,121 250.03,123.23 247.65,125.61 247.65,128.47 248,128.82 250.03,128.82 250.44,129.22 252.28,129.22
GND on BOTTOM (solid shape): 254.93,151.81 254.93,150.75 254.9,150.75 254.9,150.71 254.9,150.71 254.9,149.65 254.74,149.5 253.28,149.5 253.22,149.56 253.22,150.64 253.28,150.7 254.36,150.7 254.55,150.89 254.55,151.84 254.64,151.94 254.8,151.94
GND on BOTTOM (solid shape): 149.73,115.46 149.73,115.27 149.35,114.9 149.35,114.15 149.29,114.09 149.03,114.09 148.91,114.22 148.91,114.85 148.53,115.23 148.53,115.42 148.65,115.55 148.84,115.55 148.99,115.41 149.26,115.41 149.42,115.57 149.61,115.57
GND on BOTTOM (solid shape): 161.56,127.73 161.56,124.87 161.5,124.81 158.12,124.81 157.63,125.3 157.63,126.19 157.43,126.4 156.85,126.4 156.6,126.65 156.6,127.6 156.82,127.82 161.46,127.82
GND on BOTTOM (solid shape): 264.11,153.84 264.11,151.41 263.67,150.97 260.23,150.97 259.91,151.29 258.9,151.29 257.63,152.56 256.74,152.56 256.55,152.75 256.55,153.89 256.74,154.08 259.85,154.08 260.08,154.31 263.64,154.31
GND on BOTTOM (solid shape): 24.2,47.47 24.2,44.04 24.65,43.59 24.65,42.58 24.42,42.35 22.71,42.35 22.11,41.75 21.22,41.75 21.09,41.88 21.09,44.23 21.19,44.32 21.45,44.32 21.61,44.48 21.61,46.97 22.3,47.66 24.01,47.66
GND on BOTTOM (solid shape): 87.19,33.75 87.19,28.35 87.54,28 88.63,28 88.72,27.92 88.72,27.4 88.65,27.34 87.19,27.34 86.37,28.16 81.48,28.16 81.29,28.35 81.29,31.53 81.86,32.1 83.38,32.1 83.83,32.54 83.83,34 84.21,34.39 86.56,34.39
GND on BOTTOM (solid shape): 139.55,115.38 139.74,115.38 139.95,115.58 140.11,115.58 140.27,115.42 140.27,115.23 139.89,114.85 139.89,114.22 139.76,114.09 139.51,114.09 139.44,114.15 139.44,114.86 139.06,115.25 139.06,115.44 139.2,115.58 139.35,115.58
GND on BOTTOM (solid shape): 141.9,115.38 142.09,115.38 142.3,115.58 142.46,115.58 142.62,115.42 142.62,115.23 142.24,114.85 142.24,114.22 142.11,114.09 141.86,114.09 141.79,114.15 141.79,114.86 141.41,115.25 141.41,115.44 141.55,115.58 141.7,115.58
GND on BOTTOM (solid shape): 144.31,115.38 144.51,115.38 144.71,115.58 144.87,115.58 145.03,115.42 145.03,115.23 144.65,114.85 144.65,114.22 144.52,114.09 144.27,114.09 144.21,114.15 144.21,114.86 143.82,115.25 143.82,115.44 143.96,115.58 144.11,115.58
GND on BOTTOM (solid shape): 146.66,115.38 146.86,115.38 147.06,115.58 147.22,115.58 147.38,115.42 147.38,115.23 147,114.85 147,114.22 146.87,114.09 146.62,114.09 146.56,114.15 146.56,114.86 146.17,115.25 146.17,115.44 146.31,115.58 146.46,115.58
GND on BOTTOM (solid shape): 152.07,115.44 152.07,115.25 151.7,114.87 151.7,114.15 151.64,114.09 151.38,114.09 151.26,114.22 151.26,114.85 150.87,115.23 150.87,115.42 151,115.55 151.19,115.55 151.34,115.41 151.59,115.41 151.77,115.58 151.94,115.58
GND on BOTTOM (solid shape): 152.12,149.09 152.12,148.78 152.07,148.73 152.07,146.51 151.88,146.33 150.39,146.33 150.36,146.36 150.36,147.49 150.39,147.52 151.47,147.52 151.74,147.78 151.74,148.76 151.65,148.85 151.65,148.98 151.64,148.99 151.64,149.12 151.77,149.25 151.95,149.25
GND on BOTTOM (solid shape): 191.92,110.6 191.92,108.98 192.41,108.49 193.04,108.49 193.13,108.39 195.36,108.39 195.4,108.35 195.4,107.77 195.28,107.65 191.54,107.65 191.12,108.07 191.12,110.57 191.22,110.67 191.85,110.67
GND on BOTTOM (solid shape): 216.1,18.82 216.1,18.44 216.2,18.34 217,18.34 217.76,17.58 217.76,17.41 217.63,17.28 216.26,17.28 215.83,17.71 215.83,17.89 215.73,17.98 215.73,18.87 215.8,18.94 215.98,18.94
GND on BOTTOM (solid shape): 99.31,44.62 99.31,43.09 98.81,42.59 98.81,41.71 99.18,41.34 99.18,40.55 99.3,40.44 99.99,40.44 100.08,40.35 100.08,39.34 99.98,39.23 98.29,39.23 98.12,39.4 98.12,44.55 98.39,44.82 99.11,44.82
GND on BOTTOM (solid shape): 183.33,144.86 183.33,144.22 183.59,143.96 183.59,142.72 183.65,142.65 183.65,141.57 183.61,141.54 182.48,141.54 182.42,141.6 182.42,142.57 182.48,142.63 183.06,142.63 183.27,142.84 183.27,143.8 182.84,144.23 182.84,144.84 182.98,144.98 183.2,144.98
GND on BOTTOM (solid shape): 221.47,129.1 221.68,129.03 221.89,129.09 221.9,129.1 222.04,129.1 222.19,128.94 222.19,128.11 222.1,128.02 220.96,128.02 220.89,128.08 220.89,129.03 220.96,129.1
GND on BOTTOM (solid shape): 168.12,145.82 168.12,144.22 168.09,144.19 168.08,144.18 168.08,143.22 167.92,143.06 166.48,143.06 166.42,143.12 166.42,144.09 166.48,144.15 167.55,144.15 167.74,144.34 167.74,145.49 167.66,145.56 167.66,145.66 167.66,145.67 167.66,145.8 167.78,145.93 168.01,145.93
GND on BOTTOM (solid shape): 198.87,184.97 200.3,183.7 200.67,183.48 201.1,183.4 205.72,183.4 205.72,176.7 198.72,176.7 198.72,185.11
GND on BOTTOM (solid shape): 162.28,170.74 162.28,167.43 162.7,167.01 162.7,166.1 162.62,166.02 161.23,166.02 161.18,166.06 161.18,166.37 161.03,166.52 160.67,166.52 160.47,166.71 160.47,167.67 160.91,168.1 160.91,170.76 161.02,170.87 162.14,170.87
GND on BOTTOM (solid shape): 195.42,18.38 195.42,18.32 195.42,18.09 195.27,17.95 195.27,16.51 195.11,16.35 194.87,16.35 194.59,16.62 194.59,18.24 194.58,18.25 194.65,18.33 195.04,18.33 195.2,18.48 195.32,18.48
GND on BOTTOM (solid shape): 79.24,19.32 79.84,19.32 80.07,19.1 80.07,18.02 80.21,17.88 81.29,17.88 81.73,17.43 81.73,10.57 81.48,10.32 75.07,10.32 74.94,10.45 74.94,17.24 75.07,17.37 75.68,17.37 76.15,17.83 76.15,19.02 76.44,19.32 79.24,19.32
GND on BOTTOM (solid shape): 122.14,120.47 122.14,118.75 121.7,118.31 121.7,117.47 122.19,116.97 122.19,115.76 121.76,115.33 121.76,114.21 121.93,114.05 121.93,113.75 121.87,113.69 121.53,113.69 121.46,113.76 121.46,115.33 121.01,115.78 121.01,118.45 120.66,118.8 120.66,120.44 120.81,120.6 122.01,120.6
GND on BOTTOM (solid shape): 159.74,146.13 159.74,143.25 159.58,143.09 158.13,143.09 158.07,143.15 158.07,144.12 158.13,144.18 159.2,144.18 159.39,144.37 159.39,145.51 159.15,145.76 159.15,145.98 159.15,146.03 159.15,146.16 159.26,146.27 159.6,146.27
GND on BOTTOM (solid shape): 9.57,66.3 1.27,66.3 1.27,72.1 1.49,72.65 2.03,72.9 2.07,72.9 9.57,72.9
GND on BOTTOM (solid shape): 227.6,152.31 227.6,151.98 227.4,151.79 227.4,149.51 227.24,149.35 225.78,149.35 225.72,149.42 225.72,150.5 225.78,150.56 226.86,150.56 227.05,150.75 227.05,151.99 227.07,152.09 227.06,152.18 227.06,152.21 227.18,152.34 227.19,152.34 227.22,152.37 227.54,152.37
GND on BOTTOM (solid shape): 176.46,145.92 176.46,145.61 176.42,145.57 176.42,143.14 176.32,143.04 174.76,143.04 174.73,143.07 174.73,144.16 174.75,144.17 175.89,144.17 176.09,144.38 176.09,145.53 175.98,145.64 175.98,145.85 176.09,145.97 176.41,145.97
GND on BOTTOM (solid shape): 258.01,148.88 258.01,148.5 258.52,147.99 263.91,147.99 264.14,147.76 264.14,140.46 263.85,140.18 260.74,140.18 260.1,140.81 260.1,144.97 259.75,145.32 258.64,145.32 256.99,146.97 256.86,146.97 253.31,146.97 253.18,147.1 253.18,148.18 253.31,148.3 253.95,148.3 254.01,148.37 254.01,149.07 254.14,149.19 257.69,149.19
GND on BOTTOM (solid shape): 158.48,115.4 158.67,115.4 158.7,115.42 158.75,115.42 158.88,115.55 159.07,115.55 159.19,115.42 159.19,115.23 158.81,114.85 158.81,114.22 159.21,113.82 159.21,113.63 159.08,113.5 158.32,113.5 158.19,113.63 158.19,114.09 158.37,114.27 158.37,114.83 157.97,115.22 157.97,115.44 158.11,115.58 158.3,115.58
GND on BOTTOM (solid shape): 92,45.94 92,45.03 92.08,44.96 92.48,44.96 92.59,45.06 92.59,45.96 92.63,46 92.74,46 92.8,45.94 92.8,45.1 92.97,44.93 93.48,44.93 93.55,44.85 93.55,43.16 93.48,43.09 91.89,43.09 91.83,43.15 91.83,44.86 91.77,44.93 91.77,45.94 91.83,46.01 91.94,46.01
GND on BOTTOM (solid shape): 252.68,28.99 252.68,26.45 252.98,26.15 252.98,26.1 253.02,26.1 253.06,26.07 253.13,26.07 255.27,26.07 255.27,26.07 256.42,26.07 256.55,25.94 256.55,25.5 256.29,25.24 256.29,23.84 256.36,23.78 256.36,23.73 256.61,23.47 256.61,22.51 256.42,22.32 254.77,22.32 254.26,22.83 254.07,22.83 253.56,22.83 250.33,26.07 250.33,29.31 252.36,29.31
GND on BOTTOM (solid shape): 229.77,42.4 229.77,41.35 230.22,40.9 230.22,38.02 230.64,37.6 230.64,34.83 230.5,34.69 228.56,34.69 228.34,34.91 228.34,35.72 228.52,35.9 228.85,35.9 228.95,36 228.95,37.57 229.46,38.08 229.46,39.36 229.11,39.71 229.11,41 229.49,41.38 229.49,42.41 229.55,42.48 229.69,42.48
GND on BOTTOM (solid shape): 246.39,39.15 246.39,38.45 246.2,38.26 245.15,38.26 245.14,38.26 244.99,38.3 244.84,38.26 244.83,38.26 244.26,38.26 244.25,38.26 244.1,38.3 243.95,38.26 243.92,38.25 243.79,38.38 243.79,38.41 243.79,39.15 243.91,39.27 246.26,39.27
GND on BOTTOM (solid shape): 161.57,115.45 161.57,115.26 161.16,114.85 161.16,114.15 161.37,113.95 161.5,113.95 161.62,113.82 161.62,113.63 161.56,113.57 160.67,113.57 160.61,113.63 160.61,114.11 160.72,114.22 160.72,114.85 160.34,115.23 160.34,115.42 160.46,115.55 160.65,115.55 160.78,115.42 160.93,115.42 161.07,115.42 161.23,115.58 161.44,115.58
GND on BOTTOM (solid shape): 186.72,176.7 179.72,176.7 179.72,183.6 180.55,183.6 180.87,183.45 181.22,183.4 183.1,183.4 184.34,183.4 184.77,183.48 185.14,183.7 186.57,184.97 186.6,185 186.72,185.11
GND on BOTTOM (solid shape): 226.55,129.1 226.77,129.03 226.98,129.1 227.18,129.1 227.34,128.94 227.34,128.11 227.24,128.02 226.1,128.02 226.04,128.08 226.04,128.92 226.07,129 226.14,129.03 226.25,129.04 226.34,129.1
GND on BOTTOM (solid shape): 242.01,43.65 242.01,43.58 242.01,41.89 242.52,41.38 242.52,40.06 242.4,39.94 242.4,39.09 242.64,38.84 242.64,37.84 242.5,37.7 241.57,37.7 241.44,37.84 241.44,38.79 241.69,39.04 241.69,39.92 241.29,40.32 241.29,41.69 241.63,42.03 241.63,43.65 241.71,43.74 241.92,43.74
GND on BOTTOM (solid shape): 244.23,148.81 244.23,148.3 244.55,147.99 249.63,147.99 249.88,147.73 249.88,145.13 249.56,144.81 249.56,144.11 249.69,143.99 251.21,143.99 251.66,143.54 251.66,139.97 251.23,139.54 246.83,139.54 246.58,139.8 246.58,144.62 245.94,145.26 244.86,145.26 243.21,146.91 239.53,146.91 239.4,147.03 239.4,148.11 239.53,148.24 240.17,148.24 240.23,148.3 240.23,149 240.36,149.13 243.91,149.13
GND on BOTTOM (solid shape): 244.35,98.34 244.72,98.34 244.78,98.41 244.98,98.41 245.07,98.32 245.38,98.32 245.48,98.42 245.68,98.42 245.75,98.36 245.75,98.13 245.67,98.05 245.5,98.05 245.4,98.15 245.05,98.15 244.96,98.06 244.81,98.06 244.73,98.14 244.32,98.14 244.18,98 243.51,98 243.26,97.75 243.01,97.75 242.58,98.18 242.58,98.32 242.7,98.43 242.82,98.43 242.95,98.3 243.28,98.3 243.45,98.47 244.22,98.47
GND on BOTTOM (solid shape): 37.89,20.44 38.24,20.19 38.58,20.44 38.59,20.48 39.06,20.48 39.32,20.23 39.32,17.81 38.92,17.42 37.12,17.42 37.07,17.37 34.74,17.37 34.49,17.62 34.49,20.16 34.81,20.48 37.88,20.48
GND on BOTTOM (solid shape): 57.6,24.18 57.6,23.65 57.73,23.53 58.94,23.53 59.38,23.97 59.89,23.97 59.95,23.91 59.95,22.38 59.7,22.13 58.94,22.13 58.75,21.94 58.75,20.82 58.47,20.54 55.63,20.54 55.41,20.77 55.41,21.46 55.89,21.94 55.89,22.96 55.7,23.15 55.38,23.15 54.94,23.58 54.94,24.17 55,24.23 57.56,24.23
GND on BOTTOM (solid shape): 163.1,115.51 163.14,115.47 163.19,115.42 163.29,115.42 163.45,115.42 163.57,115.55 163.77,115.55 163.89,115.42 163.89,115.23 163.51,114.85 163.51,113.61 163.4,113.5 163.08,113.5 162.98,113.6 162.98,113.78 162.98,114.93 162.7,115.21 162.7,115.48 162.82,115.6 163.01,115.6
GND on BOTTOM (solid shape): 213.63,149.07 216.54,149.07 216.86,148.75 216.86,148.18 217.24,147.8 221.88,147.8 223.15,146.53 223.78,146.53 223.97,146.34 223.97,138.97 223.72,138.72 218.96,138.72 218.77,138.91 218.77,141.33 218.77,141.33 218.77,144.74 218.77,144.74 218.77,144.94 218.51,145.19 217.5,145.19 215.85,146.84 212.16,146.84 212.04,146.97 212.04,148.05 212.16,148.18 212.8,148.18 212.86,148.24 212.86,148.96 212.97,149.07 213.62,149.07
GND on BOTTOM (solid shape): 263.57,18.94 263.57,18.65 263.66,18.56 263.66,18.55 263.67,18.55 263.77,18.45 265.66,18.45 266.36,17.74 266.36,17.32 266.52,17.16 266.52,15.19 265.6,14.27 265.6,11.22 265.48,11.09 262.29,11.09 262.19,11.19 262.19,14 262.32,14.13 262.95,14.13 263.17,14.35 263.17,14.84 263.33,15 263.33,17.95 263.07,18.21 263.07,18.94 263.18,19.05 263.46,19.05
GND on BOTTOM (solid shape): 224.65,129.1 224.86,129.03 225.07,129.1 225.28,129.1 225.38,129.04 225.49,129.03 225.56,129 225.59,128.92 225.59,128.08 225.53,128.02 224.45,128.02 224.26,128.21 224.26,128.97 224.33,129.04 224.39,129.07 224.44,129.1
GND on BOTTOM (solid shape): 165.64,171 165.64,170.36 165.81,170.19 165.81,169.38 166.05,169.15 167.78,169.15 167.9,169.03 167.9,168.52 167.5,168.12 167.5,167.76 167.27,167.53 165.98,167.53 165.58,167.13 165.2,167.13 164.91,166.83 164.91,166.35 164.76,166.21 164.68,166.18 164.47,166.18 164.28,166.37 164.28,167.41 164.47,167.61 164.83,167.61 165.03,167.81 165.03,171 165.16,171.13 165.52,171.13
GND on BOTTOM (solid shape): 166.1,142.71 166.1,142.57 166,142.46 165.36,142.46 165.32,142.42 165.17,142.34 165.09,142.19 164.98,142.08 164.98,137.73 164.75,137.5 162.11,137.5 161.93,137.68 161.93,140.57 161.79,140.72 158.1,140.72 158.1,141.86 158.93,141.86 158.93,142.75 164.51,142.75 164.76,142.62 165.03,142.7 165.05,142.72 165.17,142.84 165.97,142.84
GND on BOTTOM (solid shape): 37.02,12.48 37.02,11.86 36.81,11.64 36.52,11.64 36.33,11.45 36.33,9.02 36.13,8.81 36.13,8.07 36.9,7.3 37.07,7.3 37.16,7.21 37.16,6.33 37.15,6.32 36.46,6.32 36.2,6.57 34.3,6.57 34.17,6.7 33.28,6.7 32.97,6.38 31.44,6.38 31,6.83 30.49,6.83 30.11,7.21 29.35,7.21 29.28,7.27 29.28,7.91 29.35,7.97 30.11,7.97 30.17,8.03 30.17,9.3 29.92,9.56 29.54,9.56 29.42,9.67 29.42,10.72 29.62,10.93 30.2,10.93 32.14,12.87 36.64,12.87
GND on BOTTOM (solid shape): 150.08,146.06 150.08,145.89 149.94,145.74 149.35,145.74 149.15,145.65 149.07,145.44 149.08,145.42 148.66,145 148.66,140.38 148.44,140.17 146.26,140.17 146.03,140.4 146.03,143.7 145.77,143.96 142.09,143.96 142.09,145.1 142.91,145.1 142.91,145.99 148.51,145.99 148.85,145.86 149.13,146.09 149.13,146.11 149.17,146.15 150,146.15
GND on BOTTOM (solid shape): 173.67,142.9 173.71,142.89 174.3,142.89 174.38,142.9 174.51,142.78 174.51,142.59 174.38,142.46 173.55,142.46 173,141.91 173,137.59 172.86,137.45 170.86,137.45 170.37,137.94 170.37,140.41 170.12,140.67 166.43,140.67 166.43,141.81 167.26,141.81 167.26,142.7 172.85,142.7 172.86,142.67 173.25,142.5 173.53,142.82 173.53,142.84 173.6,142.91
GND on BOTTOM (solid shape): 154.46,115.45 154.46,115.2 154.4,115.14 154.36,115.06 154.35,115.05 154.13,114.83 154.13,114.33 153.92,114.12 153.64,114.12 153.4,114.36 153.4,114.99 153.34,115.05 153.33,115.07 153.29,115.14 153.22,115.2 153.19,115.22 153.19,115.41 153.33,115.55 153.6,115.55 153.66,115.48 153.72,115.44 153.91,115.42 154.06,115.53 154.11,115.58 154.34,115.58
GND on BOTTOM (solid shape): 196.24,20 196.24,19.39 196.04,19.19 196,19.2 195.78,19.19 195.6,19.05 195.57,19.03 195.52,18.99 195.46,19.01 195.3,19.17 194.93,19.17 194.92,19.15 194.8,19.03 194.7,19.03 194.63,19.09 194.63,19.32 194.66,19.37 194.72,19.39 194.79,19.39 194.87,19.41 195,19.58 194.96,19.79 194.96,19.95 195.14,20.13 196.1,20.13
GND on BOTTOM (solid shape): 154.98,100.79 154.98,100.56 154.78,100.35 154.76,100.35 154.7,100.34 154.64,100.31 154.63,100.31 154.56,100.31 154.54,100.28 154.54,100.18 154.54,100.18 154.52,100.1 154.54,100.02 154.54,100.01 154.54,99.96 154.56,99.94 154.56,99.7 154.46,99.59 154.27,99.59 154.24,99.56 154.23,99.56 154.09,99.48 154.02,99.35 154.01,99.33 153.97,99.29 153.76,99.29 153.68,99.38 153.68,99.6 153.68,99.61 153.72,99.77 153.68,99.93 153.68,99.94 153.68,100.14 154.23,100.7 154.42,100.7 154.61,100.89 154.88,100.89
