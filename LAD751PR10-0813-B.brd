# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CTX_GRX_P0: length 63.2
  IN6 w0.089: v2(175.28,99.17) 175.7,98.75 175.7,98.29 176.41,97.59 178.32,97.59 182.98,102.25 186.79,102.25 187.93,103.4 188.27,103.4 191.33,106.46 194.62,106.46 196.35,108.19 198.85,108.19 200,109.34 200,110.91 200.83,111.74 200.83,112.56 205.23,116.96 205.23,120.43 208.28,123.48 211.59,123.48 212.06,123 212.06,122.5 212.47,122.09 212.7,122.09 212.99,121.8 v2(212.99,121.47)
  BOTTOM w0.076: CPU1.C10 171.95,99.48 172.1,99.33 172.1,99.18 172.3,98.99 173.18,98.99 173.27,98.89 174.3,98.89 174.83,99.43 175.03,99.43 v2(175.28,99.17)
  BOTTOM w0.107: CC13.1 215.68,120.11 214.93,120.86 213.37,120.86 213.14,121.08 213.14,121.32 v2(212.99,121.47)
PEG_CTX_GRX_P1: length 61.8
  IN6 w0.089: v2(214.93,121.44) 214.68,121.7 214.68,122.1 214.24,122.54 213.49,122.54 212.92,123.1 212.92,123.27 211.9,124.29 208.86,124.29 208.48,124.67 207.87,124.67 204.42,121.22 204.42,117.28 200.03,112.9 200.03,112.08 199.52,111.58 198.33,111.58 195.55,108.79 195.55,108.52 194.68,107.65 190.92,107.65 186.94,103.66 183.14,103.66 178.25,98.77 177.61,98.77 177.48,98.91 177.48,99.04 v2(177.62,99.18)
  BOTTOM w0.076: 174.24,100.04 173.32,100.04 173.23,99.95 172.83,99.95 172.72,100.06 172.72,100.19 172.79,100.27 CPU1.A11
  BOTTOM w0.089: v2(214.93,121.44) 214.82,121.44 214.7,121.57 214.7,122.04 214.78,122.13 215.13,122.13 215.33,121.93 215.33,121.58 215.35,121.56 215.35,121.52 CC14.1 ; 174.24,100.04 177.14,100.04 177.47,99.71 177.47,99.33 v2(177.62,99.18)
PEG_CTX_GRX_P2: length 62.5
  IN6 w0.089: v2(177.17,101.12) 176.98,100.94 176.98,100.68 177.07,100.59 177.8,100.59 182.15,104.93 185.12,104.93 187.6,107.42 188.89,107.42 190.39,108.92 191.74,108.92 192.56,109.73 193.14,109.73 193.57,110.17 193.72,110.17 194.78,111.23 195.07,111.23 196.27,112.44 197.09,112.44 198.68,114.03 198.68,114.49 201.11,116.91 201.11,117.56 201.96,118.42 201.96,118.78 203.15,119.96 203.15,121.75 206.09,124.69 206.09,125.33 207.13,126.37 211.93,126.37 212.32,125.98 212.52,125.98 214.77,123.73 215.44,123.73 215.63,123.54 215.63,123.02 v2(215.77,122.88)
  BOTTOM w0.076: CPU1.C12 171.78,100.96 171.78,100.75 171.95,100.58 173.13,100.58 173.34,100.37 176.99,100.37 177.17,100.55 v2(177.17,101.12)
  BOTTOM w0.107: v2(215.77,122.88) 215.6,122.88 215.49,122.99 215.49,123.18 215.69,123.38 216,123.38 216.35,123.03 CC15.1
PEG_CTX_GRX_P3: length 60.1
  IN6 w0.089: v2(214.24,123.01) 214.05,123.2 214.05,123.54 212.32,125.28 212.12,125.28 211.67,125.73 208.03,125.73 203.78,121.48 203.78,118.67 199.32,114.21 199.32,113.77 197.91,112.36 197.91,112.05 194.14,108.28 190.65,108.28 189.15,106.78 187.87,106.78 185.38,104.3 182.44,104.3 178.05,99.91 176.08,99.91 175.24,100.75 175.24,100.9 v2(175.46,101.12)
  BOTTOM w0.076: v2(175.46,101.12) 175.19,101.4 175.19,101.51 174.97,101.73 173.33,101.73 173.13,101.53 172.84,101.53 172.77,101.61 172.77,101.76 172.84,101.84 CPU1.A13
  BOTTOM w0.107: v2(214.24,123.01) 214.24,123.08 213.93,123.39 213.93,124.06 214.28,124.42 214.46,124.42 214.58,124.3 214.58,124.15 214.68,124.05 CC16.1
PEG_CTX_GRX_P4: length 62.4
  IN6 w0.089: v2(212.8,126.65) 212.58,126.87 212.58,127.13 212.19,127.51 207.05,127.51 205.4,125.86 204.61,125.86 204.27,125.53 204.27,123.77 202.51,122.01 202.51,121.15 200.18,118.82 200.18,117.13 198.84,115.79 197.86,115.79 197.38,115.31 197.38,114.71 196.96,114.29 196.96,113.53 196.57,113.14 195.82,113.14 194.76,112.08 192.5,112.08 188.47,108.05 187.34,108.05 184.86,105.57 181.68,105.57 178.13,102.01 175.28,102.01 175.19,102.1 175.19,102.41 v2(175.41,102.63)
  BOTTOM w0.076: v2(175.41,102.63) 175.33,102.55 175.33,102.3 175.07,102.04 173.2,102.04 173.09,102.16 171.97,102.16 171.79,102.34 171.79,102.53 CPU1.C14
  BOTTOM w0.107: CC17.1 216.2,125.7 215.89,125.39 213.98,125.39 213.82,125.23 213.07,125.23 212.42,125.89 212.42,126.13 212.52,126.23 212.69,126.23 212.8,126.34 v2(212.8,126.65)
PEG_CTX_GRX_P5: length 60.9
  IN6 w0.089: v2(213.46,126.65) 213.56,126.65 213.97,127.05 213.97,127.34 213.33,127.98 205.62,127.98 204.73,127.1 203.98,127.1 203.36,126.48 203.36,124.4 202.77,123.81 202.77,123.35 199.71,120.29 199.71,117.35 198.62,116.26 196.01,116.26 194.86,115.11 193.32,115.11 191.86,113.64 191.86,112.1 188.27,108.52 187.14,108.52 184.66,106.04 180.09,106.04 177.72,103.66 177.13,103.66 176.76,103.3 176.76,102.93 176.92,102.78 176.99,102.78 v2(177.18,102.58)
  BOTTOM w0.076: v2(177.18,102.58) 176.99,102.77 176.99,102.98 176.8,103.18 173.21,103.18 173.16,103.13 172.82,103.13 172.74,103.2 172.74,103.34 172.82,103.42 CPU1.A15
  BOTTOM w0.107: CC18.1 213.87,126.02 213.63,126.25 213.63,126.47 v2(213.46,126.65)
PEG_CTX_GRX_P6: length 63.1
  IN6 w0.089: v2(174.87,104.09) 174.6,104.36 174.48,104.36 174.39,104.45 174.39,104.65 174.48,104.74 175.43,104.74 175.66,104.52 177.58,104.52 179.78,106.71 184.19,106.71 187.87,110.4 188.91,110.4 190.85,112.33 190.85,113.69 192.67,115.51 192.67,115.91 193.43,116.67 193.43,117.29 193.94,117.8 194.84,117.8 195.45,118.41 195.45,118.89 195.97,119.41 197.58,119.41 199.58,121.41 199.93,121.41 201.41,122.89 201.41,123.5 202.43,124.52 202.43,126.76 203.4,127.73 204.35,127.73 205.32,128.7 207.73,128.7 208.38,129.34 208.92,129.34 209.04,129.22 209.04,128.98 208.9,128.83 208.78,128.83 v2(208.56,128.61)
  BOTTOM w0.076: CPU1.C16 171.8,104.09 171.8,103.94 172.04,103.69 173.1,103.69 173.38,103.41 174.63,103.41 174.82,103.6 174.82,104.04 v2(174.87,104.09)
  BOTTOM w0.107: CC19.1 216.08,127.08 214.56,127.08 214.43,127.21 209.61,127.21 209.59,127.23 209.23,127.23 208.56,127.91 v2(208.56,128.61)
PEG_CTX_GRX_P7: length 61.8
  IN6 w0.089: v2(175.8,105.86) 175.94,105.72 175.94,105.43 176.18,105.19 177.34,105.19 179.5,107.35 183.8,107.35 187.5,111.04 188.58,111.04 190.19,112.66 190.19,114.7 192.62,117.13 192.62,118.04 193.41,118.83 194.48,118.83 195.7,120.05 197.32,120.05 199.35,122.08 199.7,122.08 200.77,123.15 200.77,126.95 202.19,128.38 202.19,129.25 202.76,129.82 204.74,129.82 204.99,129.57 207.71,129.57 208.18,130.04 209.55,130.04 210.13,129.47 210.13,128.89 v2(209.85,128.61)
  BOTTOM w0.076: CPU1.A17 172.91,105.06 172.69,105.06 172.61,104.98 172.61,104.81 172.72,104.71 173.25,104.71 173.35,104.81 175.86,104.81 176.17,105.12 176.17,105.49 v2(175.8,105.86)
  BOTTOM w0.107: CC20.1 213.15,127.98 213.06,127.9 210.23,127.9 210,128.13 210,128.46 v2(209.85,128.61)
PEG_CTX_GRX_P8: length 103.5
  IN3 w0.127: v2(174.07,105.95) 174.22,106.11 174.22,106.36 174.8,106.93 176.57,106.93 178.45,108.82 178.45,110.83 180.57,112.95 180.57,117.16 188.65,125.23 188.65,145.65 184.34,149.95 173.06,149.95 172.87,150.14 167.93,150.14 165.72,152.35 165.72,152.45 163.65,154.52 163.65,156.72 161.49,158.88 159.32,158.88 155.74,162.45 155.74,164.77 152.15,168.37 152.15,168.99 v2(151.9,169.23)
  BOTTOM w0.076: v2(174.07,105.95) 174.11,105.95 174.44,105.62 174.44,105.53 174.36,105.45 172.11,105.45 171.98,105.58 171.98,105.72 172.08,105.82 172.29,105.82 CPU1.B18
  BOTTOM w0.107: v2(151.9,169.23) 152.09,169.42 152.09,169.83 v3(152.76,170.5) 153.39,171.13 153.39,171.52 CC21.1
PEG_CTX_GRX_P9: length 106.3
  IN3 w0.127: v2(179.78,109.95) 179.72,110.01 179.72,110.75 180.57,111.61 181.52,112.56 181.52,116.65 189.59,124.73 189.59,146.09 184.78,150.9 173.45,150.9 172.8,151.54 170,151.54 168.12,153.42 168.12,155.7 166.56,157.26 164.47,157.26 161.85,159.87 159.71,159.87 157.78,161.8 157.78,166.52 157.93,166.66 157.93,170.33 156.04,172.22 154.81,172.22 154.56,171.97 154.56,171.57 v2(154.4,171.41)
  BOTTOM w0.076: CPU1.B19 172.33,106.53 172.75,106.11 173.24,106.11 173.34,106.21 173.35,106.21 173.46,106.32 174.13,106.32 174.21,106.39 177.17,106.39 177.21,106.36 177.3,106.36
  BOTTOM w0.107: CC22.1 154.62,173.39 154.62,171.63 v2(154.4,171.41) ; v2(179.78,109.95) 179.78,108.17 177.96,106.36 177.3,106.36
PEG_CTX_GRX_P10: length 107.2
  IN3 w0.127: v2(155.61,171.04) 155.77,170.88 155.77,170.67 155.57,170.47 152.24,170.47 151.27,169.49 151.27,168.22 154.48,165.01 154.48,163.89 154.96,163.41 154.96,161.13 156.71,159.37 156.71,154.17 158.74,152.14 164.07,152.14 166.8,149.42 172.57,149.42 172.76,149.23 184.04,149.23 187.92,145.34 187.92,125.71 179.81,117.61 179.81,113.22 177.69,111.09 177.69,108.93 176.65,107.9 176.44,107.9 176.31,108.02 176.31,108.24 v2(176.44,108.36)
  BOTTOM w0.076: CPU1.B20 172.21,107.23 172.21,107.1 172.3,107.01 173.33,107.01 173.41,106.92 173.88,106.92 174.22,107.27 175.32,107.27 175.85,107.79 176.22,107.79 176.44,108.01 v2(176.44,108.36)
  BOTTOM w0.107: CC23.1 155.76,171.56 155.76,171.2 v2(155.61,171.04)
PEG_CTX_GRX_P11: length 109.9
  IN3 w0.127: v2(156.88,172.03) 157.11,172.26 157.11,172.57 156.71,172.97 154.03,172.97 150.76,169.7 150.76,168.01 151.85,166.91 151.85,165 154.45,162.4 154.45,160.92 156.2,159.16 156.2,153.96 158.53,151.63 163.86,151.63 166.58,148.91 172.35,148.91 172.55,148.72 183.83,148.72 187.14,145.4 187.14,136.17 186.62,135.65 186.62,133.9 187.41,133.1 187.41,126.03 179.21,117.82 179.21,113.26 177.86,111.92 177.15,111.92 175.9,110.68 175.9,108.4 175.21,107.7 v2(175.21,107.69)
  BOTTOM w0.076: v2(175.21,107.69) 175.13,107.77 174.65,107.77 173.3,107.77 173.21,107.68 172.87,107.68 172.86,107.68 172.76,107.68 172.33,108.11 CPU1.B21
  BOTTOM w0.107: CC24.1 157.23,173.39 157.23,173.18 157.11,173.05 157.11,172.26 v2(156.88,172.03)
PEG_CTX_TRX_N12: length 81.8
  TOP w0.107: CT15.1 192.37,159.75 193.2,160.58 v2(193.2,161.39)
  IN6 w0.089: v2(193.2,161.39) 193.09,161.28 193.09,160.14 193.54,159.69 193.54,155.92 194.55,154.91 194.55,151.16 197.85,147.87 197.85,141.27 198.07,141.05 198.07,136.86 198.7,136.24 198.7,135.01 200.17,133.54 200.17,130.48 198.76,129.07 198.76,127.64 197.89,126.77 197.89,123.32 196.53,121.95 193.28,121.95 188.8,117.47 188.8,116.61 187.88,115.69 187.88,114.75 183.49,110.35 179.03,110.35 177.88,109.19 v2(177.31,109.19)
  BOTTOM w0.076: v2(177.31,109.19) 177.29,109.21 175.64,109.21 174.77,108.33 173.34,108.33 173.24,108.43 172.09,108.43 171.68,108.84 CPU1.C22
PEG_CTX_TRX_N12_C: length 3.1
  TOP w0.089: UT1.Y22 185.6,161.1 185.83,160.87 186.6,160.87 186.86,160.61 186.86,160.02 187.03,159.84 187.67,159.84 CT15.2
PEG_CTX_TRX_N13: length 77.1
  TOP w0.107: v2(191.15,161.35) 190.85,161.64 189.46,161.64 188.9,162.2 188.51,162.2 188.35,162.04 CT13.1
  IN6 w0.089: v2(176.72,110.61) 177.06,110.27 177.45,110.27 178.33,111.15 183.15,111.15 187.08,115.08 187.08,116.03 188,116.95 188,117.83 192.92,122.75 194.76,122.75 195.92,123.92 195.92,124.55 196.6,125.23 196.6,126.8 197.96,128.16 197.96,129.79 198.46,130.28 198.46,133.91 197.9,134.47 197.9,135.91 197.27,136.53 197.27,140.71 196.94,141.04 196.94,147.64 193.75,150.84 193.75,151.47 193.2,152.02 193.2,154.78 192.73,155.25 192.73,159.29 191.84,160.18 191.84,161.85 191.74,161.95 191.55,161.95 191.31,161.72 191.22,161.72 191.15,161.64 v2(191.15,161.35)
  BOTTOM w0.076: v2(176.72,110.61) 176.72,110.57 176.39,110.24 175.67,110.24 175.06,109.63 173.34,109.63 173.13,109.42 172.87,109.42 172.74,109.55 172.74,109.62 172.83,109.71 CPU1.A23
PEG_CTX_TRX_N13_C: length 2.6
  TOP w0.089: CT13.2 187.64,162.16 187.15,162.16 186.82,162.48 186.48,162.48 186.24,162.72 185.8,162.72 UT1.T22
PEG_CTX_TRX_N14: length 81
  TOP w0.107: v2(191.14,164.74) 191.14,164.69 190.9,164.45 189.62,164.45 189.32,164.75 188.49,164.75 CT18.1
  IN6 w0.089: v2(177.3,110.99) 177.16,111.14 176.86,111.14 176.67,111.32 176.67,111.8 177.01,112.14 183.24,112.14 186.41,115.3 186.41,116.25 187.37,117.21 187.37,118.34 192.41,123.39 194.36,123.39 195.29,124.32 195.29,124.88 195.97,125.57 195.97,127.06 196.46,127.55 196.46,129.18 197.82,130.55 197.82,133.64 197.27,134.2 197.27,135.64 196.31,136.6 196.31,147.38 193.11,150.58 193.11,151.21 192.08,152.24 192.08,159.02 190.15,160.96 190.15,163.89 190.58,164.33 190.73,164.33 v2(191.14,164.74)
  BOTTOM w0.076: CPU1.C24 171.84,110.35 171.84,110.23 172.06,110.01 173.23,110.01 173.32,109.92 174.78,109.92 175.94,111.08 177.09,111.08 177.09,111.07 177.23,111.07 v2(177.3,110.99)
PEG_CTX_TRX_N14_C: length 2.5
  TOP w0.089: UT1.M22 185.81,165.01 186.21,165.01 186.56,164.66 186.73,164.66 186.97,164.9 CT18.2
PEG_CTX_TRX_N15: length 78
  TOP w0.107: v2(190.51,164.88) 190.51,165.74 189.45,166.8 188.91,166.8 188.67,167.04 188.49,167.04 CT21.1
  IN6 w0.089: v2(190.51,164.88) 190.38,164.88 189.68,164.17 189.68,160.74 191.6,158.82 191.6,152.06 192.64,151.02 192.64,150.38 195.84,147.18 195.84,136.34 196.67,135.52 196.67,130.45 195.99,129.77 195.99,128.4 192.71,125.11 192.71,124.46 186.9,118.65 186.9,117.46 185.8,116.36 185.8,116.22 182.19,112.61 177.96,112.61 177.57,113 177.41,113 177.24,112.83 177.24,112.61 v2(177.29,112.55)
  BOTTOM w0.076: v2(177.29,112.55) 177.25,112.6 177.25,113.1 177.05,113.3 175.95,113.3 175.59,112.94 175.59,111.92 174.74,111.07 173.41,111.07 173.3,110.95 172.73,110.95 172.65,111.03 172.65,111.14 172.8,111.29 CPU1.A25
PEG_CTX_TRX_N15_C: length 2.4
  TOP w0.089: CT21.2 187.57,167.18 187.24,166.85 185.81,166.85 UT1.H22
PEG_CTX_TRX_P12: length 81.8
  TOP w0.107: v2(192.61,161.39) 192.62,161.39 192.99,161.01 192.99,160.67 192.28,159.95 188.77,159.95 188.59,160.13 188.54,160.13 188.35,160.32 CT3.1
  IN6 w0.089: v2(192.61,161.39) 192.92,161.08 192.92,160.07 193.37,159.62 193.37,155.85 194.39,154.84 194.39,151.09 197.68,147.8 197.68,141.2 197.91,140.98 197.91,136.8 198.54,136.17 198.54,134.94 200.01,133.47 200.01,130.55 198.6,129.14 198.6,127.71 197.73,126.84 197.73,123.39 196.46,122.12 193.21,122.12 188.64,117.54 188.64,116.68 187.71,115.76 187.71,114.81 183.42,110.52 178.97,110.52 177.81,109.36 177.65,109.36 177.31,109.71 v2(177.31,109.74)
  BOTTOM w0.076: v2(177.31,109.74) 176.94,109.38 175.57,109.38 174.69,108.5 173.41,108.5 173.31,108.6 172.17,108.6 172.05,108.72 172.05,108.85 172.13,108.93 CPU1.B22
PEG_CTX_TRX_P12_C: length 3.1
  TOP w0.089: CT3.2 187.46,160.32 187.4,160.26 187.4,160.12 187.31,160.03 187.14,160.03 187.05,160.12 187.05,160.69 186.68,161.05 186.5,161.05 186.41,161.14 186.41,161.25 186.34,161.32 186.05,161.32 186,161.27 186,161.14 UT1.Y23
PEG_CTX_TRX_P13: length 77.1
  TOP w0.107: v2(191.15,162.12) 190.87,161.84 189.54,161.84 188.98,162.41 188.55,162.41 188.35,162.61 CT1.1
  IN6 w0.089: v2(191.15,162.12) 191.81,162.12 192.01,161.92 192.01,160.25 192.9,159.36 192.9,155.31 193.37,154.85 193.37,152.09 193.91,151.54 193.91,150.91 197.11,147.71 197.11,141.11 197.44,140.78 197.44,136.6 198.07,135.97 198.07,134.53 198.62,133.98 198.62,130.22 198.13,129.72 198.13,128.09 196.77,126.73 196.77,125.16 196.09,124.48 196.09,123.85 194.83,122.59 192.99,122.59 188.17,117.76 188.17,116.88 187.24,115.96 187.24,115.01 183.22,110.99 178.4,110.99 177.52,110.1 176.75,110.1 v2(176.72,110.07)
  BOTTOM w0.076: v2(176.72,110.07) 176.51,110.07 176.51,110.07 175.74,110.07 175.13,109.46 173.42,109.46 173.21,109.26 172.79,109.26 CPU1.B23
PEG_CTX_TRX_P13_C: length 2.5
  TOP w0.089: UT1.T23 186.14,163.05 186.29,163.05 186.39,162.95 186.39,162.84 186.56,162.68 186.91,162.68 187.23,162.35 187.3,162.35 187.36,162.42 187.36,162.72 187.43,162.79 187.59,162.79 CT1.2
PEG_CTX_TRX_P14: length 81
  TOP w0.107: v2(191.13,163.9) 190.79,164.24 189.54,164.24 189.23,164.55 188.65,164.55 188.43,164.32 CT4.1
  IN6 w0.089: v2(177.3,111.54) 177.3,111.49 177.12,111.3 176.93,111.3 176.84,111.39 176.84,111.73 177.08,111.97 183.31,111.97 186.57,115.23 186.57,116.19 187.53,117.15 187.53,118.28 192.48,123.22 194.43,123.22 195.45,124.25 195.45,124.82 196.13,125.5 196.13,126.99 196.62,127.48 196.62,129.12 197.99,130.48 197.99,133.71 197.43,134.27 197.43,135.71 196.47,136.67 196.47,147.45 193.28,150.64 193.28,151.28 192.25,152.31 192.25,159.09 190.31,161.02 190.31,163.82 190.65,164.16 190.83,164.16 190.97,164.3 191.23,164.3 191.31,164.21 191.31,164.09 v2(191.13,163.9)
  BOTTOM w0.076: CPU1.B24 172.11,110.5 172.04,110.43 172.04,110.28 172.13,110.18 173.31,110.18 173.39,110.09 174.71,110.09 175.87,111.25 177.02,111.25 v2(177.3,111.54)
PEG_CTX_TRX_P14_C: length 2.5
  TOP w0.089: UT1.M23 186.04,164.64 186.13,164.55 186.39,164.55 186.47,164.46 186.82,164.46 187.05,164.7 187.26,164.7 187.33,164.63 187.33,164.25 187.39,164.19 187.62,164.19 CT4.2
PEG_CTX_TRX_P15: length 78
  TOP w0.107: CT5.1 188.35,166.68 188.45,166.78 188.64,166.78 188.83,166.6 189.36,166.6 190.31,165.65 190.31,165.25 189.99,164.94 v2(189.75,164.94)
  IN6 w0.089: v2(189.75,164.94) 189.87,164.81 189.87,164.6 189.51,164.24 189.51,160.67 191.43,158.75 191.43,151.99 192.48,150.95 192.48,150.31 195.67,147.12 195.67,136.28 196.5,135.45 196.5,130.51 195.82,129.83 195.82,128.47 192.54,125.18 192.54,124.52 186.73,118.71 186.73,117.53 185.63,116.43 185.63,116.29 182.12,112.77 178.03,112.77 177.64,113.16 177.34,113.16 176.73,112.55 v2(176.71,112.55)
  BOTTOM w0.076: v2(176.71,112.55) 176.79,112.55 177.07,112.84 177.07,113.03 176.98,113.13 176.02,113.13 175.76,112.86 175.76,111.85 174.81,110.9 173.48,110.9 173.37,110.78 172.66,110.78 172.47,110.97 172.47,111.15 CPU1.B25
PEG_CTX_TRX_P15_C: length 2.4
  TOP w0.089: CT5.2 187.48,166.32 187.25,166.32 187.17,166.4 187.17,166.58 187.1,166.65 186.64,166.65 186.38,166.39 186.11,166.39 186.02,166.47 186.02,166.6 UT1.H23
PEG_RCOMP: length 6.2
  BOTTOM w0.089: RC2.2 v1(170.04,88.87)
  BOTTOM w0.254: CPU1.G2 169.01,94.21 169.01,93.35 169.9,92.46 170.03,92.46 170.06,92.42
  BOTTOM w0.381: 170.06,92.42 170.44,92.04 170.44,91.08 170.04,90.68 RC2.2
PEX_CLKREQ#: length 51.8
  TOP w0.102: v2(198.26,119.23) 198.53,118.96 198.53,118.61 198.93,118.22 199.42,118.22 205.3,124.1 206.88,124.1 v1(208.75,125.97) 208.86,125.97 211.57,128.68 v2(212.8,128.68)
  IN1 w0.102: v2(212.8,128.68) 217.53,128.68 219.11,127.1 226.77,127.1 234.29,119.57 v2(235.37,119.57)
  BOTTOM w0.089: RG2.1 235.25,119.69 v2(235.37,119.57) 235.68,119.57 236.13,119.12 236.13,116.26 236.47,115.92 UG9.BL26
  BOTTOM w0.102: QG510.3 197.8,119.69 v2(198.26,119.23)
PEX_TERMP: length 7.9
  TOP w0.089: v2(248.17,116.3) 247.72,115.86 243.59,115.86 243.4,115.67 RG23.2 242.83,115.3 v1(242.24,115.89)
  BOTTOM w0.089: UG9.BL44 248.52,116.3 v2(248.17,116.3)
PEX_VDD_EN: length 244.5
  TOP w0.102: PR823.1 v2(210.17,157.16) 210.13,157.12 210.13,156.06 v1(210.19,156)
  TOP w0.203: v2(316.35,60.72) 316.35,60.69 316.76,60.28 UE10.17
  IN4 w0.102: v2(210.17,157.16) 210.19,157.13 210.19,156.02 206.17,151.99 206.17,143.53 208.43,141.27 208.43,134.33 206.5,132.39 206.5,128.44 208.82,126.11 208.82,124.92 211.02,122.73 211.02,122.54 213.5,120.07 213.5,118.4 214.54,117.36 214.54,113.91 213.54,112.91 211.67,112.91 210.7,111.94 210.7,56.7 213.23,54.18 213.23,51.54 214.14,50.63 216.37,50.63 216.88,50.13 219.87,50.13 220.19,50.45 225.45,50.45 226.73,51.72 230.18,51.72 230.82,51.09 230.82,50.79 231.08,50.53 232.91,50.53 234.77,48.67 234.77,47.65 235.01,47.42 235.61,47.42 237.84,49.65 240.29,49.65 240.58,49.94 250.63,49.94 250.92,49.65 259.79,49.65 260.12,49.32 271.04,49.32 272.54,47.82 290.1,47.82 294.86,43.06 298.17,43.06 300.22,45.12 300.22,50.93 301.19,51.9 301.19,57.21 302.46,58.48 309.7,58.48 311.25,60.02 311.25,60.07 312.26,61.08 315.99,61.08 v2(316.35,60.72)
PEX_VDD_ENP: length 158.1
  TOP w0.102: v2(210.23,157.8) 210.23,158.13 PR823.2
  TOP w0.254: v2(238.69,40.15) 238.15,39.61 236.34,39.61 234.15,41.79 234.15,46.72 v1(234.2,46.77) 234.33,46.9 v2(234.33,47.87)
  IN4 w0.102: v2(234.33,47.87) 234.33,48.79 232.81,50.3 230.99,50.3 230.59,50.7 230.59,50.99 230.09,51.49 226.88,51.49 225.55,50.16 220.23,50.16 219.96,49.9 216.78,49.9 216.27,50.41 214.04,50.41 213,51.45 213,54.08 210.47,56.61 210.47,112.67 212.64,114.84 212.64,116.81 213.27,117.43 213.27,119.97 210.79,122.45 210.79,122.63 208.59,124.82 208.59,126.02 206.27,128.34 206.27,132.49 208.2,134.42 208.2,139.94 205.94,142.2 205.94,152.09 209.74,155.89 209.74,157.61 209.92,157.8 v2(210.23,157.8)
  BOTTOM w0.254: PC801.1 PR802.1 PR8217.2 ; PC801.1 PR801.1 ; PC801.1 238.39,39.85 v2(238.69,40.15) PU800.11
PI0: length 7.5
  BOTTOM w0.102: RV622.1 207.88,129.14 v1(207.58,128.84) 206.93,128.84 206.73,129.04 205.84,129.04 205.41,129.47 RV623.1 204.97,129.93 204.97,130.47 204.3,131.14 204.3,131.59 204.11,131.78 UV21.56
PLTRST_CPU#: length 220.8
  TOP w0.089: CH195.1 132.33,117.39 131.78,117.95 v2(131.78,117.95)
  IN1 w0.081: v2(208.74,41.6) 208.74,42.1 205.94,44.9 203.58,44.9 201.2,47.28 201.2,48.65 v2(199.08,50.77)
  IN3 w0.127: v2(131.78,117.95) 131.78,117.95 133.14,116.58 134.66,116.58 135.75,115.5 135.75,115.18 135.97,114.95 136.77,114.95 137.86,113.87 137.86,107.02 137.55,106.71 137.45,106.71 134.31,103.58 134.31,103.09 132.79,101.57 132.79,98.75 133.36,98.18 133.36,93.12 130.57,90.33 130.57,75.02 118.17,62.62 118.17,60.73 117.31,59.87 115.16,59.87 114.52,59.23 114.52,53.58 112.55,51.61 112.55,48.08 113.51,47.11 113.51,41.73 115.08,40.15 117.94,40.15 118.82,39.27 118.82,35.14 v2(118.94,35.02)
  IN6 w0.081: v2(199.08,50.77) 198.64,50.32 195.67,50.32 194.22,51.77 190.22,51.77 188.49,50.04 188.49,42.03 178.57,32.11 131.98,32.11 130.88,33.2 120.76,33.2 v2(118.94,35.02)
  BOTTOM w0.076: CPU1.BP35 133.46,117.95 133.25,117.95 133.13,117.83 132.55,117.83 132.49,117.77 131.96,117.77 131.78,117.95 v2(131.78,117.95)
  BOTTOM w0.089: UH1.AK2 208.89,39.06 209.13,39.29 209.13,39.41 209.16,39.45 209.16,39.89 209.24,39.97 209.24,40.69 208.74,41.19 v2(208.74,41.6)
PM_SLP_S3#: length 153.5
  TOP w0.102: v2(322.61,37.92) 322.61,37.99 322.93,38.31 v1(323.07,38.31) 324.29,38.31 324.62,38.64 QE1.5 324.62,39.53 324.43,39.72 322.97,39.72 322.68,40.01 322.08,40.01 321.89,40.2 Q8.2 ; 304.22,25.31 303.54,24.63 UE5.6 303.54,21.86 301.51,19.83 301.51,17.98 301.04,17.52 301.04,15.7 v2(301.22,15.53) ; 304.22,25.31 v2(304.22,25.3) ; 304.22,25.31 303.91,25.62 CE41.1
  IN2 w0.102: v2(322.61,37.92) 322.61,35.09 318.29,30.77 311.6,30.77 306.64,25.8 304.72,25.8 v2(304.22,25.3) ; v2(213.2,33.18) 213.2,33.16 213.75,32.61 215.51,32.61 216.46,31.66 217.2,31.66 218.09,30.77 219.56,30.77 219.83,30.49 222.21,30.49 223.12,29.57 223.12,28.53 225.5,26.15 225.5,24.98 226.35,24.12 226.35,23.05 227.86,21.54 227.86,21.34 227.86,20.78 228.59,20.05 229.61,20.05 230.36,19.3 232.14,19.3 233.16,18.27 234.75,18.27 235.73,17.29 244.95,17.29 245.98,18.33 245.98,19.56 245.49,20.05 245.49,22.89 245.85,23.24 247.77,25.17 256.42,25.17 257.63,23.96 257.63,23.45 259.94,21.14 268.34,21.14 269.43,20.05 271.67,20.05 272,19.72 275.72,19.72 280.1,15.34 294.78,15.34 294.99,15.55 296.29,15.55 296.85,14.99 300.69,14.99 v2(301.22,15.53)
  BOTTOM w0.089: UH1.AW15 213.52,32.9 213.48,32.9 v2(213.2,33.18)
PM_SLP_S3_H: length 9.9
  TOP w0.102: 321.89,39.59 322.08,39.78 322.4,39.78 322.54,39.64 Q8.6 ; 321.89,39.59 321.83,39.66 320.87,39.66 320.49,40.04 v1(320.49,42.11) 320.54,42.16 Q7.5 Q7.2 ; 321.89,39.59 Q8.5 321.89,38.34 R307.2
PM_SLP_S4#: length 323.1
  TOP w0.107: Q9.2 327.1,40.8 325.91,39.61 325.91,33.92 v1(325,33.01) 323.79,31.8 323.79,26.82 v2(322.84,25.87) ; v2(296.37,16.48) 296.58,16.27 296.58,13.85 296.08,13.35 296.08,9.24 296.34,8.97 UE5.73
  IN1 w0.102: v2(322.84,25.87) 322.37,26.35 317.76,26.35 313.46,22.04 313.46,18.09 312.35,16.99 308.05,16.99 307.21,16.15 296.88,16.15 296.55,16.48 v2(296.37,16.48)
  IN2 w0.102: v2(296.37,16.48) 296.11,16.73 292.61,16.73 291.9,16.02 280.38,16.02 274.58,21.83 266.89,21.83 264.53,24.19 261.46,24.19 259.57,26.08 258.06,26.08 257.11,27.03 248.66,27.03 244.51,22.88 244.51,19.72 244.56,19.68 244.56,18.8 243.74,17.98 236.02,17.98 234.18,19.82 232.69,19.82 231.77,20.73 228.87,20.73 228.55,21.06 228.55,22.9 227.11,24.33 227.11,28.54 224.3,31.35 v2(222.15,31.35) 221.63,31.87 219.69,31.87 v2(218.71,32.85)
  IN6 w0.102: v2(97.74,51.21) 100.21,51.21 110.34,41.08 111.82,41.08 113.23,39.68 180.15,39.68 184.78,44.3 184.78,51.93 188.4,55.55 192.36,55.55 196.27,59.46 200.23,59.46 202.03,57.66 204.26,57.66 204.55,57.95 v2(205.07,57.95)
  BOTTOM w0.089: v2(218.71,32.85) 218.18,32.33 216.76,32.33 216.58,32.51 216.38,32.51 216.13,32.76 UH1.BD15 ; 217.69,42.08 217.78,42.08 219.18,40.68
  BOTTOM w0.102: v2(205.07,57.95) 206.18,57.95 207.91,56.23 207.91,54.46 211.51,50.86 211.51,50.46 217.69,44.29 217.69,42.08 217.69,42.08 ; v2(222.15,31.35) 223,32.19 223,37.61 222.56,38.04 222.56,38.99 221.67,39.88 220.33,39.88 220.02,40.2 219.65,40.2 219.18,40.68
  BOTTOM w0.107: PR1301.2 98.15,51.63 v2(97.74,51.21)
PM_SLP_S4_H: length 4.8
  TOP w0.102: v1(328.63,37.76) 328.63,38.26 Q9.6 327.75,39.53 327.65,39.63 327.2,39.63 327.1,39.53 Q9.5 327.1,38.5 326.68,38.08 R325.2
PM_SLP_S5#: length 158
  TOP w0.102: v2(322.9,42.45) 323.29,42.84 QE4.5 ; 300.34,24.73 300.34,25.24 300.36,25.26 CE45.1 299.84,26.42 299.84,28.05 v1(299.31,28.58) v2(298.84,29.05)
  TOP w0.107: v2(298.87,15.56) 298.59,15.84 298.59,18.57 298.97,18.96 298.97,21.69 300.34,23.06 UE5.14 300.34,24.73
  IN2 w0.102: v2(298.84,29.05) 299.81,28.09 303.47,28.09 305.57,30.19 310.06,30.19 311.32,31.45 318,31.45 321.22,34.67 321.22,38.17 322.59,39.53 322.59,42.14 v2(322.9,42.45) ; v2(213.94,34.25) 213.94,34 214.32,33.62 215.28,33.62 216.73,32.16 218.81,32.16 219.33,31.64 221.06,31.64 221.76,30.94 224.38,30.94 226.88,28.45 226.88,27.32 226.11,26.54 226.11,25.01 228.32,22.8 228.32,21.15 228.32,20.97 228.78,20.5 231.68,20.5 232.59,19.59 234.08,19.59 235.92,17.75 243.84,17.75 244.79,18.7 244.79,19.77 244.74,19.82 244.74,22.78 248.76,26.8 257.01,26.8 257.97,25.85 259.48,25.85 261.37,23.96 264.43,23.96 266.79,21.6 274.48,21.6 280.29,15.79 291.99,15.79 292.71,16.5 295.67,16.5 296.61,15.56 v2(298.87,15.56)
  BOTTOM w0.089: UH1.BA13 213.94,34.07 v2(213.94,34.25)
PM_SLP_SUS#: length 108.6
  TOP w0.102: v1(289.62,20.15) 289.68,20.21 UE5.38
  TOP w0.107: v2(292.98,16.1) 292.8,16.27 292.8,19.96 292.55,20.21 UE5.38
  IN2 w0.102: v2(292.98,16.1) 292.44,15.56 280.19,15.56 275.81,19.95 272.09,19.95 271.76,20.28 269.52,20.28 268.43,21.37 266.7,21.37 264.34,23.73 261.27,23.73 259.38,25.62 257.87,25.62 256.92,26.58 252.32,26.58 251.14,25.39 247.67,25.39 244.97,22.69 244.97,20.25 245.75,19.46 245.75,18.42 244.85,17.52 235.83,17.52 233.99,19.36 232.5,19.36 232.33,19.53 230.45,19.53 229.7,20.28 228.68,20.28 228.09,20.87 228.09,21.25 228.09,21.63 226.58,23.15 226.58,24.22 225.75,25.05 225.75,26.96 225.74,26.97 225.74,29.26 224.29,30.72 219.93,30.72 219.28,31.37 218.8,31.85 216.54,31.85 215.23,33.16 v2(214.56,33.16)
  BOTTOM w0.089: v2(214.56,33.16) 214.56,33.39 214.8,33.63 UH1.BB13
POK: length 241.9
  TOP w0.508: PR14.1 67.94,8.18 PR17.2 67.94,9.44 68.21,9.71 69.33,9.71 69.64,9.4 69.64,8.85 70.16,8.33 72.48,8.33 74.29,6.53 85.21,6.53 87.26,8.58 v1(87.26,16.73) 87.26,18.04 86.75,18.55 85.72,18.55 v2(85.17,18)
  IN2 w0.508: v2(85.17,18) 85.59,18.42 96.87,18.42 99.54,21.09 99.54,24.45 99.53,24.47 99.53,29.15 100.57,30.19 110.19,30.19 112.65,32.65 119.96,32.65 122.18,34.87 166.05,34.87 167.51,33.41 178.11,33.41 186.42,41.72 203.3,41.72 203.34,41.69 204.89,41.69 205.98,42.79 210.65,42.79 210.87,42.56 213.25,42.56 213.62,42.93 214.34,42.93 214.75,42.52 v2(219,42.52)
  IN3 w0.508: v2(56.31,46.5) 56.31,46.72 56.69,47.1 57.22,47.1 57.94,46.39 63.7,46.39 66.8,43.29 69.38,43.29 81.38,31.3 81.38,24.23 83.49,22.12 83.49,19.69 v2(85.17,18)
  BOTTOM w0.203: v2(56.31,46.5) 55.89,46.08 PU100.7
  BOTTOM w0.508: v2(219,42.52) 219,41.47 219.73,40.74 221.43,40.74 223.08,39.08 223.08,38.18 223.64,37.62 DE3.1
POWER_LED: length 260.9
  TOP w0.457: QE4.6 323.94,42.14 v1(323.89,42.09) 323.76,41.96 v2(323.26,41.96)
  TOP w0.508: RE28.2 205.98,158.57 QE8.2 207.49,159.48 v2(207.2,159.77)
  IN4 w0.508: v2(207.2,159.77) 205.51,158.08 204.93,158.08 202.47,155.62 198.19,155.62 196.24,153.67 196.24,150.33 198.19,148.38 199.74,148.38 201.75,146.37 201.75,142.77 200.63,141.65 200.63,140.02 201.68,138.97 204.29,138.97 204.75,138.51 204.75,137.65 202.22,135.12 202.22,133.8 202.4,133.62 202.4,130.42 200.91,128.92 200.91,128.32 202.47,126.76 202.47,125.4 202.56,125.3 202.56,123.19 203.27,122.48 203.27,112.05 206.42,108.9 206.42,102.17 207.01,101.58 207.01,67.15 206.56,66.7 206.56,62.08 206.97,61.68 206.97,53.81 209.7,51.08 209.7,49 211.74,46.96 213.97,46.96 215.98,44.96 223.41,44.96 225.93,42.44 228.59,42.44 228.73,42.58 232.74,42.58 234.17,44.01 238.83,44.01 239.99,42.86 246.92,42.86 248.31,44.24 259.78,44.24 260.39,43.63 266.73,43.63 273.76,36.6 276.65,36.6 279.8,39.74 290.58,39.74 292.55,37.78 296.62,37.78 300.09,41.24 305.61,41.24 306.19,41.83 308.39,41.83 308.57,41.65 318.75,41.65 319.26,41.14 322.44,41.14 v2(323.26,41.96)
PQ703_S:
  vias: v1(79.47,32.21) v2(76.89,31.5) v2(76.89,30.87) v2(77.05,30.19) v2(77.53,31.5) v2(77.53,30.87) v2(77.75,30.19) v2(78.16,31.5) v2(78.16,30.87) v2(78.38,30.19) v2(78.8,31.5) v2(78.8,30.87) v2(79.5,31.5) v2(79.5,30.87) v2(80.13,31.5) v2(80.13,30.87)
PROC_DETECT#: length 210
  IN1 w0.097: v2(204.19,17.41) 203.51,16.73 201.49,16.73 200.99,17.24 200.99,21.56 200.25,22.29 199.11,22.29 198.79,22.61 197.83,22.61 197.14,23.3 196.65,23.3 196,22.66 194.69,22.66 193.27,21.24 ; 191.84,20.61 192.48,21.24
  IN1 w0.102: v2(106.94,32.48) 109.98,29.45 118.6,29.45 119.29,30.13 182.81,30.13 186.38,26.56 186.38,24.48 186.99,23.87 187.62,23.87 190.89,20.61 191.84,20.61 ; 192.48,21.24 193.27,21.24
  IN3 w0.102: v2(126.12,118.08) 127.06,117.14 127.06,113.71 128.42,112.34 128.42,107.46 128.75,107.13 128.75,104.84 121.84,97.93 121.84,96.18 118.33,92.67 118.33,91.32 117.17,90.15 117.17,72.16 108.16,63.15 108.16,60.63 104.83,57.29 104.83,53.72 104.47,53.36 104.47,37.68 106.94,35.21 v2(106.94,32.48)
  BOTTOM w0.089: v2(204.19,17.41) 203.91,17.69 UH1.Y44
  BOTTOM w0.107: RH519.1 126.4,117.8 v2(126.12,118.08)
PS_ID: length 38.2
  TOP w0.102: v2(311.91,47.67) v1(311.25,47.67)
  TOP w0.203: UE5.16 299.54,25.14 v2(299.61,25.22)
  TOP w0.254: PR3.1 PR4.2 v2(311.91,47.67)
  IN2 w0.254: v2(312.14,29.14) 310.41,29.14 306.76,25.5 305.1,25.5 304.42,24.82 303.57,24.82 302.66,25.72 300.12,25.72 v2(299.61,25.22)
  IN3 w0.254: v2(311.91,47.67) 310.57,46.34 310.57,33.83 312.14,32.26 v2(312.14,29.14)
PSID: length 50.2
  TOP w0.102: v2(65.03,46.84) v1(65.03,46.17)
  IN2 w0.254: v2(65.03,46.84) 64.91,46.96 58.13,46.96 57.66,47.44 48.25,47.44 47.93,47.11 35.14,47.11 33.85,48.4 30.22,48.4 v2(29.73,47.91)
  BOTTOM w0.254: PJPDC1.1 66.32,47.78 66.06,48.04 65.29,48.04 65.03,47.78 v2(65.03,46.84) ; v2(29.73,47.91) 29.09,47.28 PL2.2
PSID-1: length 1.5
  TOP w0.102: PQ2.2 v1(319.2,50.59)
PSID-2: length 1.5
  TOP w0.102: v1(315.35,52.39) 316.09,51.65 PQ2.1
PSID-3: length 1.2
  TOP w0.102: PR4.1 v1(312.56,45.55)
PWM1: length 6.2
  TOP w0.254: PR6067.2 278.89,134.84 v1(278.05,134.84) v2(277.31,134.84)
  BOTTOM w0.203: v2(277.31,134.84) 277.21,134.95 PU6000.11
  BOTTOM w0.254: v2(277.31,134.84) 278.89,134.84 PR6067.2
PWM1_GT: length 23.2
  IN1 w0.254: v2(123.07,144.37) 123.07,144.18 123.33,143.92 127.64,143.92 129.45,145.73 136.07,145.73 140.64,150.3 v2(140.85,150.3)
  BOTTOM w0.203: PU500.12 123.09,143.28 122.86,143.52 122.86,144.16 v2(123.07,144.37)
  BOTTOM w0.254: v2(140.85,150.3) 141.11,150.56 PR590.1
PWM1_VCORE: length 38
  IN6 w0.254: v2(157.17,148.5) 157.11,148.56 157.11,149.44 151.83,154.72 144.43,154.72 141.26,151.54 135.52,151.54 132.29,148.32 v2(132.29,147.34)
  BOTTOM w0.203: PU500.25 129.86,143.28 130.87,144.3 130.87,145.95 v1(131.23,146.31) 132.26,147.34 v2(132.29,147.34)
  BOTTOM w0.254: PR552.1 157.38,148.29 v2(157.17,148.5)
PWM2: length 3
  TOP w0.102: v2(279.03,136.49) 278.55,136.49 v1(278.41,136.35)
  TOP w0.254: PR6066.2 v2(279.03,136.49)
  BOTTOM w0.203: PU6000.10 279.01,136.47 v2(279.03,136.49) PR6066.2
PWM2_GT: length 30.8
  IN1 w0.254: v2(123.77,144.5) 124.28,144.5 124.53,144.75 124.53,145.7 124.94,146.11 135.91,146.11 140.58,150.78 141.55,150.78 141.99,150.34 144.1,150.34 144.73,150.97 148.28,150.97 v2(148.53,150.72)
  BOTTOM w0.203: v2(123.77,144.5) 123.85,144.58 124.13,144.58 124.27,144.43 PU500.13
  BOTTOM w0.254: PR591.1 148.67,150.59 v2(148.53,150.72)
PWM2_VCORE: length 43.5
  IN1 w0.254: v2(130.5,143.1) 129.87,143.73 129.87,144.75 130.46,145.35 136.23,145.35 140.01,149.13 141.55,149.13 142.38,149.96 144.26,149.96 144.44,150.15 158.17,150.15 159.23,149.08 160.4,149.08 162.57,146.91 164.94,146.91 v2(165.04,147.01)
  BOTTOM w0.102: v1(164.92,146.35) 165.04,146.47 v2(165.04,147.01)
  BOTTOM w0.203: PU500.26 129.9,142.88 129.99,142.97 130.37,142.97 v2(130.5,143.1)
  BOTTOM w0.254: PR563.1 165.3,147.27 v2(165.04,147.01)
PWM3: length 2.6
  TOP w0.254: PR6065.2 279.22,137.38 v2(279.03,137.19)
  BOTTOM w0.203: PR6065.2 279.22,137.38 v2(279.03,137.19) 278.71,136.87 PU6000.9
PWM3_VCORE: length 51.9
  IN1 w0.254: v2(173.42,147.1) 172.85,146.53 162.38,146.53 160.21,148.7 159.08,148.7 158.01,149.77 144.6,149.77 144.41,149.58 142.54,149.58 141.71,148.75 140.17,148.75 136.38,144.96 131.27,144.96 130.95,144.64 130.95,143.33 130.98,143.3 130.98,143 v2(131.13,142.85)
  BOTTOM w0.102: v1(174.25,148.47) PR573.1
  BOTTOM w0.203: v2(131.13,142.85) 131.07,142.85 130.82,142.59 130.12,142.59 130.01,142.48 PU500.27
  BOTTOM w0.254: v2(173.42,147.1) 173.63,147.3 PR573.1
PWM4: length 3.6
  TOP w0.102: v2(279.03,137.83) 278.49,137.83 v1(278.35,137.97)
  TOP w0.254: v2(279.03,137.83) 279.47,138.27 PR6064.2
  BOTTOM w0.203: PR6064.2 279.47,138.27 v2(279.03,137.83) 278.96,137.83 278.41,137.27 PU6000.8
PWM_SA: length 82.3
  IN4 w0.254: v2(179.12,146.79) 179.12,147.79 178.87,148.04 177.36,148.04 176.3,146.97 174.24,146.97 173.62,147.58 169.21,147.58 168.6,146.97 165.77,146.97 164.85,147.88 164.85,148.69 159.56,148.69 157.78,150.46 155.38,150.46 151.88,153.96 143.39,153.96 139.96,150.53 126.28,150.53 125.29,149.54 125.29,147.16 124.5,146.37 124.5,144.9 125.74,143.67 125.74,140.81 126.31,140.24 129.71,140.24 130.15,139.8 131.52,139.8 131.77,139.54 131.77,139.18 131.4,138.81 130.9,138.81 v2(130.88,138.78)
  BOTTOM w0.203: PU500.35 130.38,139.28 v2(130.88,138.78)
  BOTTOM w0.254: PR5001.2 180.6,146.21 180.28,146.53 179.39,146.53 v2(179.12,146.79)
PWR_B#: length 14.9
  TOP w0.102: v2(211.64,170.32) 211.82,170.14 211.82,170.11 JPWR.4 ; RE160.1 202.85,175.22 v2(202.66,175.02) RE154.2
  TOP w0.107: QE13.3 201.94,173.84 201.91,173.86 RE154.2
  IN3 w0.102: v2(211.64,170.32) 211.32,170.32 211.31,170.31 209.96,170.31 209.28,171 208.83,171 208.22,171.61 206.44,173.39 204.29,173.39 v2(202.66,175.02)
PWR_B_7313#: length 38.3
  TOP w0.127: v2(231.53,162.69) v1(231.53,163.84)
  TOP w0.254: UE3.17 231.01,162.17 v2(231.53,162.69)
  TOP w0.508: v2(202.83,172.48) 202.69,172.48 201.94,171.73 QE13.4
  IN3 w0.508: v2(202.83,172.48) 204.19,171.12 206.04,171.12 208.32,168.84 220.85,168.84 223.25,166.45 227.17,166.45 228.48,165.13 228.48,163.08 228.86,162.69 v2(231.53,162.69)
PWR_B_EC: length 299.7
  TOP w0.102: v2(328.4,42.32) 328.53,42.45 UE6.22 ; v2(201.58,172.53) 202.05,172.53 202.59,173.07 QE13.2
  IN4 w0.089: 212.81,42 213.52,41.29 216,41.29 216.69,41.98
  IN4 w0.102: 216.69,41.98 218.55,41.98 218.69,41.84 219.22,41.84 219.96,42.58 221.5,42.58 224.98,39.1 229.65,39.1 230.66,40.11 235.65,40.11 236.29,39.47 238.12,39.47 238.5,39.1 239.35,39.1 239.88,39.62 247.14,39.62 249.35,41.83 258.85,41.83 259.27,41.4 259.41,41.27 265.67,41.27 272.74,34.2 277.4,34.2 278.22,33.37 281.64,33.37 282.93,34.66 290.94,34.66 292.61,32.99 321.15,32.99 321.85,32.29 323.95,32.29 328.4,36.74 328.4,39.57 329.3,40.47 329.3,41.41 v2(328.4,42.32) ; 212.81,42 211.66,43.14 211.35,43.14 210.21,44.28 203.32,44.28 200.85,46.75 200.85,50.25 201.38,50.77 201.38,59.04 200.29,60.13 200.29,62.37 197.78,64.88 190.46,64.88 188.27,67.07 188.27,67.79 187.75,68.32 187.75,72.53 187.16,73.11 187.16,80.55 188.22,81.61 188.22,93.02 187.02,94.22 187.02,96.33 186.42,96.93 186.42,98.46 186.61,98.65 186.61,109.28 192.87,115.55 192.87,121.22 195.56,123.91 195.56,124.78 196.15,125.37 196.15,126.98 196.29,127.12 196.29,129.45 196.79,129.95 196.79,134.14 197.58,134.93 197.58,139.35 196.57,140.35 196.57,146.16 193.09,149.65 193.09,151.75 191.7,153.13 191.7,157.82 194.86,160.98 194.86,163.17 195.59,163.9 195.59,166.63 196.39,167.43 196.39,170.11 197.43,171.15 200.21,171.15 v2(201.58,172.53)
PWR_G#: length 24.5
  TOP w0.102: JPWR.3 211.32,167.56 210.74,168.14 206.76,168.14 205.12,169.79 v1(204.09,169.79) 200.92,169.79 200.38,170.32 199.54,170.32 198.87,171 198.87,172.75 QE21.3 199.46,174.46 199.78,174.78 200.43,174.78 200.53,174.89 RE155.1 200.37,175.37 199.61,175.37 198.76,174.53 198.76,173.3 RE156.2
PWR_G_7313#: length 43
  TOP w0.254: UE3.16 232.21,160.36 232.42,160.56 232.42,161.14 v2(231.54,162.02)
  TOP w0.508: QE21.4 199.46,171.73 199.96,172.23 v2(199.96,172.52)
  IN3 w0.508: v2(231.54,162.02) 227.75,162.02 227.11,162.66 227.11,165.21 226.51,165.81 221.69,165.81 221.02,166.48 208.46,166.48 206.67,168.28 206.67,169.32 205.49,170.49 203.59,170.49 202.19,171.88 202.19,172.78 201.81,173.16 200.47,173.16 199.96,172.65 v2(199.96,172.52)
PWR_G_EC: length 305.2
  TOP w0.102: UE6.10 334.72,42.95 335.02,42.65 335.02,38.76 v1(334.81,38.54) 334.81,36.59 332.45,34.22 v2(330.8,34.22) ; v2(199.32,172.55) 200.11,173.34 QE21.2
  IN4 w0.102: v2(330.8,34.22) 330.62,34.04 326.76,34.04 324.55,31.83 321.66,31.83 320.96,32.53 292.42,32.53 291.44,33.51 282.42,33.51 281.04,32.12 278.8,32.12 277.19,33.74 272.55,33.74 265.48,40.81 259.22,40.81 258.81,41.21 258.66,41.37 249.54,41.37 247.33,39.16 240.06,39.16 239.3,38.4 233.66,38.4 232.4,39.66 230.85,39.66 229.84,38.64 224.79,38.64 222.32,41.1 218.77,41.1 218.57,40.91 213.24,40.91 211.46,42.68 211.16,42.68 210.02,43.83 203.13,43.83 200.4,46.56 200.4,50.44 200.92,50.96 200.92,58.85 199.83,59.94 199.83,62.18 197.59,64.43 190.27,64.43 187.81,66.88 187.81,67.6 187.29,68.13 187.29,72.34 186.71,72.92 186.71,80.74 187.77,81.8 187.77,92.83 185.96,94.63 185.96,98.65 186.15,98.84 186.15,109.93 187.65,111.42 187.65,112.05 189.75,114.14 190.39,114.14 191.16,114.9 191.16,115.79 192.42,117.05 192.42,121.41 194.39,123.38 194.39,127.03 195.83,128.46 195.83,129.64 196.33,130.14 196.33,134.33 197,134.99 197,137.34 196.12,138.23 196.12,145.97 192.63,149.46 192.63,151.56 191.25,152.94 191.25,158.01 194.41,161.17 194.41,163.36 195.12,164.07 195.12,169.49 197.4,171.77 198.55,171.77 v2(199.32,172.55)
PWR_LED#: length 54.8
  TOP w0.203: UE5.92 303.94,6.19 v2(303.98,6.15)
  TOP w0.432: QE4.2 323.29,44.42 323.54,44.16 v2(323.92,44.16)
  IN3 w0.508: v2(303.98,6.15) 303.77,6.36 303.77,7.86 306.67,10.77 311.37,10.77 319.41,18.81 319.41,22.46 319.81,22.85 319.81,24.72 319.31,25.22 319.31,26.97 325.96,33.62 325.96,41.39 324.93,42.42 324.74,42.42 323.92,43.24 v2(323.92,44.16)
PWR_R#: length 11.1
  TOP w0.102: v2(210.13,170.72) 210.13,171.18 v1(211.26,172.31) ; RE158.2 v2(204.99,174.31) 205.72,174.31 RE157.1
  TOP w0.107: RE158.2 204.31,173.95 204.41,173.85 QE22.3
  IN3 w0.102: v2(204.99,174.31) 205.84,174.31 208.92,171.23 209.62,171.23 v2(210.13,170.72)
PWR_R_7313#: length 39.3
  TOP w0.127: v1(233.89,160.93) 233.23,160.93 v2(233.18,160.88)
  TOP w0.254: UE3.15 232.67,159.86 232.86,160.05 232.86,160.56 v2(233.18,160.88)
  TOP w0.508: QE22.4 v2(204.41,172.25)
  IN3 w0.508: v2(233.18,160.88) 233.5,161.2 233.5,163.09 232.82,163.77 231.56,163.77 231.05,164.27 231.05,165.11 229.07,167.08 223.51,167.08 220.93,169.66 209.39,169.66 207.29,171.76 204.9,171.76 v2(204.41,172.25)
PWR_R_EC: length 305.1
  TOP w0.102: UE6.6 332.54,40.27 333.09,39.72 333.09,38.08 v1(332.5,37.48) 331.99,37.48 v2(331.89,37.59) ; QE22.2 v2(205.06,172.68)
  IN4 w0.102: v2(205.06,172.68) 204.66,173.08 200.72,173.08 200.36,172.73 200.36,172.27 199.53,171.43 197.39,171.43 196.05,170.09 196.05,167.41 195.36,166.73 195.36,163.99 194.64,163.27 194.64,161.07 191.47,157.91 191.47,153.04 192.86,151.65 192.86,149.55 196.34,146.06 196.34,140.26 197.35,139.25 197.35,135.02 196.56,134.23 196.56,130.05 196.06,129.55 196.06,127.21 195.92,127.08 195.92,125.46 195.33,124.87 195.33,124 192.65,121.31 192.65,115.71 190.85,113.91 189.84,113.91 187.88,111.95 187.88,111.33 186.38,109.83 186.38,98.74 186.19,98.55 186.19,94.72 187.99,92.92 187.99,81.7 186.93,80.64 186.93,73.02 187.52,72.44 187.52,68.22 188.04,67.7 188.04,66.97 190.36,64.66 197.68,64.66 200.06,62.28 200.06,60.03 201.15,58.94 201.15,50.87 200.62,50.34 200.62,46.66 203.23,44.06 210.11,44.06 211.25,42.91 211.55,42.91 213.37,41.1 218.5,41.1 218.73,41.33 222.42,41.33 224.88,38.87 229.74,38.87 230.76,39.88 232.5,39.88 233.74,38.64 239.22,38.64 239.97,39.39 247.24,39.39 249.45,41.6 258.75,41.6 259.04,41.31 259.31,41.04 265.57,41.04 272.65,33.97 277.28,33.97 278.89,32.35 280.95,32.35 283.02,34.43 290.85,34.43 292.52,32.76 321.05,32.76 321.75,32.06 324.14,32.06 327.16,35.08 328.48,35.08 330.98,37.59 v2(331.89,37.59)
PWR_SRC_ON: length 16.3
  BOTTOM w0.102: v1(150.73,167.88) 151.2,167.41 RV9.2 CV15.2 153.43,167.41 154.23,166.61 156.04,166.61 156.16,166.72 156.16,167.66 156.71,168.22 158.16,168.22 158.76,168.82 QV1.3 160.47,168.82 160.64,168.65 160.64,168.15 160.14,167.66 160.14,165.22 RV12.1
PWR_VGA_CORE_BOOT1: length 2.9
  BOTTOM w0.102: PR8205.2 v1(245.07,29.82)
  BOTTOM w0.203: PU8200.1 245.53,30.93 246.19,30.26 PR8205.2
PWR_VGA_CORE_BOOT1_1: length 2.6
  BOTTOM w0.254: PC8206.2 249.11,30.07 v1(248.86,29.82) PR8205.1
PWR_VGA_CORE_BOOT2_1: length 1.8
  BOTTOM w0.102: PC8213.2 248.9,37.31 v1(249.32,37.74)
PWR_VGA_CORE_LGATE1: length 24
  IN4 w0.508: v2(247.15,32.19) 247.53,32.19 249.85,29.88 257.75,29.88 258.25,29.37 261.95,29.37 v2(264.87,26.45)
  BOTTOM w0.102: PQ8200.6 266.04,26.45 v1(266.71,27.12)
  BOTTOM w0.203: PR8206.2 247.19,32.16 v2(247.15,32.19) 246.84,32.51 PU8200.19
  BOTTOM w0.508: PQ8200.6 v2(264.87,26.45)
PWR_VGA_CORE_LGATE2: length 9.1
  IN4 w0.508: v2(251.21,31.15) 251.21,31.17 248.83,33.56 v2(247.15,33.56)
  BOTTOM w0.102: v2(251.21,31.15) 251.21,30.23 v1(250.62,29.64)
  BOTTOM w0.203: v2(247.15,33.56) 247.02,33.56 246.77,33.31 PU8200.17
  BOTTOM w0.508: v2(251.21,31.15) 251.87,30.49 PQ8201.6
PWR_VGA_CORE_PHASE1: length 23.4
  TOP w0.102: v1(265.12,35.08) PR8204.1
  TOP w0.254: v2(264.25,32.61) 265.12,33.48 PR8204.1
  IN4 w0.508: v2(263.34,26) 260.61,28.73 257.99,28.73 257.48,29.24 249.56,29.24 247.4,31.4 v2(247.04,31.4)
  BOTTOM w0.203: PC8206.1 247.4,31.4 v2(247.04,31.4) 246.77,31.67 246.77,31.94 246.6,32.11 PU8200.20
PWR_VGA_CORE_PHASE2: length 6.6
  TOP w0.102: PR8210.1 v1(254.43,33.62)
  IN4 w0.508: v2(247.15,34.2) 249.09,34.2 250.3,32.99 v2(251.28,32.99)
  vias: v2(251.85,32.48)
PWR_VGA_CORE_SS: length 2.2
  BOTTOM w0.203: PU8200.11 243.93,34.82 v1(243.26,35.48) 243.21,35.53 PC8216.1
PWR_VGA_CORE_TON: length 3
  BOTTOM w0.102: v1(241.21,32.63) 241.45,32.86 PR8202.1
  BOTTOM w0.203: PR8202.1 242.41,33.62 242.73,33.31 PU8200.9
PWR_VGA_CORE_TON_1: length 3.2
  BOTTOM w0.102: v1(239.54,36.39) PR8201.1
  BOTTOM w0.203: PR8202.2 PC8205.1 PR8201.1
PWR_VGA_CORE_UGATE1: length 17.2
  IN4 w0.508: v2(259.15,26.59) 259.15,26.67 257.22,28.61 249.12,28.61 247.28,30.45 v2(245.33,30.45)
  BOTTOM w0.203: v2(245.33,30.45) 245.31,30.47 245.31,30.5 245.13,30.68 PU8200.2
  BOTTOM w0.508: v2(259.15,26.59) 259.29,26.45 PQ8200.1
PWR_VGA_CORE_UGATE2: length 17.3
  IN4 w0.508: v2(258.39,30.13) 258.01,30.51 250.11,30.51 247.7,32.93 246.83,32.93 246.2,33.56 246.2,33.65 245.34,34.5 v2(245.34,35.22)
  BOTTOM w0.203: v2(245.34,35.22) 245.33,35.22 245.13,35.02 PU8200.14
  BOTTOM w0.508: v2(258.39,30.13) PQ8201.1
PWRSHARE_EN_EC#: length 321
  TOP w0.102: v1(25,43.14) 25.41,43.54 v2(25.41,44.23)
  TOP w0.107: v2(25.41,44.23) 25.29,44.23 24.89,43.83 UU1.5 ; v2(308.47,18.78) 308.31,18.61 UE5.119
  IN2 w0.102: v2(25.41,44.23) 25.85,44.23 29.09,47.47 30.04,47.47 30.67,48.1 31.88,48.1 33.17,46.81 48.8,46.81 49.19,46.42 52.36,46.42 53.07,47.13 57.53,47.13 58,46.66 64.11,46.66 64.81,45.96 96.39,45.96 96.95,45.4 98.88,45.4 99.04,45.23 108.2,45.23 109.04,46.07 112.21,46.07 113.1,45.18 113.1,40.61 114.35,39.36 133.36,39.36 134.16,38.56 179.93,38.56 184.71,43.34 188.1,46.73 191.28,46.73 193.11,48.56 198.85,48.56 203.05,44.36 211.33,44.36 211.56,44.13 212.53,44.13 213.21,44.81 215.9,44.81 216.42,44.29 221.37,44.29 225.59,40.08 229.79,40.08 230.42,40.7 231.46,40.7 232.9,42.13 234.77,42.13 235.61,42.97 238.94,42.97 241.33,40.58 243.9,40.58 244.59,41.28 266.78,41.28 275.9,32.16 279.29,32.16 283.73,27.72 290.32,27.72 294.22,23.82 304.83,23.82 305.51,24.5 307.18,24.5 307.53,24.86 v2(307.78,24.86)
  BOTTOM w0.107: v2(307.78,24.86) 307.95,24.7 307.95,19.31 v2(308.47,18.78)
REFADJ: length 3.5
  BOTTOM w0.203: PU6000.40 277.21,141.16 277.62,141.57 278,141.57 v1(278.79,142.36) 278.79,143.03 PR6040.1
REFIN: length 7.2
  IN1 w0.254: v2(278.86,140.27) 280.65,142.06 v2(281.2,142.06)
  BOTTOM w0.102: v1(280.35,143.07) 280.56,142.86 PR6045.1
  BOTTOM w0.203: PU6000.1 278.67,140.07 v2(278.86,140.27) 279.54,140.94 PR6053.1
  BOTTOM w0.254: v2(281.2,142.06) 281.12,142.06 280.89,141.83 PR6045.1
REGN_CHG: length 17.1
  TOP w0.203: v2(60.71,21.49) 60.55,21.49 60.22,21.83 PU700.24
  TOP w0.254: v2(53.98,26.89) 53.98,27.4 54.86,28.28 v1(55.53,28.28) 56.04,27.77 PR714.1
  IN3 w0.254: v2(60.71,21.49) 60.71,22.96 59.15,24.52 58.28,24.52 57.85,24.95 55.63,24.95 55.34,25.23 55.34,26.17 54.62,26.89 v2(53.98,26.89)
  BOTTOM w0.254: PC710.1 59.91,21.37 60.04,21.49 v2(60.71,21.49)
REMOTE1+: length 128.4
  IN3 w0.254: v2(178.13,113.19) 177.68,113.63 177.68,120.13 176.64,121.18 176.64,122.87 174.89,124.62 170.82,124.62 168.33,127.12 168.33,127.37 166.89,128.81 156.9,128.81 154.34,131.37 144.2,131.37 143.58,131.99 v2(143.2,131.99)
  BOTTOM w0.254: C2500.1 141.43,130.71 Q2407.2 142.93,130.45 Q2407.1 143.58,131.6 v2(143.2,131.99) ; v2(178.13,113.19) 178.36,113.19 181.03,110.51 181.03,107.86 178.63,105.46 178.63,94.84 176.42,92.63 176.42,87.71 184.11,80.03 184.11,70.15 183.37,69.41 183.37,66.46 183.45,66.38 183.45,62.14 184.07,61.53 184.07,48.93 184.62,48.38 185.23,48.38 185.43,48.17 C2502.1 186.33,47.78 186.33,46.76 186.39,46.69 U2407.2
REMOTE1-: length 125.3
  IN3 w0.254: v2(142.5,131.99) 142.5,132.01 142.99,132.49 143.79,132.49 144.41,131.88 154.55,131.88 157.11,129.32 167.1,129.32 168.83,127.58 168.83,127.33 171.03,125.13 175.1,125.13 176.98,123.25 176.98,121.32 178.02,120.28 178.02,113.93 v2(178.13,113.82)
  BOTTOM w0.254: R184.1 C2502.2 185.43,49.09 185.23,48.88 184.83,48.88 184.58,49.14 184.58,61.74 183.96,62.35 183.96,66.59 183.88,66.67 183.88,69.2 184.62,69.94 184.62,80.24 176.93,87.92 176.93,92.42 179.14,94.63 179.14,105.25 181.54,107.65 181.54,110.73 178.44,113.82 v2(178.13,113.82) ; C2500.2 141.55,131.62 Q2407.3 142.27,131.75 v2(142.5,131.99)
REMOTE2+: length 184.7
  TOP w0.254: v2(275.44,127.03) 275.48,127.07 275.48,127.49 C2505.1 275.08,127.88 Q2408.2 275.73,129.55 Q2408.1
  IN3 w0.254: v2(213.05,65.45) 213.19,65.45 213.56,65.08 213.56,51.28 217.41,47.43 v2(217.41,46.97)
  IN4 w0.254: v2(213.05,65.45) 213.13,65.37 213.56,65.37 213.81,65.63 213.81,85.99 216.12,88.3 226.32,88.3 226.93,88.91 226.93,108.67 226.17,109.43 226.17,115.49 226.82,116.14 227.94,116.14 230.96,119.16 232.34,119.16 233.73,120.54 233.73,120.63 234.7,121.61 238.66,121.61 240.1,123.04 250.83,123.04 251.77,123.98 257.14,123.98 259.46,121.66 274.04,121.66 275.48,123.1 275.48,126.41 275.44,126.45 v2(275.44,127.03)
  IN6 w0.254: v2(190.64,49.68) 190.71,49.75 193.79,49.75 194.92,48.62 199.67,48.62 200.87,49.83 200.87,50.42 203.27,52.82 206.86,52.82 209.39,50.29 209.39,47.89 209.94,47.34 213.29,47.34 213.7,46.93 216.09,46.93 216.57,46.45 217,46.45 217.41,46.86 v2(217.41,46.97)
  BOTTOM w0.254: v2(190.64,49.68) 190.45,49.68 187.98,47.21 C2504.1 187.39,46.81 U2407.4
REMOTE2-: length 183
  TOP w0.254: v2(276.03,127.03) 275.99,127.07 275.99,127.49 C2505.2 276.38,127.88 Q2408.3
  IN3 w0.254: v2(216.8,46.98) 216.8,47.32 213.05,51.07 v2(213.05,64.87)
  IN4 w0.254: v2(213.05,64.87) 213.77,64.87 214.32,65.42 214.32,85.78 216.5,87.95 226.47,87.95 227.28,88.76 227.28,108.81 226.51,109.57 226.51,115.35 226.96,115.79 228.08,115.79 231.1,118.82 232.48,118.82 234.01,120.35 234.16,120.35 234.92,121.1 238.87,121.1 240.31,122.54 251.04,122.54 251.98,123.48 256.93,123.48 259.25,121.15 274.25,121.15 275.99,122.89 275.99,126.41 276.03,126.45 v2(276.03,127.03)
  IN6 w0.254: v2(190.64,50.26) 194,50.26 195.13,49.13 199.46,49.13 200.36,50.04 200.36,50.64 203.06,53.33 207.07,53.33 209.9,50.5 209.9,48.1 210.15,47.85 213.5,47.85 213.91,47.43 216.3,47.43 216.75,46.98 v2(216.8,46.98)
  BOTTOM w0.254: U2407.3 186.89,47.2 C2504.2 186.88,48.09 R184.2 188.22,48.17 190.31,50.26 v2(190.64,50.26)
REMOTE3+: length 123.9
  IN6 w0.254: v2(190.64,48.86) 190.7,48.8 194.03,48.8 194.71,48.11 199.9,48.11 201.38,49.6 201.38,50.21 203.48,52.31 206.65,52.31 208.88,50.08 208.88,47.45 209.5,46.83 213.06,46.83 213.47,46.42 215.88,46.42 216.39,45.9 225.02,45.9 226.33,44.6 228.4,44.6 228.98,44.02 228.98,43.89 229.66,43.2 233.02,43.2 233.63,43.81 238.26,43.81 238.94,43.12 239.48,43.12 240.56,42.04 246.73,42.04 248.74,44.05 265.95,44.05 273.71,36.29 282.02,36.29 283.1,35.21 285.23,35.21 285.87,35.85 285.87,37.1 v2(285.78,37.18)
  BOTTOM w0.254: U2407.5 187.89,45.23 C2510.1 189.38,43.74 190,43.74 190.25,43.99 190.25,45.56 189.49,46.32 189.49,47.86 190.5,48.86 v2(190.64,48.86) ; v2(285.78,37.18) 285.82,37.14 285.82,36.49 C2511.1 285.49,36.16 Q2411.2 286.14,34.37 Q2411.1
REMOTE3-: length 121.3
  IN6 w0.254: v2(190.64,48.28) 190.65,48.29 193.82,48.29 194.5,47.61 200.11,47.61 201.89,49.38 201.89,50 203.69,51.8 206.44,51.8 208.37,49.87 208.37,47.24 209.29,46.32 212.85,46.32 213.26,45.91 215.67,45.91 216.18,45.4 224.81,45.4 226.12,44.09 228.19,44.09 228.45,43.83 228.45,43.7 229.45,42.69 233.23,42.69 233.84,43.3 238.04,43.3 238.73,42.62 239.27,42.62 240.35,41.54 246.94,41.54 248.95,43.54 265.74,43.54 273.5,35.78 281.81,35.78 282.89,34.7 285.44,34.7 286.38,35.64 286.38,37.18 v2(286.37,37.18)
  BOTTOM w0.254: Q2411.3 286.79,36.03 C2511.2 286.33,36.49 286.33,37.14 v2(286.37,37.18) ; R185.2 C2510.2 189.38,43.23 190.21,43.23 190.76,43.78 190.76,45.77 190,46.53 190,47.64 v2(190.64,48.28)
RESET_N: length 2.6
  BOTTOM w0.076: UT4.F11 203.63,162.57
  BOTTOM w0.107: RT102.1 205.42,163.27 205.31,163.17 204.69,163.17 204.06,162.53 203.66,162.53 203.63,162.57
RF_+1VALWP: length 4.2
  TOP w0.102: v1(243.85,13.61) 243.85,14.24 PR306.1
  TOP w0.254: PU300.5 243.02,16.99 242.77,16.74 242.77,15.83 243.2,15.4 PR306.1
RING2: length 16.5
  TOP w0.102: v2(29.09,20.16) 29.09,19.16 v1(29.41,18.84)
  IN1 w1.016: 27.86,20.99 27.86,23.23 26.65,24.44 23.63,24.44 22.42,25.65 22.42,29.27 23.86,30.7 24.58,30.7
  vias: v2(26.15,31.08) v2(26.62,30.73) v2(28.45,20.17)
