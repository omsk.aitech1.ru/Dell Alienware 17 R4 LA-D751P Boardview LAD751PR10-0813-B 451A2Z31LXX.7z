# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RING2_R: length 32.8
  IN1 w1.016: 27.43,18.6 26.88,19.15 24.49,19.15 23,20.64 22.08,20.64 ; 16.91,18.15 16.86,18.1 16.86,13.61 17.1,13.37 17.1,5.06 14.74,2.7 6.69,2.7 5.67,3.72 JACK1.4
  vias: v1(27.56,19.21) v2(17.59,19.64) v2(17.59,18.99) v2(21.24,19.81) v2(21.83,19.81) v2(27.44,17.49) v2(28.01,17.75)
RJ45_CT:
  vias: v1(252.57,164.9) v2(262.39,165.07) v2(263.22,165.07)
RJ45_CT0: length 2.9
  TOP w0.127: v2(248.36,163.29) v1(248.36,162.55)
  TOP w0.508: RL12.1 v2(248.36,163.29)
  BOTTOM w0.508: v2(248.36,163.29) 248.38,163.31 TL1.15
RJ45_CT1: length 3.3
  TOP w0.127: v2(249.63,163.29) v1(250.81,163.29)
  TOP w0.508: RL11.1 v2(249.63,163.29)
  BOTTOM w0.508: TL1.16 249.65,163.31 v2(249.63,163.29)
RJ45_CT2: length 3.3
  TOP w0.127: v2(255.98,163.29) v1(254.78,163.29)
  TOP w0.508: RL10.1 v2(255.98,163.29)
  BOTTOM w0.508: v2(255.98,163.29) 256,163.31 TL1.21
RJ45_CT3: length 3
  TOP w0.127: v2(257.25,163.29) v1(257.25,162.47)
  TOP w0.508: RL9.1 257.18,163.35 v2(257.25,163.29)
  BOTTOM w0.508: TL1.22 257.27,163.31 v2(257.25,163.29)
RJ45_MDI0+: length 10.4
  BOTTOM w0.292: TL1.13 245.84,166.04 246.01,166.21 246.01,166.87 v1(246.21,167.07) 246.58,167.44 248.76,167.44 250.05,168.74 250.05,169.15 249.42,169.79 249.42,170.65 249.64,170.87 JLAN.1
RJ45_MDI0-: length 10.3
  BOTTOM w0.292: TL1.14 247.11,165.92 246.94,166.08 246.64,166.08 246.41,166.31 246.41,166.67 246.78,167.04 v1(248.94,167.04) 248.94,167.05 250.46,168.57 250.46,169.32 249.82,169.95 249.82,170.48 250.01,170.67 JLAN.2
RJ45_MDI1+: length 7.7
  TOP w0.292: JLAN.3 251.68,170.38 252.1,169.96 252.1,169.2 251.32,168.41 251.32,168.41 251.3,168.39 251.3,167.31 v2(251.21,167.23)
  BOTTOM w0.254: v2(251.21,167.23) 251.32,167.12 251.32,166.63 250.92,166.23 TL1.17
RJ45_MDI1-: length 7.7
  TOP w0.292: JLAN.6 254.15,170.67 251.72,168.24 251.72,167.3 v2(251.8,167.23)
  BOTTOM w0.254: TL1.18 252.19,166.26 251.75,166.69 251.75,167.18 v2(251.8,167.23)
RJ45_MDI2+: length 7.5
  BOTTOM w0.292: JLAN.4 252.92,170.89 253.17,170.89 253.4,170.66 253.4,169.98 253.64,169.74 253.64,168.93 254.32,168.25 254.32,167.54 254.3,167.53 254.3,166.7 253.46,165.86 TL1.19
RJ45_MDI2-: length 7.4
  BOTTOM w0.292: JLAN.5 253.81,171.68 253.81,170.15 254.05,169.91 254.05,169.09 254.72,168.42 v1(254.72,167.42) 254.72,166.51 TL1.20
RJ45_MDI3+: length 8.5
  TOP w0.292: JLAN.7 v1(255.76,168.58) 257.33,167.01 257.97,167.01 258.39,166.59 v2(258.39,166.4)
  BOTTOM w0.292: v2(258.39,166.4) 258.54,166.26 TL1.23
RJ45_MDI3-: length 8.5
  TOP w0.292: JLAN.8 256.62,170.67 256.17,170.21 256.17,168.75 257.5,167.42 258.14,167.42 259.04,166.52 v2(259.04,166.4)
  BOTTOM w0.292: v2(259.04,166.4) 259.1,166.47 259.6,166.47 259.81,166.26 TL1.24
ROM_CS#: length 30.7
  TOP w0.114: UG16.1 195.69,111.28 195.8,111.39 195.8,111.86 196.39,112.44 197.74,112.44 198.1,112.8 198.28,112.8 198.68,113.21 198.68,114.38 199.82,115.52 203.15,115.52 204.65,114.02 206.71,114.02 v2(207.37,113.35)
  IN6 w0.081: v2(207.37,113.35) 208.35,112.38 214.38,112.38 216.52,114.52 220.64,114.52 v2(220.77,114.65)
  BOTTOM w0.1: UG9.BJ4 v2(220.77,114.65)
ROM_SCLK: length 34
  TOP w0.114: v2(208.86,110.97) 210.01,112.12 213.83,112.12 v1(214.99,113.27) 216.37,114.66 219.38,114.66 v2(220.07,115.35)
  BOTTOM w0.1: UG9.BK3 v2(220.07,115.35)
  BOTTOM w0.114: v2(208.86,110.97) 206.83,113 206.83,115.04 206.71,115.15 202.31,115.15 201.65,114.48 201.65,113.27 RG86.1 201.32,112.52 RG148.2 200.4,111.18 199.87,110.65 199.87,108.64 199.53,108.3 199.53,107.46 RG89.2 RG75.2
ROM_SI: length 31
  IN6 w0.081: v2(219.36,115.36) 219.17,115.55 218.18,115.55 217.81,115.18 216.42,115.18 214.11,112.86 210.27,112.86 209.09,114.05 205.84,114.05 202.02,110.23 202.02,109.68 200.22,107.88 v2(200.22,107.66) 200.22,105.72 199.75,105.25 v2(199.75,104.74)
  BOTTOM w0.1: UG9.BK2 v2(219.36,115.36)
  BOTTOM w0.114: RG77.2 199.96,104.74 v2(199.75,104.74) ; RG149.2 RG87.2 RG84.1 200.35,108.5 200.35,107.79 v2(200.22,107.66)
ROM_SO: length 32.5
  TOP w0.114: UG16.4 195.8,109.78 196.05,109.53 196.05,108.49 196.33,108.21 198.67,108.21 v1(199.6,109.14) 200.57,110.1 RG85.1 RG88.2 200.57,112.01 201.86,113.3 205.03,113.3 206.38,111.95 207.77,111.95 v2(208.8,112.97)
  IN6 w0.081: v2(220.77,115.35) 220.18,114.76 216.46,114.76 214.29,112.59 209.18,112.59 v2(208.8,112.97)
  BOTTOM w0.1: UG9.BK4 v2(220.77,115.35)
RPD_G1: length 5.2
  BOTTOM w0.076: 203.35,166.22 203.27,166.22 202.67,165.63 202.67,165.57 202.41,165.3 202.41,165.17 202.41,165.17 202.41,164.96 202.41,164.96 202.41,164.95 202.16,164.7 UT4.K9
  BOTTOM w0.089: 203.35,166.22 203.71,166.59
  BOTTOM w0.102: v1(204.31,168.83) 204.31,167.56 203.91,167.15 RT64.1 203.84,166.72 203.71,166.59
RPD_G2: length 4.2
  BOTTOM w0.076: 203.66,165.65 203.51,165.65 203.34,165.48 203.22,165.48 202.91,165.17 202.91,164.89 202.66,164.64 UT4.K10
  BOTTOM w0.127: 203.66,165.65 203.78,165.77 204.45,165.77 v1(204.79,166.1) 205.1,166.41 205.1,167.1 RT65.1
RST#: length 4.2
  TOP w0.102: CE55.2 331.42,39.86 331.04,40.24 UE6.3 ; CE55.2 RE91.2 ; CE55.2 331.87,38.77 332.43,38.77 v1(332.71,39.05)
RT8812_PVCC: length 5
  BOTTOM w0.102: PC8200.1 247.97,35.01 v1(248.95,36)
  BOTTOM w0.203: PU8200.18 246.94,32.91 247.09,33.05 247.78,33.05 PR8200.1
  BOTTOM w0.254: PR8200.1 PC8200.1
RTD3_CIO_PWR_EN: length 188
  TOP w0.102: RT16.2 172.67,163.8 172.38,163.51 v2(171.71,163.51)
  IN2 w0.102: v2(171.71,163.51) 171.33,163.13 171.33,158.02 172.28,157.07 172.28,154.92 172.13,154.77 172.13,153.62 173.28,152.47 183.89,152.47 189.2,147.16 189.2,126.86 181.56,119.22 181.56,104.95 179.3,102.7 179.3,93.32 177.76,91.78 177.76,84.41 175.5,82.14 175.5,71.47 187.84,59.13 v2(191.26,59.13)
  IN3 w0.089: 197.66,42.08 197.66,41.52 198.5,40.68 198.5,39.86 199.07,39.29 200.4,39.29 200.94,38.76 200.94,37.49 201.43,36.99 201.43,34.38 200.9,33.86 200.9,32.9 200.45,32.44 200.45,28.63 201.25,27.83 201.25,24.09 201.7,23.64 202.35,23.64 203.16,22.83 203.84,22.83 205.56,21.11 207.97,21.11 208.16,20.92 208.16,20.38 209,19.54 209,19.54 209.71,18.83 211.09,18.83 v2(211.15,18.89)
  IN3 w0.102: v2(191.26,59.13) 191.02,58.88 191.02,57.14 191.89,56.27 191.89,52.88 197.66,47.12 197.66,42.08
  BOTTOM w0.089: v2(211.15,18.89) 211.34,18.69 UH1.AR44
RTD3_CIO_PWR_EN_R: length 6.6
  TOP w0.102: UT1.F1 175.71,167.54 175.67,167.5 175.46,167.5 174.81,166.85 174.81,166.8 v1(174.44,166.43) 173.85,165.83 173.19,165.83 172.86,165.49 172.86,164.92 RT16.1 172.2,165.2 171.74,165.2 RT36.1
RTD3_USB_PWR_EN: length 193.5
  TOP w0.102: v1(169.52,167.59) 169.31,167.38 RT12.2
  TOP w0.107: RT12.2 v2(168.77,166.19)
  IN2 w0.102: v2(193.21,58.28) 193.2,58.29 186.65,58.29 185.14,59.8 185.14,61.18 175.04,71.28 175.04,82.33 177.31,84.6 177.31,91.97 178.88,93.55 178.88,102.92 181.1,105.14 181.1,119.41 188.74,127.05 188.74,146.97 183.7,152.02 173.09,152.02 171.01,154.09 171.01,155.67 170.63,156.05 170.63,158.08 170.09,158.62 170.09,164.86 v2(168.77,166.19)
  IN3 w0.089: 198.82,42.08 199.27,41.62 200.54,41.62 200.98,41.18 200.98,40.22 202.71,38.49 202.71,36.75 203.11,36.36 203.11,32.5 201.34,30.73 201.34,29 202.14,28.2 202.14,25.59 203.13,24.6 203.85,24.6 205.05,23.4 205.05,23.21 205.48,22.78 208.14,22.78 208.97,21.94 209.56,21.94 210.03,21.47 210.42,21.47 210.84,21.05 211.51,21.05 v2(212.2,20.37)
  IN3 w0.102: v2(193.21,58.28) 193.2,58.28 193.04,58.12 193.04,54.3 196.26,51.07 196.26,50.13 198.8,47.59 198.8,42.09 198.82,42.08
  BOTTOM w0.107: UH1.AR41 211.64,19.81 v2(212.2,20.37)
RTD3_USB_PWR_EN_R: length 13
  TOP w0.102: UT1.D4 v2(177.39,168.37)
  TOP w0.107: v2(168.77,165.49) RT37.1 169.31,165.54 169.9,166.12 RT12.1
  IN1 w0.102: v2(168.77,165.49) 168.77,165.49 170.91,167.63 176.06,167.63 176.79,168.37 v2(177.39,168.37)
  BOTTOM w0.102: v4(169.88,165.91) 169.46,165.49 v2(168.77,165.49)
SATA_DET#: length 3.3
  TOP w0.356: v2(122.56,8.92) v1(123.34,8.92) 124,9.58 RS8.2
  BOTTOM w0.254: JHDD.19 122.42,9.07 v2(122.56,8.92)
SATA_GP0: length 42.7
  IN6 w0.102: v2(206.83,21.69) 207.08,21.94 208.16,21.94 208.61,21.5 208.61,19.99 210.08,18.51 212.73,18.51 214.64,20.42 216.04,20.42 217.5,18.96 218.7,18.96 221.12,16.54 226.13,16.54 226.61,17.02 230.97,17.02 231.48,16.51 232.85,16.51 233.37,17.03 233.37,17.18 v2(233.38,17.18)
  BOTTOM w0.089: v2(206.83,21.69) 206.89,21.69 207.16,21.95 UH1.AG36
  BOTTOM w0.102: v2(233.38,17.18) v1(233.83,17.63) 235.19,18.98 R364.1 235.47,18.99 235.47,18.57 237.02,17.02 JSSD3.69
SATA_GP1: length 140.4
  TOP w0.102: v1(328.34,32.22) 327.84,31.73 R363.1 327.38,31.26 v2(327.22,31.11)
  IN1 w0.097: 296.23,20.8 298.4,22.96 301.05,22.96 302.08,21.94
  IN1 w0.102: v2(327.22,31.11) 325.36,29.24 319.16,29.24 316.96,27.04 313.33,27.04 312.16,25.88 312.16,23.83 310.27,21.94 302.08,21.94 ; v2(266.01,24.21) 266.23,24.21 267.01,24.99 271.02,24.99 273.04,22.96 279.92,22.96 282.09,20.8 296.23,20.8
  IN3 w0.089: v2(207.83,23.14) 208.42,23.14 208.9,22.67 209.47,22.67 210.91,21.23 211.58,21.23 211.82,21.47 212.32,21.47 212.64,21.15 212.64,19.62 212.9,19.36 213.53,19.36 215.43,21.26 217.16,21.26 217.59,21.69
  IN3 w0.102: v2(266.01,24.21) 264.75,25.47 260.76,25.47 260.18,26.04 258.23,26.04 257.71,26.56 257.44,26.83 247.81,26.83 244.13,23.15 239.9,23.15 236.09,19.34 230.13,19.34 229.19,20.28 226.39,20.28 226.04,20.63 223.12,20.63 222.07,21.69 217.59,21.69
  BOTTOM w0.089: UH1.AG35 207.4,22.71 v2(207.83,23.14)
  BOTTOM w0.107: v2(327.22,31.11) JSSD1.69
SATA_GP3: length 170.4
  TOP w0.102: v1(233.16,16.72) 233.57,16.72 v2(233.96,17.11)
  IN6 w0.102: v2(233.96,17.11) 233.89,17.11 233.51,16.73 233.43,16.73 233.17,16.46 233.13,16.46 232.95,16.28 231.38,16.28 230.98,16.69 226.87,16.69 226.45,16.28 220.76,16.28 218.53,18.51 216.21,18.51 215.58,17.88 213.77,17.88 213.32,18.32 210,18.32 208.42,19.91 208.42,20.86 208.16,21.11 206.7,21.11 206.32,21.5 206.32,22.64 v2(206.83,23.15) 206.13,23.84 205.3,23.84 203.73,25.42 202.8,25.42 201.21,27.01 192.67,27.01 191.79,27.89 184.9,27.89 182.76,25.75 182.76,23.84 179.9,20.99 159.58,20.99 156.77,18.18 128.78,18.18 125.78,15.18 122.68,15.18 v2(120.4,12.89)
  BOTTOM w0.089: v2(206.83,23.15) 206.39,22.71 UH1.AD35
  BOTTOM w0.102: RS2.1 96.08,12.73 97.54,11.27 102.43,11.27 103.7,12.54 103.7,13.2 105.38,14.88 105.38,15.65 106.04,16.31 117.27,16.31 120.4,13.18 v2(120.4,12.89) 121.19,12.11 121.19,10.83 120.92,10.56 JHDD.16 ; v2(233.96,17.11) 233.96,17.11 234.37,17.11 234.86,17.6 RS3.1
SATA_GP4: length 103.5
  TOP w0.102: v1(274.01,6.19) R365.1
  TOP w0.107: R365.1 v2(273.19,7.27)
  IN2 w0.102: v2(206.73,24.61) 207.18,24.16 208.87,24.16 208.94,24.23 209.94,24.23 211.57,25.86 215.51,25.86 216.35,26.7 217.58,26.7 217.9,26.38 221.68,26.38 223.9,24.17 223.9,23.2 224.78,22.33 224.78,21.8 226.48,20.1 226.48,19.3 227.53,18.24 228.04,18.24 230.46,15.83 234.13,15.83 234.45,16.15 245.55,16.15 247.74,18.34 247.74,19.46 246.63,20.56 246.63,22.41 248.24,24.02 255.95,24.02 256.49,23.48 256.49,22.98 259.69,19.78 264.53,19.78 265.89,18.43 267.56,18.43 267.66,18.32 272.94,18.32 v2(274.75,16.52)
  BOTTOM w0.089: v2(206.73,24.61) 206.55,24.79 UH1.AD31
  BOTTOM w0.102: v2(273.19,7.27) 276.42,7.27 277.19,8.03 277.19,8.65 274.78,11.06 274.78,16.49 v2(274.75,16.52)
  BOTTOM w0.107: v2(273.19,7.27) 273.17,7.26 JSSD2.69
SATA_PRX_DTX_N3: length 106.6
  IN3 w0.089: 193.27,17.17 193.29,17.17 193.31,17.19 194.39,17.19 195.22,18.02 196.2,18.02 196.48,18.3 196.48,18.55 196.57,18.64 v2(196.8,18.64)
  IN3 w0.127: v2(106.46,13.43) 106.47,13.43 106.6,13.3 106.6,12.77 106.89,12.48 109.79,12.48 113.96,16.65 135.15,16.65 135.95,17.44 184,17.44 184.61,16.83 192.12,16.83 192.46,17.17 193.27,17.17
  BOTTOM w0.099: v2(196.8,18.64) 196.43,18.64 UH1.D43
  BOTTOM w0.107: v2(106.46,13.43) 106.59,13.3 106.59,12.51 106.56,12.48 106.56,11.55 106.53,11.52 106.53,10.95 106.56,10.92 106.56,10.76 107.07,10.26 109.48,10.26 110.37,11.14 113.58,11.14 113.72,11.01 113.72,10.76 113.42,10.47 JHDD.1
SATA_PRX_DTX_P3: length 106.6
  IN3 w0.089: 193.27,17.39 193.29,17.39 193.31,17.37 194.32,17.37 195.14,18.19 196.12,18.19 196.3,18.37 196.3,18.65 196.59,18.94 196.59,18.94 v2(196.86,19.21)
  IN3 w0.127: v2(107.07,13.43) 107.04,13.43 106.82,13.21 106.82,12.86 106.98,12.7 109.7,12.7 113.87,16.86 135.06,16.86 135.86,17.66 184.09,17.66 184.7,17.05 192.03,17.05 192.37,17.39 193.27,17.39
  BOTTOM w0.099: UH1.E42 196.45,19.25 196.55,19.35 196.72,19.35 v2(196.86,19.21)
  BOTTOM w0.107: JHDD.2 113.92,11.09 113.66,11.35 110.29,11.35 109.4,10.46 107.15,10.46 106.77,10.85 v3(106.77,11.23) 106.77,12.39 106.79,12.42 106.79,13.19 107.04,13.43 v2(107.07,13.43)
SATA_PTX_DRX_N3: length 102.7
  IN3 w0.127: v2(193.79,19.64) 188.85,19.64 188.41,19.21 184.23,19.21 183.91,18.9 135.34,18.9 134.55,18.1 112.69,18.1 109.33,14.74 107.68,14.74 107.41,15.01 107.41,15.33 v2(107.25,15.49)
  BOTTOM w0.107: v2(107.25,15.49) 107.25,14.58 107.57,14.26 107.57,12.67 108.28,11.96 114.43,11.96 115.22,11.17 115.22,10.93 114.92,10.63 JHDD.4 ; UH1.A41 194.62,19.78 193.93,19.78 v2(193.79,19.64)
SATA_PTX_DRX_P3: length 102.8
  IN3 w0.127: v2(107.84,15.49) 107.63,15.28 107.63,15.1 107.77,14.95 109.24,14.95 112.6,18.32 134.46,18.32 135.25,19.11 183.82,19.11 184.14,19.43 188.32,19.43 188.76,19.86 193.36,19.86 193.36,19.86 193.47,19.86 193.81,20.2 v2(193.81,20.29)
  BOTTOM w0.107: v2(193.81,20.29) 193.81,20.25 194.08,19.98 194.59,19.98 UH1.A40 ; v2(107.84,15.49) 107.83,15.49 107.46,15.11 107.46,14.66 107.66,14.46 107.67,14.46 107.78,14.36 107.78,12.75 108.37,12.16 114.51,12.16 115.42,11.25 JHDD.5
SERIRQ: length 130.6
  TOP w0.102: v2(301.81,15.53) 301.27,16.06 301.27,17.42 302.2,18.35 303,18.35 303.23,18.58 303.23,20.54 304.74,22.05 UE5.3
  IN2 w0.102: v2(214.45,32.17) 216.05,30.58 218.4,30.58 218.97,30 219.54,30 220.05,29.49 221.83,29.49 225.24,26.08 225.24,24.91 225.46,24.69 225.46,22.94 225.57,22.84 226.2,22.84 227.48,21.56 227.48,19.59 227.91,19.16 228.42,19.16 229.54,18.04 234.66,18.04 235.64,17.07 245.04,17.07 246.21,18.23 246.21,19.65 245.72,20.14 245.72,22.79 247.86,24.94 256.33,24.94 257.4,23.86 257.4,23.36 259.85,20.91 268.24,20.91 269.33,19.82 271.57,19.82 271.9,19.49 275.62,19.49 280,15.11 294.87,15.11 295.09,15.32 296.2,15.32 296.76,14.76 301.04,14.76 v2(301.81,15.53)
  BOTTOM w0.089: 219.18,28.48 218.74,28.48 v1(218.41,28.81) 218.41,29.86 217.69,30.59 217.69,31.15 217.4,31.44 216.53,31.44 216.12,31.03 216.12,30.84 216,30.72 215.16,30.72 215.04,30.85 215.04,30.93 214.51,31.46 UH1.BA17 214.46,31.6 214.46,32.17 v2(214.45,32.17)
  BOTTOM w0.107: RH111.1 221.86,28.88 221.28,28.88 220.88,28.48 219.18,28.48
SLEEVE: length 10.7
  IN1 w1.016: 28.62,30.95 28.62,26.78 31.48,23.93 31.48,22.74 30.55,21.81
  vias: v1(28.53,20.68) v2(27.09,31.11) v2(27.69,31.11) v2(29.28,21.81) v2(29.28,21.18)
SLEEVE_R: length 33.1
  TOP w0.102: v2(30.23,20.99) v1(30.23,20.43)
  IN3 w1.016: 20.38,19.02 20.38,20.16 20.93,20.71 22.24,20.71 22.31,20.64 23.15,20.64 24.58,19.21 29.25,19.21 ; JACK1.3 8.27,3.45 8.99,2.74 14.65,2.74 17.09,5.18 17.09,15.84
  vias: v2(17.73,17.06) v2(17.73,16.48) v2(20.2,18.12) v2(20.79,18.1) v2(30.87,20.99)
SLP_S3: length 66
  TOP w0.114: RE15.2 290.82,27.29 v1(290.82,25.81) 290.82,24.94 293.11,22.66 293.53,22.66 294.47,21.72 294.47,19.23 294.61,19.09 v2(294.61,16.05) ; QE1.3 323.97,40.74 v2(323.39,40.16) ; v2(314.14,16.35) 313.32,15.53 UE1.26
  IN1 w0.081: v2(314.14,16.35) 312.75,14.95 307.67,14.95 307.13,15.49 304.3,15.49 303.83,15.02 296.55,15.02 295.79,15.78 295.09,15.78 294.83,16.05 v2(294.61,16.05)
  IN3 w0.127: v2(314.14,16.35) 314.91,17.11 315.16,17.11 316.77,18.73 316.77,22.31 316.44,22.64 316.44,27.05 317.29,27.9 317.29,29.72 323.92,36.35 323.92,39.4 323.39,39.93 v2(323.39,40.16)
SLP_S5: length 32.5
  TOP w0.114: v2(322.27,44.36) 322.64,44.72 QE4.3 322.64,45.34 RE16.2 ; v2(315.72,19.2) 316.2,18.72 UE1.21
  IN3 w0.127: v2(315.72,19.2) 315.67,19.25 315.67,21.93 315.55,22.04 315.55,29.24 323.03,36.72 323.03,38.38 322.56,38.85 322.56,42.12 322.22,42.46 322.22,44.31 v2(322.27,44.36)
SM_PG_CTRL: length 52.7
  TOP w0.102: v2(97.42,47.91) 100.28,47.91 102.46,45.73
  TOP w0.127: 102.46,45.73 103.09,45.73 109.48,52.11 109.48,57.56 116.34,64.42 116.34,74.15 117.04,74.84 v1(122.59,74.84) RH525.2 124.85,75.4 124.85,76.18 124.28,76.75 UC1.4
  BOTTOM w0.254: v2(97.42,47.91) 96.85,47.34 PR211.2
SML0CLK: length 230.7
  TOP w0.089: v2(214.77,19.25) 214.9,19.12 214.9,18.82 215.46,18.26 RH501.2
  IN1 w0.081: v2(214.77,19.25) 214.77,19.35 214.55,19.57 213.81,19.57 212.55,18.31 210.39,18.31 209.61,19.1 208.5,19.1 208.25,18.84 207.54,18.84 207.23,19.15 207.23,29.83 206.9,30.17 203.86,30.17 202.71,31.32 202.71,35.88 202.1,36.49 202.1,36.8 200.07,38.84 198.84,38.84 197.24,37.23 197.24,36.03 196.77,35.56 195.28,35.56 194.69,34.97 193.48,34.97 192.55,35.9 192.39,35.9 191.52,36.76 191.52,40.86 188.92,43.47 188.92,61.59 185.63,64.87 185.63,67.16 185.13,67.66 185.13,85.76 187.33,87.96 187.33,92.63 184.28,95.69 184.28,111.52 186.84,114.08 186.84,121.08 188.65,122.89 188.65,131.31 191.76,134.42 192.69,134.42 193.48,135.21 193.48,144.21 193.39,144.29 193.21,144.29 v2(193.02,144.1) 192.77,144.35 192.58,144.35 192.38,144.55 192.38,146.85 189.98,149.25 189.98,150.73 187.5,153.22 169.89,153.22 167.01,156.1 166.35,156.1 166.27,156.02 166.27,155.49 166.37,155.39 166.55,155.39 166.64,155.31 v2(166.64,155.14)
  BOTTOM w0.089: v2(214.77,19.25) 214.77,19.09 214.27,18.59 UH1.AY44
  BOTTOM w0.114: v2(193.02,144.1) 193.17,144.25 193.73,144.25 195.54,142.45 205.15,142.45 206.25,141.34 206.25,140.27 206.98,139.54 207.77,139.54 208.42,138.89 v3(208.42,136.4) 208.42,134.65 207.83,134.07 206.21,134.07 RV632.1 ; UM4.11 165.34,157.33 165.52,157.16 166.2,157.16 166.52,156.83 166.52,155.26 v2(166.64,155.14)
SML0DATA: length 231
  TOP w0.089: RH502.2 215.12,19.69 v2(214.88,19.94)
  IN1 w0.081: v2(166.05,155.14) 166.06,155.15 166.06,156.1 166.26,156.3 167.09,156.3 169.97,153.43 187.58,153.43 190.19,150.82 190.19,149.33 192.59,146.93 192.59,144.63 192.67,144.56 192.89,144.56 v2(193.02,144.69) 193.21,144.5 193.48,144.5 193.68,144.29 193.68,135.12 192.77,134.21 191.84,134.21 188.86,131.22 188.86,122.8 187.05,120.99 187.05,114 184.49,111.44 184.49,95.77 187.54,92.72 187.54,87.87 185.34,85.67 185.34,67.75 185.84,67.25 185.84,64.96 189.13,61.68 189.13,43.56 191.73,40.95 191.73,36.84 192.47,36.1 192.64,36.1 193.42,35.33 193.42,35.27 193.55,35.14 194.62,35.14 195.21,35.73 196.7,35.73 197.07,36.1 197.07,37.3 197.61,37.85 198.77,39.01 200.14,39.01 202.27,36.87 202.27,36.56 202.88,35.95 202.88,31.39 203.93,30.34 206.97,30.34 207.4,29.9 207.4,19.22 207.61,19.01 208.18,19.01 208.43,19.27 209.68,19.27 210.46,18.49 212.48,18.49 213.74,19.74 214.68,19.74 v2(214.88,19.94)
  BOTTOM w0.089: v2(214.88,19.94) 214.96,19.86 215.25,19.86 215.34,19.95 215.34,20.2 215.14,20.4 UH1.BB39
  BOTTOM w0.114: UM4.10 165.34,156.8 165.45,156.92 166.1,156.92 166.28,156.73 166.28,155.35 166.07,155.14 v2(166.05,155.14) ; RV633.1 206.21,133.83 207.93,133.83 208.66,134.55 208.66,138.99 207.87,139.78 207.08,139.78 206.49,140.37 206.49,141.44 205.25,142.69 195.64,142.69 193.83,144.49 193.21,144.49 v2(193.02,144.69)
SML1CLK: length 10.1
  TOP w0.114: RH460.2 209.38,13.57 209.38,14.3 v2(209.31,14.37) 209.76,14.83 210.45,14.83 210.95,15.33 211,15.33 211.57,15.9 211.57,16.24 212.66,17.32 212.66,17.97 212.89,18.21 213.02,18.21 v2(213.57,18.76)
  BOTTOM w0.089: UH1.AW42 213.39,18.95 v2(213.57,18.76)
  BOTTOM w0.114: QH5.6 209.01,15.48 209.26,15.23 209.26,14.43 v2(209.31,14.37)
SML1DATA: length 8.8
  TOP w0.114: RH461.2 209.62,13.66 209.62,14.11 v2(209.89,14.37) 210.1,14.59 210.55,14.59 211.77,15.81 211.77,16.15 212.86,17.24 212.86,17.89 212.98,18 213.31,18 213.44,17.87 v2(213.44,17.32)
  BOTTOM w0.089: UH1.AW45 213.46,17.35 v2(213.44,17.32)
  BOTTOM w0.114: v2(209.89,14.37) 210.09,14.18 QH5.3
SNB_1.0VS_VGAP: length 1
  BOTTOM w0.102: PC802.1 v1(247.8,46.31)
SNB_+1.8VGS: length 1
  BOTTOM w0.254: PC806.1 234.25,43.85 PR809.2
SNB_VCCIO: length 3.9
  BOTTOM w0.102: v1(119.9,108.53) 119.48,108.11 PC591.1
  BOTTOM w0.508: PC591.1 118.37,108.18 PR5009.2
SNUB_CHG: length 2.3
  TOP w0.102: v1(66.44,18.04) 66.35,18.04 64.8,19.59
SPEAKER_SEL: length 374.3
  TOP w0.102: v2(316.49,54.9) 316.76,55.16 UE10.2 ; v2(43.32,15.59) v1(43.32,14.69)
  IN3 w0.102: v2(316.49,54.9) 316.49,51.37 320.4,47.47 334.37,47.47 335.91,45.93 335.91,17.9 331.16,13.15 325.42,13.15 324.81,12.54 323.1,12.54 322.27,11.72 322.27,9.05 321.64,8.41 316.91,8.41 v2(316.37,7.87)
  IN6 w0.102: v2(43.32,15.59) 43.8,16.07 48.88,16.07 50.14,14.81 54.77,14.81 57.85,11.73 103.89,11.73 110.19,5.43 172.28,5.43 177.26,10.41 181.28,10.41 186.27,5.42 186.41,5.28 250.62,5.28 256.2,10.87 279.39,10.87 282.39,7.87 294.31,7.87 297.79,11.35 301.04,11.35 302.22,10.17 304.83,10.17 307.13,7.87 v2(316.37,7.87)
  BOTTOM w0.102: 47.03,15.56 47.18,15.41 JSPK.5
  BOTTOM w0.107: v2(43.32,15.59) 43.95,16.22 46.36,16.22 47.03,15.56
SPI_MOCLK: length 234
  TOP w0.114: v2(313.5,6.83) 314.14,6.83 314.74,7.42 CE57.1 314.74,8 314.6,8.14 UE1.2
  IN1 w0.081: v2(129.29,22.47) 130.35,23.53 174.79,23.53 186.81,11.5 192.31,11.5 193.02,10.8 201.27,10.8 201.36,10.89 206.05,10.89 206.21,11.05 206.22,11.05 206.69,11.52 211.87,11.52 212.19,11.85 228.65,11.85 229.05,12.24 239.5,12.24 241.96,14.7 245.52,14.7 246.11,14.1 248.01,14.1 248.92,15.01 254.42,15.01 256.11,13.32 264.52,13.32 266.11,14.91 269.71,14.91 270.54,15.74 271.9,15.74 273.08,16.92 279.15,16.92 279.57,16.5 291.47,16.5 293.69,14.28 296.06,14.28 296.97,13.37 299.39,13.37 301.45,11.31 301.45,10.73 302.66,9.52 305.96,9.52 307.6,7.88 312.44,7.88 v2(313.5,6.83)
  IN6 w0.081: v2(129.29,22.47) 124.72,22.47 122.93,24.26 109.07,24.26 107.01,26.32 100.97,26.32 v2(100.14,27.15)
  BOTTOM w0.114: RE11.2 v2(100.14,27.15)
SPI_MOCS#: length 235.6
  TOP w0.114: UE1.31 313.58,11.53 313.7,11.65 314.21,11.65 v2(314.71,11.14)
  IN6 w0.081: v2(103.63,15.4) 104.28,14.75 109.74,14.75 114.51,9.98 122.7,9.98 129.36,16.64 157.13,16.64 158.24,17.75 178.32,17.75 186.83,9.24 192.86,9.24 193.79,8.3 206.04,8.3 207.13,9.39 211.79,9.39 212.67,10.27 230.48,10.27 234.2,6.55 235.36,6.55 235.95,7.14 237.12,7.14 237.72,6.55 250.1,6.55 251.6,8.05 251.6,11.66 253.83,13.89 264.95,13.89 265.73,14.66 269.41,14.66 270.19,13.89 292.48,13.89 293.92,12.45 303.95,12.45 304.72,13.22 312.64,13.22 v2(314.71,11.14)
  BOTTOM w0.114: RE12.2 103.42,15.2 v2(103.63,15.4) UE2.1
SPI_MOSI: length 255.1
  TOP w0.114: UE1.32 313.6,10.73 v2(314.02,11.14)
  IN6 w0.081: v2(94.51,15.72) 94.63,15.84 102.2,15.84 103.49,14.54 109.65,14.54 114.43,9.77 122.79,9.77 129.45,16.43 157.21,16.43 158.32,17.54 178.22,17.54 186.73,9.03 192.77,9.03 193.71,8.1 206.13,8.1 207.21,9.18 211.88,9.18 212.75,10.06 230.39,10.06 234.11,6.34 235.44,6.34 236.03,6.93 237.05,6.93 237.63,6.34 250.18,6.34 251.81,7.97 251.81,11.57 253.92,13.68 265.46,13.68 266.23,14.45 269.33,14.45 270.1,13.68 292.4,13.68 293.83,12.24 304.06,12.24 304.83,13.01 312.15,13.01 v2(314.02,11.14)
  BOTTOM w0.114: RE9.2 98.37,25.62 98.37,23.72 98,23.35 98,21.43 97.42,20.85 95.72,20.85 94.51,19.64 v2(94.51,15.72)
SPI_MOSO: length 239.4
  TOP w0.114: UE1.1 313.8,7.81 v2(312.81,6.83)
  IN1 w0.081: v2(130.18,22.23) 131.02,23.06 174.42,23.06 186.45,11.04 192.12,11.04 192.82,10.33 201.46,10.33 201.55,10.42 206.24,10.42 206.4,10.58 206.41,10.58 206.89,11.06 212.06,11.06 212.38,11.38 228.84,11.38 229.24,11.78 239.7,11.78 241.56,13.64 255.14,13.64 255.92,12.86 264.71,12.86 266.3,14.44 269.9,14.44 270.66,15.21 272.16,15.21 272.82,15.87 291.45,15.87 293.5,13.82 295.83,13.82 296.86,12.8 299.3,12.8 300.91,11.18 300.91,10.57 302.49,9 305.79,9 307.37,7.41 312.23,7.41 v2(312.81,6.83)
  IN6 w0.081: v2(130.18,22.23) 129.29,21.33 114.21,21.33 111.83,18.96 102.43,18.96 v2(101.93,18.45)
  BOTTOM w0.114: v2(101.93,18.45) 98.62,18.45 98.24,18.07 98.24,14.72 99.12,13.84 101.55,13.84 RE10.2
SPK_L+_CONN: length 26.7
  IN1 w1.016: 36.09,6.14 37.11,6.14 38.86,7.89 41.21,7.89 42.62,9.3 42.62,11.65 43.54,12.57
  IN3 w1.016: 30.43,15.84 30.43,15.08 32.14,13.37 36.46,13.37 37.6,12.22 37.6,7.27 36.78,6.45
  vias: v1(44.74,13.05) v2(29.78,16.93) v2(30.37,16.93) v2(36.01,5.24) v2(36.46,4.86) v2(44.65,12.48) v2(45.28,12.48) v2(47.89,12.48) v2(48.48,12.48)
SPK_L-_CONN: length 29.8
  TOP w0.102: v2(45.54,10.76) v1(44.41,10.76)
  IN1 w1.016: 39.06,4.99 40.33,6.26 42.81,6.26 43.95,7.4 43.95,10.74
  IN3 w1.016: 38.74,4.6 41.16,7.02 41.16,9.18 40.2,10.13 40.2,14.13 38.61,15.72 32.39,15.72
  vias: v2(32.13,16.99) v2(32.72,16.99) v2(39.31,3.85) v2(39.31,3.21) v2(45.54,11.4) v2(47.82,10.67) v2(48.46,10.67)
SPK_R+_CONN: length 24.8
  IN3 w1.016: 27.76,4.54 28.71,5.49 28.71,7.65 28.46,7.91 28.46,10.19 28.01,10.64
  IN4 w1.016: 27.76,4.6 29.6,6.45 31.5,6.45 31.82,6.13 37.28,6.13 39.06,7.91 41.35,7.91 41.54,8.1 44.01,8.1
  vias: v1(28.32,3.23) v2(27.06,11.78) v2(27.06,11.14) v2(27.06,3.84) v2(27.69,3.84) v2(44.97,7.97) v2(45.47,8.35) v2(47.86,8.44) v2(48.49,8.44)
SPK_R-_CONN: length 28.1
  TOP w0.102: v2(45.53,6.24) v1(44.74,6.24)
  IN3 w1.016: 28.01,13.81 28.01,13.11 30.49,10.64 30.49,7.53 30.04,7.08 30.04,5.05 30.17,4.92 30.17,3.52
  IN4 w1.016: 30.49,2.32 32.58,2.32 33.32,3.05 35.33,3.05 35.99,3.72 37.73,3.72 40.22,6.2 44.59,6.2
  vias: v2(27.06,14.32) v2(27.06,13.68) v2(28.94,1.62) v2(29.54,1.62) v2(45.51,6.84) v2(47.86,6.4) v2(48.49,6.4)
SS: length 10.2
  TOP w0.254: v2(271.5,139.83) 271.19,140.14 267.32,140.14 266.84,140.62 v1(266.56,140.62) v2(265.76,140.62)
  BOTTOM w0.203: PC6017.1 271.07,139.83 v2(271.5,139.83) 271.63,139.83 272.19,139.27 PU6000.28
  BOTTOM w0.254: PR6015.2 PC6002.2 v2(265.76,140.62)
STRAP0: length 18.9
  TOP w0.102: RG90.2 RG78.1 206.71,109.51 209.81,112.6 213.63,112.6 216.06,115.03 v1(216.86,115.03) 217.62,115.03 218.39,115.79 219.77,115.79 v2(220.05,116.07)
  BOTTOM w0.1: UG9.BL3 v2(220.05,116.07)
STRAP1: length 20.2
  TOP w0.102: RG79.1 205.25,110.65 RG91.2 204.81,111.47 208.35,111.47 209.71,112.83 213.54,112.83 216.04,115.34 217.49,115.34 v1(218.32,116.17) 218.77,116.62 219.5,116.62 219.63,116.49 220.33,116.49 v2(220.77,116.05)
  BOTTOM w0.1: UG9.BL4 v2(220.77,116.05)
STRAP2: length 7.4
  IN1 w0.089: v2(216.1,116.43) 217.27,117.6 219.92,117.6 v2(220.74,116.78)
  BOTTOM w0.089: v2(216.1,116.43) RG92.2 RG80.1
  BOTTOM w0.1: UG9.BM4 v2(220.74,116.78)
STRAP3: length 121.3
  TOP w0.102: v2(179.6,71.23) 179.59,71.24 179.59,71.84 v1(179.54,71.88) ; v2(201.43,110.97) 201.43,109.75 201.61,109.57 RG81.1 RG93.2
  IN4 w0.102: v2(179.6,71.23) 179.18,70.81 179.18,70.29 179.35,70.12 179.35,59.49 180.89,57.95 180.89,55.5 186.24,50.14 186.24,36.47 185.53,35.76 185.53,35.17 v2(185.94,34.77)
  IN6 w0.089: 215.02,115.35 215.6,115.93 216.21,115.93 217.15,116.87 217.79,116.87 218.35,117.43 220.79,117.43 v2(221.44,116.78)
  IN6 w0.102: v2(179.6,71.23) 179.6,72.25 181.2,73.85 181.8,73.85 182.41,74.47 182.9,74.47 185.06,76.63 185.06,92.7 184.71,93.06 184.71,99.09 188.28,102.67 188.54,102.67 191.37,105.51 196.22,105.51 197.68,106.97 198.63,106.97 201.11,109.45 201.11,110.65 v2(201.43,110.97) 201.43,111.16 204.85,114.57 209.29,114.57 209.76,114.1 211.72,114.1 212.44,114.81 214.49,114.81 215.02,115.35
  BOTTOM w0.089: UG9.BM5 v2(221.44,116.78)
  BOTTOM w0.102: DG8.2 186.32,34.39 v2(185.94,34.77)
STRAP3_PCH: length 28.2
  IN4 w0.102: v2(199.9,19.76) 200.41,20.28 200.41,26.81 197.87,29.35 197.87,30.18 196.78,31.27 192.23,31.27 192.19,31.24 187.88,31.24 187.14,31.97 187.14,32.73 v2(187.78,33.37)
  BOTTOM w0.089: v2(199.9,19.76) 199.65,19.52 199.65,19.15 199.36,18.85 UH1.L43
  BOTTOM w0.102: RG555.2 188.26,34.42 DG8.1 188.22,33.82 v2(187.78,33.37)
STRAP4: length 28.4
  TOP w0.102: v1(202.47,112.6) 202.12,112.6 v2(201.81,112.3) 201.93,112.19 RG94.2 RG82.1
  IN6 w0.102: v2(221.47,115.35) 221.84,115.72 221.84,116.91 221.09,117.66 217.78,117.66 217.31,117.19 213.45,117.19 212.39,116.13 212.39,115.13 211.69,114.42 210.05,114.42 209.6,114.87 204.38,114.87 v2(201.81,112.3)
  BOTTOM w0.1: UG9.BK5 v2(221.47,115.35)
STRAP5: length 122.5
  TOP w0.089: RG95.2 221.47,114.73 v2(221.43,114.69) 221,114.26 220.58,114.26 220.39,114.45 218.23,114.45 RG83.1
  TOP w0.102: v2(179.6,70.63) 179.6,70.63 179.6,70.62 179.6,70.04 v1(179.55,70)
  IN4 w0.102: v2(185.94,35.47) 186.47,36 186.47,50.24 181.12,55.59 181.12,58.09 179.6,59.61 179.6,70.62 179.6,70.63 v2(179.6,70.63)
  IN6 w0.081: 214.64,111.86 215.02,112.24
  IN6 w0.102: 215.02,112.24 216.99,112.24 218.02,113.27 220.01,113.27 v2(221.43,114.69) ; v2(179.6,70.63) 179.68,70.63 182.1,73.05 182.1,73.51 182.6,74.01 183.09,74.01 185.54,76.47 185.54,92.9 185.25,93.19 185.25,98.74 185.72,99.21 185.72,99.35 187.24,100.87 188.54,100.87 189.25,101.58 189.25,102.73 191.57,105.05 196.3,105.05 197.96,103.38 200.02,103.38 203.65,107.02 203.65,107.74 207.77,111.86 214.64,111.86
  BOTTOM w0.089: UG9.BJ5 v2(221.43,114.69)
  BOTTOM w0.102: v2(185.94,35.47) 185.94,36.55 186.19,36.8 DG9.2
STRAP5_PCH: length 29.7
  IN4 w0.102: v2(188.67,32.54) 189.68,31.53 196.8,31.53 198.07,30.26 198.07,29.43 200.61,26.89 200.61,19.54 v2(199.87,18.81)
  BOTTOM w0.089: UH1.L44 199.36,18.29 v2(199.87,18.81)
  BOTTOM w0.102: RG556.2 188.22,35.95 DG9.1 188.35,36.8 189.05,36.1 189.05,32.93 v2(188.67,32.54)
SUSACK#: length 115.7
  TOP w0.114: v2(298.99,17.94) 298.82,17.77 298.82,16.35 299.37,15.8 299.37,15.06 300.17,14.26 300.17,12.67 302.78,10.07 305.32,10.07 305.57,9.81 UE5.97
  IN6 w0.081: 219.18,28.84 219.29,28.84 221.88,26.24 221.88,25.91 224.91,22.89 224.91,21.01 226.76,19.16 228.29,19.16 228.68,19.55 231.4,19.55 232.54,18.41 235.11,18.41 235.76,17.77 243.52,17.77 244.72,18.96 244.72,22.02 248.13,25.42 251.79,25.42 252.73,26.36 256.81,26.36 257.74,25.43 260.15,25.43 260.69,24.89 260.69,21.72 261.7,20.71 268.81,20.71 269.72,19.8 271.66,19.8 273.1,18.36 298.57,18.36 v2(298.99,17.94)
  IN6 w0.089: v2(216.87,29.74) 217.06,29.55 217.06,29.45 217.67,28.84 219.18,28.84
  BOTTOM w0.089: v2(216.87,29.74) 216.55,30.06 215.41,30.06 215.11,30.36 UH1.BB19
SUSCLK: length 199.3
  IN6 w0.081: v2(299.24,16.6) 298.29,15.65 292.81,15.65 292.18,16.29 275.57,16.29 v2(275.34,16.52) 274.92,16.94 271.42,16.94 271,17.35 268.49,17.35 267.36,18.48 261.67,18.48 255.56,24.59 248.47,24.59 246.2,22.31 246.2,18.26 244.86,16.93 235.42,16.93 234.77,17.58 232.6,17.58 v2(232.16,17.15) 231.88,17.15 231.55,17.47 224.18,17.47 223.41,18.24 223.41,23.2 221.78,24.83 220.89,24.83 219.65,26.08 218.19,26.08 217.05,27.21 216.89,27.21 215.85,28.26 212.71,28.26 210.97,29.99 v2(210.97,33.09)
  BOTTOM w0.089: UH1.AN15 210.67,32.77 v2(210.97,33.09)
  BOTTOM w0.114: v2(232.16,17.15) 232.16,17.11 232.43,16.85 232.43,16.53 232.7,16.26 232.7,10.8 234.74,8.76 235.25,8.76 237.27,6.73 JSSD3.68 ; JSSD1.68 328.48,31.36 327.61,32.23 v1(323.85,32.23) 322.25,32.23 321.84,32.63 321.84,35.51 321,36.35 321,37.99 321.34,38.33 321.34,38.91 319.67,40.58 319.67,42.32 319.03,42.96 313.57,42.96 312.57,41.96 JWLAN.42 312.57,39.99 312.43,39.85 309.25,39.85 307.51,38.1 307.51,33.71 303.6,29.81 303.6,28.1 299,23.5 299,18.73 299.41,18.32 299.41,16.77 v2(299.24,16.6) ; JSSD2.68 278.67,7.5 275.34,10.83 v2(275.34,16.52)
SUSP#: length 663
  TOP w0.114: v2(321.24,41.75) Q8.3 ; v2(219.46,46.97) 219.46,47.45 220.08,48.07 224.71,48.07 225.64,49 231.62,49 232.6,48.02 v2(232.6,47.7) ; v2(304.52,14.31) 304.52,15.84 306.09,17.41 UE5.116 ; U20.4 184,78.48 184.4,78.07 184.4,75.99 184.13,75.72 v2(182.95,75.72)
  IN3 w0.127: v2(321.24,41.75) 320.77,41.28 320.77,39.82 321.35,39.25 321.35,38.34 320.96,37.95 320.96,36.01 314.14,29.19 314.14,25.79 313.29,24.94 313.29,17.32 310.98,15.01 309.67,15.01 309.33,14.66 308.03,14.66 306.92,13.54 305.29,13.54 v2(304.52,14.31) ; v2(126.11,116.8) 126.11,116.76 124.6,115.24 124.6,113 123.34,111.74 123.34,100.64 120.91,98.21 v2(120.91,96.49) 117.48,93.06 117.48,91.67 116.32,90.5 116.32,72.52 105.69,61.89 105.69,60.16 105.18,59.66 104.78,59.66 102.62,57.5 102.62,55.1 101.89,54.37 101.89,52.24 99.37,49.72 v2(99.37,47.42)
  IN4 w0.127: v2(99.37,47.42) 99.37,46.75 95.64,43.02 95.64,39.97 95.96,39.66 97.87,39.66 99.2,38.33 99.2,35.38 100.92,33.66 100.92,30.45 97.54,27.08 97.54,24.89 95.1,22.45 79.45,22.45 75.71,18.71 65.24,18.71 v2(64.91,18.39)
  IN6 w0.081: v2(126.11,116.8) 126.63,117.32 126.63,125.76 119.2,133.2 119.2,143.58 120.6,144.99 120.6,147.73 120.52,147.81 120.52,148.79 125.49,153.77 137.55,153.77 140.85,157.07 150.63,157.07 153.49,159.93 160.6,159.93 162.82,162.15 162.82,163.85 163.46,164.48 163.46,166.34 164.03,166.91 168.37,166.91 v2(168.7,167.24) ; v2(267.06,17.57) 267.07,17.57 268.98,15.65 271.41,15.65 271.6,15.46 291.98,15.46 293.19,14.26 299.03,14.26 299.54,14.76 304.07,14.76 v2(304.52,14.31) ; v2(99.37,47.42) 99.37,46.82 105.93,40.26 111.75,40.26 112.97,39.04 119.98,39.04 122.84,36.18 158.23,36.18 159.18,37.13 174.23,37.13 175.28,38.18 180.19,38.18 v2(182.35,40.34) 185.41,43.41 185.41,51.67 188.66,54.92 192.63,54.92 196.53,58.83 199.91,58.83 202.2,56.53 208.42,56.53 211.22,53.74 211.22,51.75 213.49,49.47 226.97,49.47 227.43,49.01 231.28,49.01 v2(232.6,47.7) 233.44,46.85 241.78,46.85 242.48,47.55 249.04,47.55 250.42,46.17 257.05,46.17 257.75,45.46 269.16,45.46 274.55,40.08 287.37,40.08 288.95,41.66 302.66,41.66 304.64,43.64 310.74,43.64 312.72,41.66 321.15,41.66 v2(321.24,41.75)
  BOTTOM w0.114: RT15.2 172.37,166.06 171.19,167.24 v2(168.7,167.24) ; v2(182.95,75.72) 182.95,75.22 182.06,74.32 182.06,61.06 183.4,59.72 183.4,51.41 181.68,49.69 181.68,41 v2(182.35,40.34) ; PR5007.1 126.11,116.81 v2(126.11,116.8) ; PR807.2 223.31,39.48 221.62,41.17 220.48,41.17 219.96,41.7 219.96,42.44 219.36,43.03 219.36,46.87 v2(219.46,46.97) ; v2(120.91,96.49) 120.92,96.49 127.66,96.49 128.1,96.92 UZ21.3 ; v2(267.06,17.57) 266.94,17.57 265.88,18.62 U16.4 ; v2(64.91,18.39) 64.91,18.31 R174.1 R182.1 ; v2(99.37,47.42) 99.37,46.88 98.88,46.39 PR209.2
SUSP#_R: length 7
  TOP w0.089: UT1.D2 176.16,168.24 175.47,168.24
  TOP w0.102: 175.47,168.24 175.19,168.24 174.88,167.93 173.24,167.93 172.54,167.23 v2(172.35,167.23) RT30.2
  BOTTOM w0.102: v2(172.35,167.23) v1(172.76,166.81) 172.96,166.62 RT15.1
SW_1.2V: length 1.3
  IN4 w1.016: 89.73,40.1 89.73,41.43
  vias: v1(87.03,40.98) v2(87.38,39.81) v2(87.38,39.21) v2(87.38,38.58) v2(87.38,37.94) v2(87.38,37.31) v2(87.7,36.8) v2(88.02,39.21) v2(88.02,38.58) v2(88.02,37.94) v2(88.02,37.31) v2(88.34,36.8) v2(88.65,38.58) v2(88.65,37.94) v2(88.65,37.31) v2(88.97,36.8) v2(89.16,37.62) v2(89.9,39.71) v2(90.28,42.36) v2(90.31,39.26) v2(90.76,42.72)
SW_+1VALWP:
  vias: v1(251.56,17.7) v2(251.67,19.53) v2(251.67,18.94) v2(251.91,21.39) v2(251.91,20.81) v2(251.91,20.23) v2(252.31,19.53) v2(252.31,18.94) v2(252.55,21.39) v2(252.55,20.81) v2(252.55,20.23) v2(253.18,21.39) v2(253.18,20.81) v2(253.18,20.23)
SW_USB20_N1: length 16.2
  TOP w0.107: v2(25.66,46.64) 25.42,46.88 25.42,47.33 25.2,47.56 24.41,47.56 24.39,47.59 23.82,47.59 23.79,47.56 22.69,47.56 22.23,47.1 22.23,46.76 22.08,46.62 UU1.11
  BOTTOM w0.107: v2(25.66,46.64) 25.6,46.58 25.33,46.58 25.15,46.76 25.15,46.96 25.35,47.15 26.68,47.15 26.93,46.9 26.93,44.25 24.51,41.83 23.78,41.83 23.55,41.6 23.55,41.48 23.44,41.37 23.36,41.37 23.25,41.26 LU3.1
SW_USB20_P1: length 16.3
  TOP w0.107: UU1.10 22.58,46.67 22.44,46.82 22.44,47.01 22.78,47.35 v3(24.1,47.35) 25.11,47.35 25.22,47.25 25.22,46.5 25.11,46.39 24.96,46.39 v2(24.71,46.64)
  BOTTOM w0.107: LU3.4 23.75,41.52 23.86,41.62 24.6,41.62 27.14,44.16 27.14,46.98 26.76,47.35 25.26,47.35 24.95,47.04 24.95,46.88 v2(24.71,46.64)
SYNC_OUT: length 1.8
  TOP w0.107: v2(29.53,9.06) 29.57,9.1 29.72,9.1 30.01,8.81 UA4.38
  BOTTOM w0.102: TC24.1 29.23,9.06 v2(29.53,9.06)
SYS_PEX_RST_MON#: length 33.3
  IN1 w0.081: v2(197.42,116.88) 197.82,117.29 199.54,117.29 199.77,117.06 200.84,117.06 203.69,114.21 208.88,114.21 209.57,113.52 211.39,113.52 212.21,114.35 215.63,114.35 v2(217.07,112.91)
  BOTTOM w0.1: v2(217.07,112.91) 217.24,112.74 217.53,112.74 218.31,111.97 219.1,111.97 219.52,111.55 UG9.BE2
  BOTTOM w0.114: RG537.2 202.13,116.86 201.68,116.41 200.44,116.41 199.39,117.47 DG1.2 198.34,117.47 198.18,117.3 197.84,117.3 v2(197.42,116.88) 197.42,116.91 196.67,117.66 RG21.1
SYS_PWROK: length 122.6
  TOP w0.114: v2(296.49,10.88) 296.49,9.3 296.74,9.05 UE5.74 296.74,6.97 CE46.1
  IN3 w0.127: v2(227.5,32.96) 229.95,32.96 230.88,32.02 233.19,32.02 234.07,32.9 235.42,32.9 235.81,32.51 236.66,32.51 241.17,37.01 246.04,37.01 247.03,38.01 247.03,40.13 250.06,43.16 265.52,43.16 273.82,34.86 277.41,34.86 278.1,34.17 283.34,34.17 284.11,33.41 289.68,33.41 293.76,29.33 v2(293.76,29.31)
  IN6 w0.081: 215.53,36.23 214.53,37.23 v2(213.71,37.23) ; 219.18,34.61 219.37,34.61 220.44,33.55 222.95,33.55 223.98,34.58 225.64,34.58 227.26,32.96 v2(227.5,32.96)
  IN6 w0.089: 215.53,36.23 215.72,36.04 215.72,35.27 216.38,34.61 219.18,34.61
  BOTTOM w0.089: UH1.AY1 214.34,39.11 214.34,38.76 214.03,38.46 214.03,37.93 213.71,37.6 v2(213.71,37.23)
  BOTTOM w0.114: v2(293.76,29.31) 293.76,28.48 294.17,28.07 294.17,21.21 293.58,20.62 293.58,18.53 295.52,16.59 295.52,13.38 296.49,12.41 v2(296.49,10.88)
SYS_RESET#: length 8.2
  BOTTOM w0.114: UH1.AW1 213.46,39.49 213.81,39.84 214.02,39.84 215.86,41.68 215.86,43 RH571.1 215.74,43.11 CH175.1 214.9,43.14 RH5.2 214.01,44.48 214.44,44.9 v1(214.44,45.08)
SYSON: length 383.6
  TOP w0.114: U19.4 179.28,77.65 178.72,77.09 v2(178.49,77.09) ; v2(322.79,27.16) 323.56,27.93 323.56,32.04 325.67,34.16 325.67,39.94 326.45,40.72 Q9.3 ; UE5.95 305.14,7.25 305.47,6.92 305.47,6.56 CE42.1 306.05,6.08 v2(306.56,5.57)
  IN3 w0.127: v2(322.79,27.16) 322.42,26.8 322.42,25.24 321.37,24.19 321.37,19.71 320.82,19.16 320.82,18.37 316.21,13.75 316.21,8.94 315.01,7.75 307.95,7.75 306.56,6.36 v2(306.56,5.57) ; v2(128.34,25.75) 129.68,27.08 168.28,27.08 172.73,31.53 172.73,35.4 174.57,37.24 174.57,39.34 176.41,41.19 176.41,45.63 176.84,46.05 176.84,53.35 177.81,54.32 177.81,76.42 v2(178.49,77.09)
  IN6 w0.081: v2(97.42,43.34) 98.21,43.34 102.25,39.3 102.25,32.47 105.04,29.69 105.35,29.69 110.32,24.72 127.31,24.72 v2(128.34,25.75) ; v2(322.79,27.16) 321.69,28.26 321.69,41.86 321.34,42.21 320.9,42.21 320.55,41.87 312.81,41.87 310.83,43.85 304.55,43.85 302.57,41.87 288.86,41.87 287.28,40.28 274.64,40.28 269.25,45.67 257.83,45.67 256.34,47.16 249.71,47.16 248.37,48.51 241.5,48.51 240.93,47.93 237.74,47.93 236.97,47.16 233.7,47.16 231.65,49.22 227.51,49.22 227.06,49.68 213.58,49.68 211.43,51.83 211.43,53.82 206.03,59.21 202.52,59.21 200.83,60.9 198.07,60.9 197.59,61.37 195.52,61.37 194,59.85 192.97,59.85 192.63,59.51 192.63,58.93 192.2,58.5 190.65,58.5 189.76,59.39 185.5,59.39 185.36,59.26 181.32,59.26 178.74,61.84 178.74,67.83 177.24,69.33 177.24,75.85 v2(178.49,77.09)
  BOTTOM w0.114: PR208.1 97.05,43.34 v2(97.42,43.34)
TB_STAT#_CHG: length 8.5
  TOP w0.203: PU700.16 56.64,19.77 v2(56.14,19.27) PR718.1
  TOP w0.254: v2(60.52,19.91) 60.52,19.72 60.83,19.41 PQ705.2
  IN3 w0.254: v2(60.52,19.91) 60.52,19.68 60.27,19.42 58.66,19.42 57.86,20.23 56.78,20.23 56.14,19.59 v2(56.14,19.27)
TBT_A_AUX_N: length 2.6
  TOP w0.089: UT1.W15 182.28,161.53 v2(182.61,161.87)
  BOTTOM w0.089: v2(182.61,161.87) 182.61,161.81 182.44,161.64 182.23,161.64 181.91,161.32 181.91,160.96 182.05,160.81 CT44.2
TBT_A_AUX_N_C: length 32.7
  IN3 w0.109: v2(182.52,155.53) 182.63,155.64 182.63,156.07 182.97,156.4 183.33,156.4 183.33,156.41 183.94,156.41 184.41,156.88 184.41,159.13 185.22,159.93 191,159.93 191.9,160.83 191.9,161.53 192.31,161.95 192.31,162.75 193.27,163.7 193.27,164.08 193.87,164.69 194.72,164.69 195.27,165.23 195.27,166.63 195.87,167.24 196.54,167.24 196.77,167.01 v2(196.77,166.28)
  BOTTOM w0.076: v2(196.77,166.28) 196.77,165.58 197.48,164.87 197.48,164.79 197.95,164.32 198.26,164.32 198.51,164.07 UT4.J2
  BOTTOM w0.089: CT44.1 182.26,159.47 182.26,157.69 182.56,157.39 182.56,156.38 182.84,156.1 182.84,155.62 182.75,155.53 v2(182.52,155.53) ; RT70.2 196.77,167.1 v2(196.77,166.28)
TBT_A_AUX_P: length 2.5
  TOP w0.089: v2(182.61,161.2) 182.29,160.88 UT1.Y15
  BOTTOM w0.089: v2(182.61,161.2) 182.61,161.28 182.43,161.46 182.3,161.46 182.08,161.24 182.08,161.03 182.37,160.75 182.53,160.75 182.62,160.66 CT43.2
TBT_A_AUX_P_C: length 32.9
  IN3 w0.109: v2(196.1,166.28) 196.29,166.28 196.36,166.35 196.36,166.45 196.57,166.66 196.57,166.93 196.46,167.04 195.95,167.04 195.46,166.55 195.46,165.15 194.8,164.49 193.96,164.49 193.47,164 193.47,163.62 192.51,162.66 192.51,161.87 192.1,161.45 192.1,160.75 191.08,159.73 185.3,159.73 184.61,159.04 184.61,156.79 184.02,156.21 183.05,156.21 182.83,155.98 182.83,155.79 182.93,155.7 182.93,155.62 183.05,155.5 v2(183.33,155.5)
  BOTTOM w0.076: UT4.J1 198.07,164.15 197.89,164.15 197.32,164.72 197.32,164.8 196.6,165.51 196.6,165.94 196.27,166.28 196.22,166.28
  BOTTOM w0.089: 196.22,166.28 v2(196.1,166.28) 196.48,166.66 196.48,167.21 RT73.1 ; v2(183.33,155.5) 183.12,155.5 183.02,155.61 183.02,156.18 182.73,156.46 182.73,157.46 182.51,157.69 182.51,157.7 182.44,157.77 182.44,159.49 CT43.1
TBT_A_USB20_L_NB: length 8.3
  IN4 w0.127: v2(192.35,178.77) 192.54,178.58 192.54,177.46 192.77,177.23 192.77,176.28 193.47,175.58 193.47,175.37 v2(193.28,175.19)
  BOTTOM w0.099: JUSBC1.B7 192.35,178.78
  BOTTOM w0.107: LT3.3 193.35,172.48 193.48,172.61 193.48,172.96 193.32,173.12 DT10.7 DT10.4 193.32,174.61 193.48,174.77 193.48,174.99 v2(193.28,175.19) ; 192.35,178.78 v2(192.35,178.77)
TBT_A_USB20_L_NT: length 6.4
  BOTTOM w0.107: JUSBC1.A7 193.1,177.57 192.92,177.4 192.92,175.86 192.81,175.75 192.81,175.71 192.41,175.31 192.37,175.31 192.16,175.1 192.16,174.78 192.32,174.63 DT10.2 DT10.8 192.32,173.16 192.16,173.01 192.16,172.62 192.27,172.52 LT2.2
TBT_A_USB20_L_PB: length 8.3
  IN4 w0.127: v2(192.94,178.78) 192.76,178.61 192.76,177.55 192.99,177.32 192.99,176.37 193.68,175.67 193.68,175.37 v2(193.87,175.19)
  BOTTOM w0.099: JUSBC1.B6 192.85,178.87
  BOTTOM w0.107: v2(193.87,175.19) 193.68,175 193.68,174.78 193.81,174.65 DT10.5 DT10.6 193.81,173.2 193.68,173.07 193.68,172.63 193.85,172.46 LT3.2 ; 192.85,178.87 v2(192.94,178.78)
TBT_A_USB20_L_PT: length 6.4
  BOTTOM w0.107: LT2.3 191.76,172.42 191.96,172.61 191.96,172.97 191.81,173.11 DT10.9 DT10.1 191.81,174.63 191.96,174.77 191.96,175.19 v3(192.45,175.68) 192.72,175.95 192.72,177.49 192.6,177.61 JUSBC1.A6
TBT_A_USB20_N: length 22.7
  TOP w0.089: UT1.D20 v2(184.55,168.36)
  IN6 w0.089: v2(184.55,168.36) 184.55,168.27 184.86,167.96 185.77,167.96 186.06,167.67 186.72,167.67 187.01,167.96 189.1,167.96 190.27,169.13 195.49,169.13 198.74,165.88 198.74,165.54 199.11,165.17 199.87,165.17 200.19,165.49 200.19,166.51 200.04,166.65 199.89,166.65 v2(199.8,166.56)
  BOTTOM w0.076: v2(199.8,166.56) 199.8,166.03 200.01,165.82 200.01,165.41 199.91,165.31 199.91,164.96 UT4.K5
TBT_A_USB20_NB: length 19.2
  IN6 w0.089: v2(201.28,168.78) 201.44,168.78 201.68,169.02 201.68,170.35 201.13,170.9 197.39,170.9 196.17,172.12 195.04,172.12 194.95,172.03 194.95,171.63 195.04,171.55 v2(195.27,171.55)
  BOTTOM w0.076: UT4.L7 201.24,165.15 201.24,166.37 201.55,166.68 201.55,166.7
  BOTTOM w0.107: LT3.4 193.35,170.06 193.58,169.83 194.51,169.83 195.03,170.35 195.03,171.3 v2(195.27,171.55) ; v2(201.28,168.78) 201.28,168.92 201.47,169.1 201.62,169.1 201.9,168.82 201.9,168.64 201.73,168.47 201.73,167.25 201.55,167.06 201.55,166.78 201.55,166.78 201.55,166.7
TBT_A_USB20_NT: length 16.9
  IN6 w0.089: v2(200.3,169.83) 200.14,169.67 200.14,169.34 199.95,169.16 198.23,169.16 196.86,170.53 192.38,170.53 192.29,170.44 192.29,170.17 192.38,170.09 v2(192.54,170.09)
  BOTTOM w0.076: UT4.L6 200.66,164.95 200.73,164.88 200.85,164.88 200.91,164.94 200.91,165.18 200.71,165.38 200.71,165.74 201.02,166.05 201.02,166.56 201.06,166.6
  BOTTOM w0.107: 201.06,166.6 201.06,167.26 201.25,167.45 201.25,168.1 200.11,169.23 200.11,169.64 v2(200.3,169.83) ; v2(192.54,170.09) 192.36,170.09 192.21,170.24 192.21,170.39 192.27,170.44 LT2.1
TBT_A_USB20_P: length 22.7
  TOP w0.089: UT1.E20 v2(184.55,167.71)
  IN6 w0.089: v2(200.35,166.91) 200.35,165.42 199.94,165.01 199.04,165.01 198.57,165.47 198.57,165.81 195.42,168.97 190.34,168.97 189.17,167.8 187.08,167.8 186.79,167.51 186,167.51 185.7,167.8 184.65,167.8 v2(184.55,167.71)
  BOTTOM w0.076: 200.35,166.66 200.35,166.61 199.97,166.23 199.97,166.1 200.18,165.89 200.18,165.34 200.07,165.24 200.07,165.12 200.13,165.07 UT4.L5
  BOTTOM w0.107: 200.35,166.66 v2(200.35,166.91)
TBT_A_USB20_PB: length 19.2
  IN6 w0.089: v2(194.39,171.6) 194.7,171.6 194.79,171.69 194.79,172.1 194.97,172.28 196.24,172.28 197.46,171.06 201.2,171.06 201.85,170.41 201.85,169.45 v2(202.1,169.2)
  BOTTOM w0.076: UT4.K7 201.41,164.82 201.41,165.08 201.41,165.08 201.41,166.3 201.62,166.52 201.63,166.52 201.73,166.62 201.73,166.67 201.75,166.69 201.75,166.7
  BOTTOM w0.107: 201.75,166.7 201.75,166.97 201.94,167.16 201.94,168.39 202.1,168.56 v2(202.1,169.2) ; LT3.1 193.85,170.42 193.77,170.34 193.64,170.34 193.56,170.25 193.56,170.14 193.66,170.03 194.42,170.03 194.83,170.44 194.83,171.57 194.67,171.72 194.52,171.72 v2(194.39,171.6)
TBT_A_USB20_PT: length 16.9
  IN6 w0.089: v2(191.78,170.09) 191.84,170.09 192.12,170.36 192.12,170.51 192.31,170.69 196.93,170.69 198.3,169.32 199.88,169.32 199.97,169.41 199.97,169.58 v2(199.72,169.83)
  BOTTOM w0.076: UT4.K6 200.66,164.71 200.41,164.96 200.41,165.17 200.54,165.31 200.54,165.8 200.85,166.11 200.85,166.78
  BOTTOM w0.107: v2(199.72,169.83) 199.91,169.64 199.91,169.15 201.04,168.01 201.04,167.53 200.85,167.34 200.85,166.79 200.85,166.78 ; LT2.4 191.76,170.61 192.01,170.36 192.01,170.21 191.88,170.09 v2(191.78,170.09)
TBT_CIO_PLUG_EVENT#: length 188
  TOP w0.089: UT1.W2 176.38,161.57 176.15,161.8 175.52,161.8 174.72,161 174.39,161
  TOP w0.102: 174.39,161 v2(174.37,160.99)
  TOP w0.127: v2(174.37,160.99) 174.3,160.91 RT29.2
  IN2 w0.102: v2(174.37,160.99) 172.23,158.84 172.23,157.45 172.51,157.17 172.51,154.83 172.36,154.68 172.36,153.71 173.37,152.7 183.98,152.7 189.42,147.26 189.42,126.76 181.79,119.12 181.79,104.86 179.53,102.6 179.53,93.23 177.99,91.69 177.99,84.31 175.73,82.05 175.73,71.56 187.76,59.53 191.67,59.53 v2(192.07,59.13)
  IN3 w0.089: v2(210.19,19.4) 209.94,19.4 209.58,19.76 209.58,20.23 209.37,20.44 209.14,20.44 208.34,21.25 208.34,21.82 207.92,22.24 205.19,22.24 204.25,23.18 203.3,23.18 202.5,23.99 201.85,23.99 201.61,24.23 201.61,27.97 200.8,28.78 200.8,31.47 201.54,32.21 201.54,33.81 202.51,34.78 202.51,36.13 202.18,36.46 202.18,37.36 201.37,38.17 201.37,39.07 200.79,39.66 200.22,39.66 199.71,40.17 199.71,40.21 198.12,41.8 198.12,42.08
  IN3 w0.102: 198.12,42.08 198.12,47.31 192.35,53.07 192.35,56.46 191.47,57.33 191.47,58 192.07,58.6 v2(192.07,59.13)
  BOTTOM w0.089: UH1.AN43 210.73,18.97 210.83,19.07 210.83,19.32 210.7,19.46 210.25,19.46 v2(210.19,19.4)
TBT_EE_CLK: length 29.2
  TOP w0.089: UT1.AB4 177.07,159.95 177.07,159.34 175.71,157.98 175.71,157.89 175.53,157.71 175.45,157.71
  TOP w0.114: 175.45,157.71 v2(174.63,157.71)
  IN3 w0.127: v2(174.63,157.71) 174.96,157.39 178.03,157.39 178.7,156.72 178.7,156.66 179.95,155.41 181.16,155.41 182.23,154.34 v2(192.72,154.34)
  BOTTOM w0.114: RT101.1 193.9,156.01 192.72,154.83 v2(192.72,154.34) UT2.6
TBT_EE_CS_N: length 42.8
  TOP w0.089: UT1.AC3 176.84,159.36 175.44,157.96
  TOP w0.114: 175.44,157.96 174.95,157.96 174.7,158.21 v2(174.26,158.21)
  IN3 w0.127: v2(174.26,158.21) 173.85,158.21 173.45,157.81 173.45,157.11 174.15,156.42 174.15,153.97 174.58,153.54 194.33,153.54 194.66,153.88 194.66,156.34 v2(194.45,156.55)
  BOTTOM w0.114: RT50.2 187.52,161.45 188.12,160.85 RT100.1 189.71,160.85 190.18,160.38 UT2.1 190.18,158.86 192.48,156.55 v2(194.45,156.55)
TBT_EE_DI: length 30.2
  TOP w0.089: 176.47,159.25 176.6,159.38 176.6,159.94 UT1.AB3
  TOP w0.102: 176.47,159.25 175.43,158.21 175.14,158.21
  TOP w0.114: 175.14,158.21 v2(174.7,158.66)
  IN3 w0.127: v2(174.7,158.66) 175.46,157.89 178.24,157.89 179.46,156.67 179.46,156.62 180.16,155.92 181.37,155.92 182.42,154.87 184.12,154.87 184.83,155.58 192.68,155.58 v2(193.99,154.27)
  BOTTOM w0.114: RT98.1 196.03,155.73 195.4,155.1 194.51,155.1 193.99,154.58 v2(193.99,154.27) UT2.5
TBT_EE_DO: length 40.3
  TOP w0.089: 175.46,157.19 v1(175.97,157.71) 176.03,157.77 176.03,158.05 177.3,159.31 UT1.AC4
  TOP w0.114: v2(173.87,157.64) 174.32,157.19 175.46,157.19
  IN3 w0.127: v2(173.87,157.64) 174.57,156.94 174.57,156.05 175.34,155.28 176.45,155.28 176.98,154.74 181.11,154.74 182.06,153.8 194.22,153.8 194.41,153.98 194.41,155.95 193.94,156.42 v2(193.94,157.07)
  BOTTOM w0.114: RT49.1 189.15,162.07 RT99.1 189.24,161.51 189.49,161.26 190.13,161.26 190.83,160.56 191.33,160.56 191.45,160.45 UT2.2 191.45,158.08 192.46,157.07 v2(193.94,157.07)
TBT_EE_WP_N: length 43.5
  TOP w0.089: v2(174.68,161.48) 174.95,161.48 175.49,162.02 UT1.V1
  IN3 w0.127: v2(193.94,157.72) 194.92,156.74 194.92,153.77 194.43,153.29 174.48,153.29 173.9,153.87 173.9,156.31 173.2,157.01 173.2,157.92 174.06,158.78 174.06,159.48 174.97,160.39 174.97,161.2 v2(174.68,161.48)
  BOTTOM w0.114: v2(193.94,157.72) 193.02,157.72 192.72,158.02 UT2.3 192.72,160.62 192.54,160.8 190.93,160.8 190.39,161.34 190.39,161.71 190.03,162.07 RT48.2
TBT_FORCE_PWR: length 177.9
  TOP w0.107: v2(170.49,161.11) 169.9,161.7 RT13.2
  IN1 w0.097: 193.27,31.53 194.75,31.53 195.53,30.75 197.37,30.75 197.89,30.23 197.89,29.85 198.41,29.33 198.47,29.33 200.92,26.88 200.92,24.53 201.44,24.01 201.44,20.34 v2(202.07,19.72)
  IN1 w0.102: v2(186.95,58.9) 186.04,57.98 186.04,55.3 186.62,54.71 186.62,37.55 192.64,31.53 193.27,31.53
  IN4 w0.102: v2(170.49,161.11) 171.34,160.26 175.61,160.26 177.2,158.67 178.76,158.67 179.08,158.35 182.99,158.35 185.26,156.08 188.52,156.08 190.09,154.5 190.09,152.38 191.54,150.93 191.54,149 195.02,145.52 195.02,137.77 195.54,137.26 195.54,136.26 194.6,135.32 194.6,129.97 193.98,129.35 193.98,128.22 193.3,127.53 193.3,123.84 188.18,118.72 188.18,115.45 187,114.27 187,111.56 185.7,110.25 185.7,99.03 185.51,98.83 185.51,94.44 187.18,92.76 187.31,92.64 187.31,81.99 186.25,80.93 186.25,72.71 186.83,72.13 186.83,67.94 187.35,67.41 187.35,63.16 186.68,62.48 186.68,59.17 v2(186.95,58.9)
  BOTTOM w0.089: v2(202.07,19.72) 201.81,19.46 201.3,19.46 201.12,19.28 UH1.P43
TBT_FORCE_PWR_R: length 13.7
  TOP w0.102: v1(168.46,162.43) 168.65,162.62 v2(168.65,162.95) ; UT1.H4 v2(177.4,167.06)
  TOP w0.107: RT13.1 RT35.1 169.25,162.95 v2(168.65,162.95)
  IN1 w0.102: v2(177.4,167.06) 176.68,167.06 176.44,166.81 173.37,166.81 171.01,164.45 171.01,164.18 170.7,163.86 169.57,163.86 v2(168.65,162.95)
  BOTTOM w0.107: RT94.2 168.87,163.16 v2(168.65,162.95)
