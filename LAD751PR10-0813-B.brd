# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NVVDD1_ENP: length 11.7
  TOP w0.254: PR6034.1 274.89,141.48 v2(275.75,142.35) ; v2(277.9,149.23) PQ8203.3
  BOTTOM w0.203: v2(275.75,142.35) 275.61,142.21 PU6000.36
  BOTTOM w0.254: v2(275.75,142.35) 275.75,147.33 v1(276.72,148.3) 277.65,149.23 v2(277.9,149.23)
NVVDD1_PGOOD: length 320.8
  TOP w0.102: UG29.2 277.77,142.84 v2(277.46,142.53) ; v1(309.36,56.09) 308.99,55.72 v2(308.81,55.72)
  TOP w0.254: v2(308.81,55.72) PR6403.1 ; DG4.1 212.94,159.18 212.52,159.6 v2(212.47,159.6)
  IN4 w0.254: v2(308.81,55.72) 308.77,55.68 302.48,55.68 301.49,54.69 301.49,51.77 300.53,50.81 300.53,44.99 297.85,42.31 292.4,42.31 287.19,47.52 272.41,47.52 270.91,49.02 259.99,49.02 259.66,49.35 250.8,49.35 250.51,49.64 240.71,49.64 240.42,49.35 237.97,49.35 235.73,47.11 234.4,47.11 233.84,47.67 233.84,48.84 232.69,49.99 230.86,49.99 230.29,50.57 230.29,50.86 229.96,51.19 227.01,51.19 225.41,49.59 216.66,49.59 216.15,50.1 213.92,50.1 212.7,51.32 212.7,53.95 210.17,56.48 210.17,112.8 212.34,114.97 212.34,120.47 210.49,122.32 210.49,122.47 208.29,124.67 208.29,125.89 205.96,128.21 205.96,132.61 207.9,134.55 207.9,139.82 205.63,142.08 205.63,152.22 207.15,153.73 207.15,156.49 209.24,158.59 211.46,158.59 v2(212.47,159.6) 212.82,159.95 217.37,159.95 219.16,161.74 220.1,161.74 220.57,162.21 222.7,162.21 223.57,161.35 227.75,161.35 229.28,161.35 229.72,161.79 231.52,163.59 236.47,163.59 237.59,162.47 237.59,159.23 239.21,157.6 239.21,153.87 240.31,152.77 240.31,151.65 241.34,150.63 263.04,150.63 269.72,143.95 276.53,143.95 277.46,143.02 v2(277.46,142.53)
  BOTTOM w0.203: PU6000.38 276.41,141.43 277.46,142.48 v2(277.46,142.53) 277.46,143.19 PR6042.2
NVVDD2_EN: length 443.6
  TOP w0.102: UE10.19 314.7,58.94 v2(314.65,58.99) ; v1(282.04,161.3) 281.59,160.84 281.59,160.19
  TOP w0.203: PR6404.2 306.73,53.05 v2(306.63,53.15) 306.13,53.65 PU6400.3
  TOP w0.254: v2(281.59,159.22) UG28.4 281.59,160.19 ; PR6404.2 307.28,53.93 307.27,53.94 PR6403.2 PR6436.1
  IN1 w0.254: v2(306.63,53.15) 307.44,52.34 309.77,52.34 310.83,53.4 310.83,55.84 313.97,58.99 v2(314.65,58.99)
  IN2 w0.254: v2(290.18,85.51) 290.18,83.35 292.99,80.55 292.99,72.43 297.65,67.77 297.65,63.09 297.3,62.74 297.3,59.48 299.38,57.4 304.85,57.4 306.66,55.59 306.66,53.17 v2(306.63,53.15)
  IN3 w0.254: v2(306.63,53.15) 307.16,52.62 307.16,47.53 306.65,47.02 305.76,47.02 304.24,45.51 304.24,39.79 303.09,38.64 302.08,38.64 v2(299.86,36.42)
  IN4 w0.254: v2(299.86,36.42) 297.99,34.55 292.15,34.55 291.28,35.42 282.61,35.42 281.32,34.13 278.54,34.13 277.71,34.96 273.06,34.96 265.99,42.03 259.72,42.03 259.15,42.6 249.03,42.6 246.81,40.38 239.16,40.38 238.83,40.71 238.57,40.71 237.17,42.11 236.35,42.11 v2(235.89,41.65) 234.07,41.65 233.39,40.96 229.38,40.96 228.27,39.86 226.24,39.86 222.77,43.34 217.89,43.34 217.37,42.82 214.81,42.82 212.55,45.08 203.61,45.08 201.62,47.06 201.62,49.9 202.18,50.46 202.18,59.43 201.08,60.54 201.08,62.81 198.13,65.75 191.61,65.75 188.51,68.86 188.51,73.03 188.08,73.46 188.08,80.35 189.01,81.27 189.01,93.48 188.18,94.3 188.18,98.13 187.41,98.9 187.41,108.93 193.68,115.21 193.68,118.66 197.7,122.68 197.7,126.64 198.11,127.05 198.11,129.94 198.47,130.3 198.47,139.68 197.34,140.81 197.34,146.48 193.85,149.97 193.85,152.2 193.34,152.71 193.34,154.44 197.9,159 199.19,159 200.76,160.56 202.85,160.56 203.33,161.05 203.33,161.75 203.71,162.12 204.11,162.12 204.54,162.56 204.54,163.42 206.7,165.58 206.7,166.47 209.75,169.51 214.37,169.51 216.1,171.24 221.5,171.24 222.56,170.18 227.56,170.18 227.97,169.77 230.58,169.77 233.09,167.25 235.37,167.25 235.64,167.52 238.28,167.52 239.62,166.18 239.62,163.28 241.56,161.34 241.56,157.19 242.59,156.17 265.55,156.17 268.39,159 268.39,163.7 270.47,165.78 276.35,165.78 276.83,165.3 276.83,162.33 279.37,159.79 281.02,159.79 v2(281.59,159.22)
  BOTTOM w0.102: QG507.2 v2(290.18,85.51)
  BOTTOM w0.254: PR8217.1 236.6,38.06 236.03,38.63 236.03,39.54 235.89,39.68 v2(235.89,41.65)
NVVDD2_PGOOD: length 238.1
  TOP w0.102: QG502.4 213.47,157.99 RG506.2 214.25,158.06 214.25,158.76 214.36,158.88 DG4.2 214.29,159.25 213.78,159.25 v2(213.78,159.25)
  TOP w0.203: PU6400.13 300.71,53.65 v2(300.57,53.79) 299.79,53.79 PR6408.1
  TOP w0.254: v2(236.42,40.8) v1(235.77,40.8) 235.72,40.8 235.41,41.11 235.41,45.34 235.17,45.57 235.17,47.82 v2(235.18,47.82)
  IN4 w0.102: v2(235.18,47.82) 235.17,47.82 235.17,48.58 234.15,49.61 234.15,49.98 233.26,50.87 233.26,51.25 232,52.51 231.08,52.51 230.52,51.95 226.53,51.95 225.26,50.67 222.25,50.67 221.98,50.94 214.18,50.94 213.46,51.66 213.46,54.27 210.93,56.8 210.93,111.84 211.77,112.68 213.63,112.68 214.77,113.81 214.77,117.45 213.72,118.49 213.72,120.16 211.25,122.64 211.25,122.93 209.05,125.13 209.05,126.21 206.73,128.53 206.73,132.3 208.66,134.23 208.66,141.37 206.4,143.63 206.4,151.9 210.88,156.38 211.79,156.38 212.37,156.95 212.37,158.77 212.85,159.25 v2(213.78,159.25)
  IN4 w0.254: v2(300.57,53.79) 299.92,53.14 299.92,45.24 298.04,43.36 294.99,43.36 290.23,48.13 272.66,48.13 271.17,49.63 260.24,49.63 259.91,49.96 251.05,49.96 250.76,50.25 240.45,50.25 240.24,50.03 237.79,50.03 235.58,47.82 v2(235.18,47.82)
  BOTTOM w0.254: v2(236.42,40.8) 237.11,40.8 PR801.2
NVVDD2_PSI: length 9
  TOP w0.102: v1(306.78,54.08) 306.28,54.58 v2(306.02,54.58)
  TOP w0.203: PU6400.4 305.48,54.05 v2(306.02,54.58)
  TOP w0.254: v2(309.65,54.22) 309.82,54.04 PR6410.2 310.26,54.18 310.52,54.44 310.52,54.44 PR6413.2 311.17,55.96 PR6406.1
  IN1 w0.254: v2(309.65,54.22) 309.43,54.43 306.17,54.43 v2(306.02,54.58)
NVVDD_B+: length 2.9
  BOTTOM w0.508: v2(264.61,143.92) 265.25,143.29 266.37,143.29 PC6000.2 266.39,143.29 PR6006.1
  vias: v1(258.42,150.65) v2(207.72,146.08) v2(207.72,145.45) v2(207.72,144.81) v2(207.72,144.18) v2(208.3,146.08) v2(208.3,145.45) v2(208.3,144.81) v2(208.3,144.18) v2(208.89,146.08) v2(208.89,145.45) v2(208.89,144.81) v2(208.89,144.18) v2(217.24,149.38) v2(217.88,149.38) v2(218.51,149.38) v2(219.15,149.38) v2(219.78,149.38) v2(220.42,149.38) v2(221.05,149.38) v2(221.69,149.38) v2(222.32,149.38) v2(230.89,149.45) v2(231.53,149.45) v2(232.16,149.45) v2(232.8,149.45) v2(233.43,149.45) v2(234.07,149.45) v2(234.7,149.45) v2(235.34,149.45) v2(235.97,149.45) v2(244.61,149.51) v2(245.25,149.51) v2(245.88,149.51) v2(246.52,149.51) v2(247.15,149.51) v2(247.79,149.51) v2(248.42,149.51) v2(249.06,149.51) v2(249.69,149.51) v2(258.39,149.57) v2(259.03,149.57) v2(259.63,149.57) v2(260.23,149.57) v2(260.87,149.57) v2(261.5,149.57) v2(262.14,149.57) v2(262.77,149.57) v2(263.41,149.57)
NVVDD_ISUMN1: length 11.7
  BOTTOM w0.254: PL6100.3 257.25,136.81 257.5,137.07 264.85,137.07 PR6010.1
NVVDD_ISUMN2: length 40.9
  IN2 w0.254: v2(264.49,134.97) 264.14,134.97 262.18,133.02 262.18,128.63 261.47,127.92 244.3,127.92 243.57,128.65 243.57,137.53 v2(243.47,137.64)
  BOTTOM w0.254: PL6101.3 v2(243.47,137.64) ; PR6011.1 v2(264.49,134.97)
NVVDD_ISUMN3: length 55
  IN2 w0.254: v2(264.49,133.06) 264.14,133.06 262.95,131.87 262.95,128.22 261.24,126.52 230.9,126.52 230.07,127.35 230.07,137.2 v2(229.75,137.51)
  BOTTOM w0.254: PL6200.3 v2(229.75,137.51) ; PR6013.1 v2(264.49,133.06)
NVVDD_ISUMN4: length 69.7
  IN2 w0.254: v2(216.1,137.7) 216.1,126.14 216.91,125.33 261.22,125.33 263.82,127.94 263.82,130.86 264.12,131.16 v2(264.49,131.16)
  BOTTOM w0.254: PR6014.1 v2(264.49,131.16) ; PL6201.3 v2(216.1,137.7)
NVVDD_ISUMP1: length 13.6
  BOTTOM w0.102: v1(264.79,138.94) 265.11,138.63 PR6001.1
  BOTTOM w0.254: PL6100.2 257.25,137.7 257.5,137.45 264.85,137.45 PR6001.1
NVVDD_ISUMP2: length 40.1
  IN2 w0.254: v2(243.47,138.27) 243.53,138.27 243.95,137.85 243.95,128.9 244.48,128.37 261.38,128.37 261.8,128.79 261.8,133.18 v2(264.49,135.86)
  BOTTOM w0.254: PR6002.1 v2(264.49,135.86) ; PL6101.2 v2(243.47,138.27)
NVVDD_ISUMP3: length 54.4
  IN2 w0.254: v2(264.49,133.95) 262.57,132.03 262.57,128.48 261.06,126.97 230.99,126.97 230.45,127.51 230.45,137.58 229.88,138.14 v2(229.75,138.14)
  BOTTOM w0.254: PL6200.2 v2(229.75,138.14) ; PR6003.1 v2(264.49,133.95)
NVVDD_ISUMP4: length 68.7
  IN2 w0.254: v2(264.49,132.07) 263.7,131.28 263.44,131.02 263.44,128.09 261.06,125.71 217.23,125.71 216.59,126.35 216.59,137.9 v2(216.1,138.4)
  BOTTOM w0.254: PR6004.1 v2(264.49,132.07) ; PL6201.2 v2(216.1,138.4)
NVVDD_PSI: length 98.8
  TOP w0.089: RG565.1 217.13,110.88 v2(217.47,110.54)
  TOP w0.102: v1(275.7,145.41) 276.22,144.89 v2(276.34,144.89)
  IN4 w0.102: v2(276.34,144.89) 278.68,142.54 278.68,141.95 278.14,141.41 278.14,135.1 277.69,134.66 277.69,130.08 276.74,129.13 264.94,129.13 262.18,126.37 239.44,126.37 236.3,123.23 229.96,123.23 226.48,119.76 226.48,118.06 225.04,116.62 222.9,116.62 221.66,117.86 218.51,117.86 217.62,116.97 217.62,114.95 218.07,114.51 218.07,113.2 217.69,112.82 217.69,112.17 217.88,111.98 217.88,111.03 217.47,110.62 v2(217.47,110.54)
  BOTTOM w0.089: RG15.1 214.68,110.32 217.26,110.32 v2(217.47,110.54) 219.1,110.54 219.41,110.85 UG9.BD2
  BOTTOM w0.102: v2(276.34,144.89) 276.42,144.8 PR6039.2
NVVDD_VCC_SENSE: length 11.8
  TOP w0.102: v1(246.47,123.98) 246.47,122.54 247.07,121.93 PR6021.2
  TOP w0.254: PR6021.2 v2(247.07,120.75)
  IN2 w0.254: v2(250.12,115.4) 250.58,115.86 250.58,118.71 248.55,120.75 v2(247.07,120.75)
  BOTTOM w0.203: v2(250.12,115.4) 249.77,115.05 UG9.BK45
NVVDD_VID: length 95.3
  IN4 w0.102: v2(222.77,110.55) 222.23,111.09 219.43,111.09 217.9,112.62 217.9,112.77 218.26,113.13 218.26,114.59 217.81,115.03 217.81,116.89 218.59,117.67 221.58,117.67 222.82,116.43 225.12,116.43 226.67,117.98 226.67,119.63 229.96,122.92 236.43,122.92 239.57,126.05 262.31,126.05 265.07,128.81 276.87,128.81 278.01,129.95 278.01,134.53 278.46,134.97 278.46,141.32 278.91,141.78 278.91,144.25 v2(278.3,144.86)
  BOTTOM w0.1: UG9.BD6 v2(222.77,110.55)
  BOTTOM w0.102: v1(278.2,145.55) 278.3,145.45 v2(278.3,144.86) 278.3,144.35 PR6044.1
NVVDD_VSS_SENSE: length 10.2
  TOP w0.254: PR6025.2 v2(245.83,120.43)
  IN2 w0.254: v2(250.14,116.12) 250.14,118.52 248.36,120.3 245.96,120.3 v2(245.83,120.43)
  BOTTOM w0.089: v2(245.83,120.43) v1(245.83,119.23)
  BOTTOM w0.203: v2(250.14,116.12) UG9.BL45
NVVDDS_B+:
  vias: v1(275.42,35.73) v2(275.05,38.38) v2(275.05,37.79) v2(275.05,37.21) v2(287.92,45.32) v2(287.92,44.74) v2(287.92,44.15) v2(287.92,43.54) v2(287.92,42.96) v2(287.92,42.32)
NVVDDS_BST1:
  vias: v1(306.16,52.22)
NVVDDS_BST2:
  vias: v2(300.55,52.36)
NVVDDS_COMP: length 3.5
  TOP w0.203: PU6400.12 300.96,54.05 v1(300.69,54.31) 300.39,54.61 PR6411.2 299.31,54.61 299.08,54.85 PC6427.2
NVVDDS_HG1: length 2.7
  TOP w0.203: PU6400.2 305.83,53.25 306.92,52.17 PR6429.1
NVVDDS_HG2: length 3.6
  TOP w0.203: PR6431.1 299.99,53.11 v2(300.57,53.11) 300.71,53.25 PU6400.14
  BOTTOM w0.102: v1(301.02,54.2) 301.02,53.57 v2(300.57,53.11)
NVVDDS_LG1: length 16.4
  TOP w0.102: v2(295.33,44.29) v1(296.12,44.29)
  IN1 w0.762: 303.79,50.32 303.48,50.01 303.48,48.23 299.54,44.29 296.24,44.29
  IN2 w0.762: 295.03,43.56 295.03,41.94 294.14,41.05 294.14,39.47
  vias: v2(294.1,38.51) v2(294.75,44.29) v2(294.68,38.51) v2(303.95,51.31) v2(304.43,50.96)
NVVDDS_LG2: length 25.1
  IN1 w0.762: 301.76,50.39 301.25,49.88 296.05,49.88 294.14,47.97 284.11,47.97 283.03,49.05
  IN2 w0.762: 281.38,48.36 281.38,44.74
  BOTTOM w0.102: v2(281.39,49.48) 280.25,49.48 v1(280.17,49.55)
  vias: v2(281.25,43.78) v2(281.83,43.78) v2(281.98,49.48) v2(302.46,50.96) v2(302.94,51.31)
NVVDDS_PSI: length 230.9
  TOP w0.089: RG565.2 218.03,111.09 v2(218.33,111.4) 218.33,111.74 218.61,112.02 219.02,112.02 219.45,111.59 RG503.1 220.04,112.02 219.69,112.36 219.69,112.95 RG564.2
  TOP w0.102: PR6410.1 311.61,54.04 v2(311.78,54.21) 312.06,54.49 v1(312.06,54.67)
  IN6 w0.102: v2(218.33,111.4) 218.07,111.13 217.14,111.13 216.67,110.66 216.67,107.91 213.53,104.77 209.64,104.77 207.15,102.28 190.92,102.28 188.82,100.17 187.84,100.17 187.65,100.17 185.94,98.46 185.94,93.47 186.23,93.18 186.23,75.05 182.16,70.98 182.16,70.29 183.05,69.41 188.49,69.41 191.8,66.11 207.5,66.11 209.53,64.08 209.53,57.12 212.1,54.55 212.1,52.11 213.28,50.94 219.87,50.94 220.13,50.67 227.02,50.67 227.79,49.9 232.02,49.9 233.3,48.61 240.65,48.61 241.22,49.18 248.82,49.18 249.74,48.27 259.57,48.27 260.61,49.31 272.27,49.31 273.34,48.24 276.61,48.24 277.46,47.39 293.63,47.39 296.85,50.61 296.85,56.08 298.13,57.36 309.79,57.36 311.45,55.7 311.45,54.54 v2(311.78,54.21)
NVVDDS_SNB1: length 3.7
  TOP w0.102: v1(286.58,53.41) 286.53,53.37 PC6428.1
  TOP w0.508: PR6409.2 286.56,50.78 PC6428.1
NVVDDS_SNB2: length 2.7
  TOP w0.102: v1(277.54,53.64) PR6424.2
  TOP w0.508: PC6440.1 277.54,51.41 PR6424.2
NVVDDS_SW1:
  vias: v1(305.22,51)
NVVDDS_SW2:
  vias: v1(301.74,50.87)
NVVDDS_VCC_SENSE: length 106.8
  TOP w0.102: PR6422.1 297.58,60.81 v1(296.83,60.06)
  TOP w0.254: PR6422.1 v2(297.86,61.42)
  IN4 w0.254: v2(249.18,118.21) 249.34,118.05 262.43,118.05 264.77,120.39 284.22,120.39 286.11,118.49 286.11,107.97 286.25,106.08 286.87,101.33 288.21,95.95 289.21,92.92 291.03,88.74 292.57,85.81 294.46,82.73 294.92,82.09 294.97,78.19 294.97,72.41 299.47,67.91 299.47,61.26 298.97,60.75 298.53,60.75 v2(297.86,61.42)
  BOTTOM w0.203: UG9.BM45 249.62,116.6 249.62,117.77 v2(249.18,118.21) 249.18,118.55 PR6425.2
NVVDDS_VID: length 225.7
  TOP w0.089: v1(216.84,112.06) 217.23,111.67 v2(217.5,111.67)
  TOP w0.102: v2(309.09,56.85) 308.47,57.47 PR6412.1
  IN6 w0.102: v2(217.5,111.67) 217.37,111.67 216.48,110.78 216.48,108.05 213.43,105 209.55,105 207.06,102.51 190.83,102.51 188.73,100.41 187.51,100.41 186.2,99.1 186.2,99.05 185.71,98.55 185.71,93.38 186,93.09 186,75.14 181.94,71.08 181.94,70.2 182.95,69.18 188.4,69.18 191.7,65.88 207.41,65.88 209.3,63.98 209.3,57.03 211.87,54.46 211.87,52.02 213.76,50.13 219.87,50.13 220.19,50.45 226.92,50.45 227.7,49.67 231.92,49.67 233.21,48.38 240.74,48.38 241.32,48.95 248.73,48.95 249.92,47.76 259.95,47.76 261.12,48.93 272.33,48.93 273.25,48.01 276.52,48.01 277.36,47.16 293.72,47.16 297.08,50.52 297.08,54.65 299.43,56.99 308.95,56.99 v2(309.09,56.85)
  BOTTOM w0.1: v2(217.5,111.67) 217.5,111.29 217.77,111.02 218.6,111.02 218.78,111.2 220.72,111.2 UG9.BE4
NVVDDS_VIDBUF:
  vias: v1(305.43,56.43)
NVVDDS_VREF: length 8.9
  TOP w0.102: PR6426.1 302.45,60.59 v1(301.77,61.27)
  TOP w0.203: v2(303.44,56.17) PU6400.8
  TOP w0.254: PR6426.1 302.43,60.27 v2(301.91,59.75) 301.91,59.59 PC6441.2 302.31,59.13 PR6419.1
  IN1 w0.254: v2(301.91,59.75) 303.44,58.21 v2(303.44,56.17)
NVVDDS_VSS_SENSE: length 112.7
  TOP w0.102: v2(298.73,61.45) 298.73,62.24 v1(298.82,62.34)
  TOP w0.254: PR6421.1 298.73,60.9 v2(298.73,61.45) ; PC6437.2 304.1,59.09 PR6423.2 304.98,59.13 PC6439.2 v2(304.99,59.76)
  IN4 w0.254: v2(249.18,117.44) 249.45,117.71 262.66,117.71 264.96,120.01 284.06,120.01 285.73,118.33 285.73,107.96 285.87,106.04 286.5,101.26 287.84,95.84 288.86,92.78 290.69,88.58 292.24,85.62 294.14,82.52 294.53,81.99 294.59,78.19 294.59,72.26 298.99,67.86 298.99,61.71 v2(298.73,61.45)
  IN6 w0.254: v2(304.99,59.76) 304.48,60.27 299.9,60.27 v2(298.73,61.45)
  BOTTOM w0.203: PR6427.2 248.76,118.97 248.76,118.48 248.76,118.26 248.76,117.86 v2(249.18,117.44) 249.18,116.56 UG9.BM44
ON/OFF#: length 283
  TOP w0.102: v1(306.32,42.07) 306.32,42.56 v2(306.49,42.74)
  TOP w0.107: v2(311.9,6.79) SW1.2 ; UE5.114 308.14,16.61 v2(308.45,16.31) 308.62,16.31 CE27.1 309.99,14.93 RE63.1
  IN3 w0.102: v2(308.45,16.31) 308.81,16.31 309.45,16.95 311.74,16.95 312.78,17.99 312.78,22.84 312.42,23.21 312.42,25.95 310.43,27.93 310.43,31.88 309.1,33.21 309.1,38.18 308.85,38.42 308.85,40.37 v2(306.49,42.74)
  IN4 w0.102: v2(212.32,164.83) 212.32,164.04 205.44,157.16 205.44,155.95 204.89,155.39 204.22,155.39 203.08,154.25 203.08,150.48 202.41,149.8 202.41,142.61 205.41,139.61 205.41,134.94 203.17,132.7 203.17,130.25 202.36,129.44 202.36,128.4 203.36,127.4 203.36,125.87 203.93,125.29 203.93,113.8 207.08,110.65 207.08,102.44 207.67,101.85 207.67,66.88 207.22,66.43 207.22,62.36 207.63,61.95 207.63,54.08 210.36,51.35 210.36,50.33 213.06,47.62 214.25,47.62 216.25,45.62 224.24,45.62 225.06,44.8 225.61,44.8 226.37,44.04 226.86,44.04 227.8,43.1 228.31,43.1 228.45,43.24 232.46,43.24 233.9,44.67 239.11,44.67 239.69,44.09 240.36,44.09 240.94,44.67 247.66,44.67 247.89,44.9 260.05,44.9 260.66,44.29 268.72,44.29 273.88,39.13 278.25,39.13 279.52,40.41 290.85,40.41 291.66,39.59 297.83,39.59 299.91,41.68 305.43,41.68 v2(306.49,42.74)
  BOTTOM w0.107: v2(308.45,16.31) 307.98,15.84 307.98,13.74 308.86,12.86 308.86,11.49 307.84,10.47 307.84,6.7 308.21,6.33 311.44,6.33 v2(311.9,6.79)
OUT_A: length 0.8
  BOTTOM w0.102: v1(36.78,4.3) 37.33,4.86 v2(37.35,4.86)
  vias: v2(36.9,5.24)
OUT_B: length 1.7
  BOTTOM w0.102: v2(36.33,2.32) v1(36.33,1.71)
  BOTTOM w0.508: LA51.1 36.71,2.73 36.48,2.51 36.48,2.47 v2(36.33,2.32)
OUT_D: length 0.5
  BOTTOM w0.102: v2(27,6.64) v1(27.5,6.64)
  vias: v2(27,7.23) v2(31.63,3.78) v2(31.63,3.18)
OVERT#: length 316.3
  TOP w0.102: v2(213.48,154.91) 213.48,153.82 213.29,153.64 v1(211.24,153.64) 206.89,153.64 v2(206.38,154.15) ; v2(206.19,117.82) 206.14,117.82 205.18,116.86 199.18,116.86 198.78,116.45 196.48,116.45 194.95,117.98 193.6,117.98 192.65,117.02 189.19,117.02 186.91,114.75 184.53,114.75 184.29,114.51 v2(184.29,113.82) ; UG23.5 v2(309.16,59.49)
  IN1 w0.102: v2(275.29,153.24) 274.3,152.25 274.3,149.82 271.76,147.27 267.35,147.27 265.45,149.18 265.45,149.98 264.7,150.72 264.7,153.73 263.86,154.57 253.67,154.57 252.64,153.54 252.64,151.19 251.79,150.34 241.82,150.34 241.68,150.48 239.65,150.48 239.21,150.04 228.43,150.04 227.81,149.42 225.59,149.42 224.98,150.03 213.34,150.03 212.33,151.04 212.33,152.96 213.48,154.1 v2(213.48,154.91) ; v2(206.19,117.82) 206.14,117.82 204.44,116.12 204.44,115.07 204.88,114.63 209.06,114.63 209.69,114.01 211.27,114.01 212.04,114.77 216.76,114.77 218.38,113.16 220.89,113.16 221.4,112.65 v2(221.47,112.65)
  IN3 w0.102: v2(309.16,59.49) 309.16,60.14 308.85,60.46 307.13,60.46 305.76,59.09 300.62,59.09 300.4,58.87 299.64,58.87 299.23,59.28 299.23,69.88 292.01,77.1 292.01,78.66 291.25,79.42 291.25,83.12 291.25,86.46 289.11,90.87 288.46,92.28 288.46,92.28 288.17,93.25 287.68,94.75 287.13,96.6 286.85,97.67 286.35,99.72 286.14,100.73 285.56,103.97 285.45,104.92 285.33,106.19 285.23,107.74 285.21,109.09 285.23,109.88 285.23,139.12 283.63,140.72 280.36,140.72 278.74,142.35 278.74,143.53 277.55,144.71 277.55,146.46 275.22,148.8 275.22,153.17 v2(275.29,153.24)
  IN4 w0.102: v2(206.38,154.15) 206.38,153.72 204.45,151.79 204.45,142.5 206.78,140.18 206.78,134.37 205.43,133.02 205.43,127.99 207.44,125.99 207.44,122.5 205.34,120.4 205.34,118.68 v2(206.19,117.82)
  BOTTOM w0.1: v2(221.47,112.65) UG9.BG5
  BOTTOM w0.102: v2(184.29,113.82) 183.82,114.29 183.82,118.08 188.73,122.99 197.42,122.99 RG9.1 ; v2(206.19,117.82) 206.14,117.82 205.8,118.16 QG501.1
P1: length 18.7
  TOP w0.254: PQ708.1 66.32,35.1 64.72,33.5 61.86,33.5 v4(61.44,33.08) 61.22,32.86 61.22,31.15 58.75,28.67 PC701.1 58.05,28.16 58.29,27.92 PR706.1 ; 66.75,34.32 65.48,33.05 v2(65.48,32.61) 65.11,32.24 64.94,32.24 64.52,31.83 PR701.2
  BOTTOM w0.254: v2(65.48,32.61) 65.05,32.18 PQ700.3
  vias: v2(68.06,37.34) v2(68.06,36.07) v2(68.14,39.24) v2(68.13,38.63) v2(68.16,34.87) v2(68.47,38.11) v2(68.55,36.4) v2(68.5,35.44) v2(68.77,37.57) v2(68.77,36.96) v2(68.78,39.21) v2(68.79,38.61) v2(68.78,34.69) v2(68.88,35.91)
P2:
  vias: v2(60.84,40.86) v2(60.84,39.74) v2(61.03,40.3) v2(61.48,40.86) v2(61.48,39.74) v2(61.67,40.3) v2(62.11,40.86) v2(62.11,39.74) v2(62.3,40.3) v2(62.75,40.86) v2(62.75,39.74) v2(62.94,40.3) v2(63.38,40.86) v2(63.38,39.74) v4(59.6,40.28)
PA_USB2_RBIAS: length 2.6
  TOP w0.102: v2(184.55,166.41) UT1.H19
  BOTTOM w0.102: v1(185.59,165.2) 185.39,165.4 RT43.1
  BOTTOM w0.127: RT43.1 185.04,166.4 185.03,166.41 v2(184.55,166.41)
PANELL_LED_B_DRV#: length 262.1
  TOP w0.102: v2(308.02,44.45) 308.12,44.35 v1(308.12,43.67) 308.12,42.62 310.7,40.04 310.7,37.67 310,36.98 UE8.14 ; v2(231.66,165.11) 231.92,165.37 JLOGO.11
  IN4 w0.102: v2(308.02,44.45) 307.58,44.01 305.4,44.01 303.75,42.36 299.63,42.36 297.54,40.28 291.95,40.28 291.14,41.09 279.24,41.09 277.96,39.82 274.17,39.82 269.01,44.98 260.94,44.98 259.18,46.74 251.16,46.74 249.48,48.42 241.21,48.42 240.92,48.13 238.47,48.13 236.37,46.03 235.7,45.36 233.61,45.36 232.81,44.56 230.4,44.56 229.76,43.92 229.34,43.92 228.52,44.74 226.64,44.74 225.89,45.49 225.35,45.49 224.53,46.3 216.54,46.3 214.53,48.31 213.35,48.31 211.04,50.61 211.04,51.64 208.31,54.37 208.31,62.24 207.91,62.64 207.91,66.14 208.36,66.59 208.36,102.13 207.77,102.72 207.77,110.94 204.62,114.09 204.62,121.91 206.13,123.42 206.13,125.56 205.71,125.98 205.65,125.98 205.08,126.54 205.08,126.95 204.75,127.28 204.75,133.3 206.09,134.65 206.09,139.89 203.77,142.22 203.77,153.96 204.51,154.71 205.24,154.71 206.13,155.6 206.13,156.88 210.46,161.21 216.24,161.21 219.02,163.99 223.21,163.99 224.17,163.04 226.64,163.04 227.34,162.34 228.87,162.34 231.64,165.11 v2(231.66,165.11)
PANELL_LED_G_DRV#: length 263.6
  TOP w0.102: UE8.11 309.96,35.48 310.27,35.78 310.27,36.67 310.93,37.33 310.93,40.13 308.61,42.46 v2(308.61,44.45) ; v2(227.72,163.35) 227.89,163.19 v1(229.21,163.19) 230.54,163.19 230.92,163.57 JLOGO.10
  IN4 w0.102: v2(308.61,44.45) 307.94,43.78 305.49,43.78 303.84,42.13 299.72,42.13 297.64,40.05 291.85,40.05 291.04,40.86 279.33,40.86 278.06,39.59 274.07,39.59 268.91,44.75 260.85,44.75 259.08,46.51 249.31,46.51 248.16,45.36 247.7,45.36 247.47,45.13 233.71,45.13 232.91,44.33 230.49,44.33 229.86,43.69 229.25,43.69 228.43,44.51 226.54,44.51 225.8,45.26 225.25,45.26 224.43,46.08 216.44,46.08 214.44,48.08 213.25,48.08 210.82,50.52 210.82,51.54 208.09,54.27 208.09,62.14 207.68,62.55 207.68,66.24 208.13,66.69 208.13,102.04 207.54,102.63 207.54,110.84 204.39,113.99 204.39,122 205.9,123.51 205.9,125.47 205.66,125.7 205.6,125.7 204.86,126.45 204.86,126.85 204.52,127.19 204.52,133.4 205.87,134.75 205.87,139.8 202.87,142.8 202.87,149.62 203.54,150.29 203.54,154.06 204.41,154.93 205.14,154.93 205.9,155.69 205.9,156.97 210.37,161.44 216.14,161.44 218.92,164.22 223.31,164.22 224.26,163.27 227.63,163.27 v2(227.72,163.35)
PANELL_LED_R_DRV#: length 263.5
  TOP w0.102: v2(309.19,44.45) 309.19,42.2 309.58,41.8 v1(310.52,41.8) 310.63,41.8 311.26,41.17 311.26,37.03 310.59,36.35 310.59,35.27 310.29,34.98 UE8.10 ; v2(227.72,163.99) 228.8,165.07 229.75,165.07 229.92,165.24 JLOGO.9
  IN4 w0.102: v2(227.72,163.99) 227.23,163.49 224.36,163.49 223.4,164.45 218.81,164.45 216.03,161.67 210.27,161.67 205.67,157.07 205.67,155.79 205.05,155.16 204.32,155.16 203.31,154.15 203.31,150.38 202.64,149.71 202.64,142.7 205.64,139.7 205.64,134.84 204.29,133.49 204.29,127.09 204.63,126.76 204.63,125.66 204.43,125.46 204.43,125.12 204.73,124.82 204.73,122.67 204.16,122.1 204.16,113.9 207.31,110.75 207.31,102.53 207.9,101.94 207.9,66.78 207.45,66.33 207.45,62.45 207.86,62.05 207.86,54.18 210.59,51.45 210.59,50.42 213.16,47.85 214.34,47.85 216.35,45.85 224.34,45.85 225.16,45.03 225.71,45.03 226.45,44.29 228.33,44.29 229.15,43.47 232.37,43.47 233.8,44.9 247.56,44.9 247.79,45.13 248.25,45.13 249.41,46.29 258.99,46.29 260.75,44.52 268.82,44.52 273.98,39.36 278.15,39.36 279.43,40.63 290.95,40.63 291.76,39.82 297.73,39.82 299.81,41.9 303.94,41.9 305.59,43.55 308.29,43.55 v2(309.19,44.45)
PANELR_LED_B_DRV#: length 258.7
  TOP w0.102: v2(233.31,164.44) 233.39,164.44 234.27,165.32 234.82,165.32 234.92,165.42 JLOGO.14 ; v2(306.35,45.69) 306.35,44.55 v1(306.45,44.45) 307.34,43.56 307.34,41.65 308.72,40.27 UE8.17
  IN4 w0.102: v2(233.31,164.44) 232.81,164.44 232.26,163.89 231.39,163.89 229.42,161.92 229.15,161.65 227.62,161.65 227.62,161.65 223.69,161.65 222.83,162.52 220.45,162.52 219.98,162.05 219.04,162.05 217.51,160.52 210.75,160.52 206.84,156.62 206.84,153.85 204.72,151.73 204.72,149.5 205.1,149.12 205.1,142.18 207.01,140.27 207.01,134.09 205.66,132.74 205.66,128.09 207.67,126.08 207.67,122.32 209.69,120.3 211.31,120.3 212.04,119.58 212.04,115.09 209.86,112.92 209.86,56.35 212.39,53.83 212.39,51.18 213.77,49.8 216.02,49.8 216.53,49.29 225.54,49.29 226.39,50.14 230.28,50.14 230.73,49.69 232.56,49.69 233.54,48.71 233.54,47.55 234.28,46.81 235.86,46.81 238.09,49.04 240.54,49.04 240.83,49.33 250.38,49.33 250.67,49.04 258.17,49.04 261.32,45.89 271.53,45.89 272.86,47.21 287.06,47.21 292.27,42.01 297.98,42.01 301.61,45.64 305.13,45.64 305.62,46.13 305.9,46.13 v2(306.35,45.69)
PANELR_LED_G_DRV#: length 260
  TOP w0.102: v2(306.93,45.69) 306.93,44.29 307.56,43.66 307.56,42.38 v1(308.1,41.85) 308.81,41.14 308.81,40.94 310.24,39.5 310.24,38.17 310.05,37.98 UE8.16 ; v2(233.29,165.03) 233.65,165.03 233.92,165.3 JLOGO.13
  IN4 w0.102: v2(233.29,165.03) 233.07,165.03 232.16,164.12 231.3,164.12 229.19,162.01 229.06,161.88 227.53,161.88 223.79,161.88 222.92,162.74 220.35,162.74 219.88,162.27 218.94,162.27 217.42,160.75 210.65,160.75 206.59,156.69 206.59,155.41 205.43,154.25 204.7,154.25 204.22,153.77 204.22,142.41 206.55,140.08 206.55,134.46 205.2,133.12 205.2,127.9 206.61,126.49 206.61,123.2 205.08,121.66 205.08,114.28 208.23,111.13 208.23,110.22 209.41,109.04 209.41,55.83 211.93,53.31 211.93,50.99 213.58,49.34 215.83,49.34 216.34,48.83 225.73,48.83 226.58,49.68 230.1,49.68 230.54,49.23 232.37,49.23 233.08,48.52 233.08,47.36 234.09,46.35 236.05,46.35 238.28,48.58 240.73,48.58 241.02,48.88 250.19,48.88 250.48,48.58 257.98,48.58 261.13,45.43 269.2,45.43 274.36,40.27 277.78,40.27 279.05,41.55 298.17,41.55 301.8,45.18 306.42,45.18 v2(306.93,45.69)
PANELR_LED_R_DRV#: length 261.3
  TOP w0.102: v2(231.66,164.53) 231.75,164.53 232.92,165.7 JLOGO.12 ; v2(307.44,44.45) 307.79,44.1 307.79,42.62 310.13,40.29 v1(310.13,40.11) 310.47,39.77 310.47,37.95 310,37.48 UE8.15
  IN4 w0.102: v2(307.44,44.45) 305.51,44.45 303.65,42.59 299.53,42.59 298.26,41.32 279.14,41.32 277.87,40.05 274.26,40.05 269.1,45.21 261.04,45.21 259.27,46.97 251.25,46.97 249.58,48.65 241.12,48.65 240.83,48.36 238.38,48.36 236.14,46.12 233.6,46.12 232.19,47.53 232.19,48.32 231.5,49 230.45,49 230,49.45 226.67,49.45 225.82,48.6 220.27,48.6 219.03,47.36 219.03,46.78 218.8,46.55 216.61,46.55 214.63,48.54 213.44,48.54 211.27,50.71 211.27,53.1 208.54,55.83 208.54,62.33 208.14,62.74 208.14,66.05 208.59,66.5 208.59,102.23 208,102.82 208,111.03 204.85,114.18 204.85,121.81 206.36,123.32 206.36,125.66 205.81,126.21 205.74,126.21 205.31,126.64 205.31,127.04 204.97,127.38 204.97,133.21 206.32,134.56 206.32,139.99 204,142.32 204,153.87 204.6,154.48 205.33,154.48 206.36,155.5 206.36,156.78 210.56,160.98 217.33,160.98 218.85,162.5 219.79,162.5 220.26,162.97 223.73,162.97 223.9,162.81 226.55,162.81 227.24,162.11 227.43,162.11 228.96,162.11 231.38,164.53 v2(231.66,164.53)
PB_USB2_RBIAS: length 4.4
  TOP w0.102: UT1.F19 183.92,167.69 v2(183.92,167.71)
  BOTTOM w0.102: 185.48,168.23 RT44.1 v1(186.33,167.77)
  BOTTOM w0.127: 185.48,168.23 184.9,168.82 184.35,168.82 184.03,168.5 184.03,167.82 v2(183.92,167.71)
PBTN_OUT#: length 122.2
  TOP w0.089: RH2.2 209.42,35.43 CH174.1 210.69,35.43 v2(211.93,34.19)
  TOP w0.114: UE5.106 303.9,13.41 303.01,14.3 v2(302.53,14.3)
  IN3 w0.127: v2(302.53,14.3) 302.53,15.08 302.92,15.47 302.92,18.94 302.24,19.62 302.24,22.32 300.34,24.23 294.08,24.23 293.51,24.8 292.36,24.8 288.85,28.31 281.23,28.31 280.53,29.01 277.17,29.01 276.47,29.71 271.51,29.71 271.32,29.52 244.89,29.52 241.02,25.65 238.86,25.65 237.56,24.35 236.25,24.35 235.91,24.01 235.91,23.32 235.27,22.68 232.74,22.68 231.76,23.65 231.01,23.65 228.04,26.62 228.04,30.24 227.33,30.95 v2(225.54,30.95)
  IN6 w0.081: v2(211.93,34.19) 211.93,33.35 213.73,31.55 219.06,31.55 219.82,30.79 223.56,30.79 223.71,30.95 v2(225.54,30.95)
  BOTTOM w0.089: UH1.AT13 212.04,34.08 v2(211.93,34.19)
PC0: length 3.1
  BOTTOM w0.102: RV625.1 RV624.1 v1(197.87,135.64) 197.87,135.47 197.52,135.11 UV21.38
PC1: length 6.1
  BOTTOM w0.102: 205.41,130.41 205.84,130.84 206.7,130.84 206.84,130.7 RV626.1 ; 205.41,130.41 RV627.1 ; 205.41,130.41 205.04,130.77 205,130.77 204.53,131.24 204.53,131.7 204.12,132.11 203.65,132.11 203.58,132.18 UV21.55
PC_BEEP: length 14.6
  TOP w0.254: DA1.1 36.93,25.43 RA9.1 38.3,23.4 38.3,22.57 v1(36.66,20.94) 35.31,19.59 32.97,19.59 31.2,21.36 RA15.1
PCH_AZ_BITCLK: length 30.5
  TOP w0.114: v2(224.63,18.6) 224.16,18.13 223.59,18.13 223.37,18.35 222.17,18.35 220.48,16.67 v1(220.33,16.67) 220.04,16.38 RP2.5
  IN1 w0.081: v2(214.59,35.17) 215.25,35.17 216.67,33.75 219.23,33.75 220.02,32.96 220.02,30.42 221.4,29.04 222,29.04 222.26,28.79 222.26,26.51 224.18,24.59 224.18,23.09 224.81,22.46 224.81,19.66 224.63,19.48 v2(224.63,18.6)
  BOTTOM w0.089: UH1.BA9 214.61,35.2 214.64,35.17 v2(214.59,35.17)
PCH_AZ_CODEC_BITCLK: length 211.1
  TOP w0.114: v2(220.27,9.62) 220.59,9.94 220.59,12.24 220.04,12.8 RP2.4
  IN3 w0.127: v2(35.51,27.15) 35.51,27.72 35.89,28.1 36.53,28.1 36.79,27.84 37.13,27.84 37.38,28.09 38.69,28.09 40.43,26.35 40.43,21.29 44.65,17.08 44.73,17.08 47.17,14.64 54.15,14.64 56.21,12.58 104.49,12.58 105.48,11.59 110.75,11.59 115.3,16.14 135.36,16.14 136.16,16.93 168.82,16.93 169.48,16.28 183.44,16.28 188.86,10.85 192.11,10.85 194.04,8.92 205.95,8.92 207.19,10.16 212.56,10.16 212.95,10.55 219.6,10.55 220.27,9.89 v2(220.27,9.62)
  BOTTOM w0.114: v2(35.51,27.15) 35.06,27.59 35.06,28.1 35.27,28.31 UA1.13 36.22,28.31 36.27,28.25 36.38,28.25 36.99,27.65 RA2.1
PCH_AZ_CODEC_RST#: length 202.7
  TOP w0.114: RP2.3 219.54,12.6 220.09,12.04 v1(220.09,11.87) 220.09,10.53 219.68,10.12 v2(219.68,9.62)
  IN3 w0.127: v2(38.81,23.99) 39.42,23.38 39.42,20.87 43.7,16.59 43.7,16.17 46.25,13.62 53.73,13.62 55.78,11.57 104.07,11.57 105.06,10.57 111.18,10.57 115.72,15.12 135.96,15.12 136.76,15.92 168.4,15.92 169.06,15.26 173.44,15.26 175.65,13.05 184.82,13.05 188.69,9.18 192.35,9.18 193.62,7.91 206.37,7.91 207.41,8.95 219.14,8.95 219.68,9.49 v2(219.68,9.62)
  BOTTOM w0.114: v2(38.81,23.99) 39.22,24.4 39.22,25.12 38.09,26.25 RA17.1
PCH_AZ_CODEC_RST#_R: length 2.9
  BOTTOM w0.114: RA17.2 36.53,26.25 36.18,26.59 35.45,26.59 35.45,26.59 35.19,26.59 35.13,26.53 34.94,26.53 34.82,26.65 UA1.15
PCH_AZ_CODEC_SDIN0: length 247.6
  IN1 w0.081: v2(218,46.98) 218,45.94 218.35,45.59 218.35,37.72 v2(218.32,37.69)
  IN3 w0.127: v2(43.03,16.49) 43.03,16.9 38.81,21.12 38.81,22.93 38.3,23.44 38.3,24.12 v2(38.74,24.57)
  IN6 w0.081: v2(174.76,36.48) 175.26,36.98 179.84,36.98 185.86,43 185.86,51.44 188.92,54.5 192.8,54.5 196.71,58.41 199.73,58.41 202.03,56.12 208.25,56.12 210.8,53.56 210.8,51.5 214.45,47.86 217.46,47.86 218,47.31 v2(218,46.98) ; v2(43.03,16.49) 43.03,16.48 43.22,16.29 48.97,16.29 50.23,15.03 54.86,15.03 57.94,11.95 72.91,11.95 75.06,14.1 81.84,14.1 86.43,18.7 91.27,18.7 93.61,16.35 125.15,16.35 127.43,18.63 156.91,18.63 159.84,21.56 v2(179.21,21.56)
  BOTTOM w0.089: UH1.BE7 216.49,36.49 216.57,36.57 216.71,36.57 217.17,37.03 217.67,37.03 v2(218.32,37.69)
  BOTTOM w0.114: v2(174.76,36.48) 175.4,35.85 175.4,29.75 179.21,25.94 v2(179.21,21.56) ; v2(38.74,24.57) 38.74,25.05 38.43,25.36 38.27,25.36 38.27,25.36 RA18.1
PCH_AZ_CODEC_SDOUT: length 205.2
  TOP w0.114: v2(218.51,9.62) 218.54,9.64 v1(218.54,12.83) RP2.1
  IN3 w0.127: v2(218.51,9.62) 218.09,9.2 207.3,9.2 206.26,8.16 193.73,8.16 192.46,9.43 188.79,9.43 184.92,13.3 175.76,13.3 173.54,15.51 169.16,15.51 168.5,16.17 136.66,16.17 135.86,15.38 115.62,15.38 111.07,10.83 105.17,10.83 104.17,11.82 55.89,11.82 53.84,13.88 46.35,13.88 43.95,16.28 43.95,16.69 39.67,20.97 39.67,24.53 38.26,25.94 35.74,25.94 v2(35.72,25.92)
  BOTTOM w0.114: UA1.17 34.02,26.61 34.58,26.04 35.6,26.04 v2(35.72,25.92) 36.03,25.62 RA10.1
PCH_AZ_CODEC_SYNC: length 205.2
  TOP w0.114: v2(219.1,9.62) 219.1,9.69 219.04,9.75 v1(219.04,10.41) RP2.2
  IN3 w0.127: v2(36.04,27.42) 36.12,27.34 37.34,27.34 37.59,27.58 38.48,27.58 39.92,26.14 39.92,21.08 44.2,16.8 44.2,16.38 46.46,14.13 53.94,14.13 56,12.07 104.28,12.07 105.27,11.08 110.96,11.08 115.51,15.63 135.75,15.63 136.55,16.43 168.61,16.43 169.27,15.77 173.65,15.77 175.86,13.56 185.44,13.56 188.65,10.34 191.9,10.34 193.83,8.41 206.16,8.41 207.4,9.65 212.77,9.65 213.16,10.04 218.74,10.04 219.1,9.69 v2(219.1,9.62)
  BOTTOM w0.114: UA1.14 36.14,27.91 36.25,27.79 36.25,27.63 v2(36.04,27.42)
PCH_AZ_RST#: length 33.2
  TOP w0.114: v2(225.76,18.5) 221.96,14.7 v1(221.55,14.7) 219.72,14.7 219.54,14.88 RP2.6
  IN1 w0.081: 219.18,36.73 219.25,36.66 219.25,35 221.37,32.87 221.37,31.54 223.14,29.77 223.14,28.3 225.21,26.23 225.21,23.31 225.69,22.83 225.69,20.67 226.15,20.21 226.15,18.89 v2(225.76,18.5)
  IN1 w0.097: 219.18,36.73 219.04,36.87 v2(218.89,36.87)
  BOTTOM w0.089: v2(218.89,36.87) 218.89,36.87 218.89,36.86 217.75,36.86 217.74,36.85 217.28,36.39 216.79,36.39 216.46,36.07 216.04,36.07 UH1.BD8
PCH_AZ_SDOUT: length 35.5
  TOP w0.097: v2(215.51,36.79) 215.51,36.8 214.99,36.8 214.83,36.95 214.83,37.33 214.41,37.76 RH16.2
  TOP w0.114: RP2.8 218.54,15.92 221.95,19.34 224.61,19.34 224.7,19.43 v1(224.71,19.43) 224.8,19.53 225.24,19.53 v2(225.69,19.08)
  IN1 w0.081: v2(225.69,19.08) 225.48,19.29 225.48,22.74 224.98,23.25 224.98,26.14 222.93,28.19 222.93,29.68 221.12,31.5 221.12,32.82 219.18,34.76
  IN1 w0.089: 219.18,34.76 218.92,35.02 218.92,36.05
  IN1 w0.097: v2(215.51,36.79) 218.17,36.79 218.92,36.05
  BOTTOM w0.089: v2(215.51,36.79) 215.51,36.8 215.18,36.8 UH1.BB7
PCH_AZ_SYNC: length 31.2
  TOP w0.114: v2(225.08,19.08) 225.07,19.09 222.21,19.09 v1(221.1,17.99) 220.95,17.99 219.04,16.08 RP2.7
  IN1 w0.081: 219.18,34.46 220.87,32.76 220.87,30.21 221.59,29.5 222.43,29.5 222.72,29.21 222.72,28.08 224.76,26.04 224.76,23.17 225.27,22.66 225.27,19.27 v2(225.08,19.08)
  IN1 w0.089: 219.18,34.46 218.63,35.01 218.63,35.16
  IN1 w0.097: v2(218,36.13) 218.63,35.5 218.63,35.16
  BOTTOM w0.089: v2(218,36.13) 217.97,36.16 216.81,36.16 216.54,35.89 216.23,35.89 215.85,35.52 UH1.BD9
PCH_BATLOW#: length 189.2
  TOP w0.107: v2(170.49,161.74) 171.57,161.74 171.74,161.91 RT14.2
  IN1 w0.102: v2(215.29,34.17) 214.82,34.64 212.67,34.64 212.23,35.08 212.23,36.54 212.61,36.93 212.61,38.89 212.1,39.4 212.1,40.05 212.78,40.73 212.78,45.31 212.61,45.49 212.61,48.42 207.4,53.62 207.4,56.92 202.19,62.14 198.06,62.14 v2(197.66,62.55)
  IN2 w0.102: v2(170.49,161.74) 171.1,161.13 171.1,157.93 171.55,157.49 171.55,156.16 171.24,155.86 171.24,154.18 173.18,152.24 183.79,152.24 188.97,147.07 188.97,126.95 181.33,119.31 181.33,105.05 179.07,102.79 179.07,93.42 177.53,91.88 177.53,84.5 175.27,82.24 175.27,71.38 188.06,58.58 192.16,58.58 192.54,58.96 192.54,59.44 192.99,59.88 193.29,59.88 196.39,62.98 197.22,62.98 v2(197.66,62.55)
  BOTTOM w0.089: v2(215.29,34.17) 215.57,34.17 215.97,33.78 UH1.BD13 216.43,33.76 216.63,33.55 218.2,33.55 218.43,33.79 218.43,34.29
  BOTTOM w0.102: v2(170.49,161.74) 170.62,161.74 v1(171.18,162.3)
  BOTTOM w0.107: 218.43,34.29 218.64,34.5 218.95,34.5 219.18,34.28 219.18,33.4 219.59,32.99 RH515.1
PCH_CPU_BCLK_N: length 97.1
  BOTTOM w0.107: UH1.H2 198.18,40.12 198.18,40.86 197.99,41.04 197.99,47.83 196.45,49.37 194.73,49.37 188.74,55.36 188.74,58.19 186.29,60.64 186.29,62.44 185.7,63.04 185.7,65.7 186.39,66.39 186.39,84.56 187.25,85.42 187.25,93.27 184.6,95.92 182.63,95.92 180.73,97.82 180.73,104.43 183.25,106.94 183.25,111.43 v3(178.92,115.76) 178.31,116.38 177.45,116.38 177.45,116.38 176.98,116.38 176.98,116.38 173.44,116.38 173.17,116.11 172.89,116.11 172.86,116.14 172.86,116.33 CPU1.A32
PCH_CPU_BCLK_P: length 97.2
  BOTTOM w0.102: UH1.G2 197.65,38.91 197.95,39.2
  BOTTOM w0.107: 197.95,39.2 197.98,39.23 197.98,40.2 197.98,40.78 197.79,40.96 197.79,47.74 196.36,49.17 194.65,49.17 188.54,55.28 188.54,58.1 186.08,60.56 186.08,62.36 185.49,62.95 185.49,65.79 186.18,66.48 186.18,84.64 187.05,85.51 187.05,93.18 184.52,95.71 182.55,95.71 180.53,97.73 180.53,104.51 183.05,107.03 183.05,111.35 178.95,115.45 178.94,115.45 178.61,115.78 178.61,115.79 178.23,116.17 v3(177.21,116.17) 173.52,116.17 173.26,115.91 172.8,115.91 172.7,116.01 CPU1.B31
PCH_CPU_PCIBCLK_N: length 100.5
  IN1 w0.089: v2(170.84,118.73) 171.08,118.57 171.2,118.6 171.28,118.72 171.51,118.94 172.54,118.94 172.86,118.62 174.41,118.62 175.1,117.93 176.15,117.93 v2(176.35,118.12)
  BOTTOM w0.076: v2(170.84,118.73) 170.84,118.73 CPU1.C36
  BOTTOM w0.107: v2(176.35,118.12) 176.52,117.95 v3(177.26,117.95) 177.89,117.95 184.07,111.77 184.07,106.24 181.55,103.72 181.55,99.79 182.31,99.04 182.79,99.04 188.07,93.76 188.07,84.52 187.2,83.66 187.2,67.88 187.58,67.5 187.58,66.1 187.11,65.62 187.11,61.09 189.68,58.52 189.68,55.69 195.13,50.25 196.77,50.25 198.95,48.06 198.95,43.49 198.59,43.12 198.59,39.56 UH1.J1
PCH_CPU_PCIBCLK_P: length 100.4
  IN1 w0.089: v2(176.35,117.58) 176.16,117.76 175.04,117.76 174.34,118.46 172.79,118.46 172.47,118.78 171.58,118.78 171.41,118.61 171.34,118.51 171.36,118.38 v2(171.61,118.22)
  BOTTOM w0.076: v2(171.61,118.22) 171.59,118.24 CPU1.D35
  BOTTOM w0.102: UH1.J2 198.65,39.11
  BOTTOM w0.107: v2(176.35,117.58) 176.52,117.75 177.03,117.75 177.03,117.75 177.5,117.75 177.5,117.75 177.81,117.75 183.87,111.69 183.87,106.33 181.35,103.81 181.35,99.71 182.22,98.84 182.71,98.84 187.87,93.67 187.87,84.61 187,83.74 187,67.79 187.38,67.41 187.38,66.18 186.9,65.7 186.9,61.01 189.48,58.43 189.48,55.61 195.05,50.04 196.68,50.04 198.75,47.97 198.75,43.57 198.38,43.2 198.38,39.39 198.65,39.11
PCH_DPWROK: length 128.6
  TOP w0.089: RH90.2 212.43,35.43 v2(212.68,35.19)
  TOP w0.114: v2(302.44,17.37) 303.42,17.37 304.64,18.58 304.64,20.72 305.73,21.81 UE5.127 ; v4(226.02,31.85) 225.7,31.53 225.37,31.53 v2(225.31,31.59)
  IN3 w0.127: v2(302.44,17.37) 302.38,17.43 300.19,17.43 299.83,17.8 299.83,19.77 300.28,20.23 301.19,20.23 301.74,20.77 301.74,22.11 300.64,23.21 292.42,23.21 287.82,27.8 278.82,27.8 278.11,28.51 276.96,28.51 276.26,29.2 271.73,29.2 271.53,29.01 245.1,29.01 241.23,25.14 239.07,25.14 236.1,22.17 231.11,22.17 229.96,23.32 228.96,23.32 227.86,24.42 227.05,24.42 226.09,25.37 226.09,26.55 226.89,27.35 226.89,28.74 225.12,30.52 225.12,31.4 v2(225.31,31.59)
  IN6 w0.081: v2(225.31,31.59) 225.24,31.53 225.05,31.53 224.83,31.75 219.54,31.75 219.38,31.91 216.99,31.91 216.29,32.61 213.24,32.61 212.35,33.5 212.35,34.86 v2(212.68,35.19)
  BOTTOM w0.089: UH1.AV11 212.68,34.96 v2(212.68,35.19)
  BOTTOM w0.114: v2(225.31,31.59) 225.31,32.83 227.06,34.58 DE4.2
PCH_JTAG_TCK: length 281.6
  TOP w0.089: v2(130.87,112.55) v4(130.87,112)
  TOP w0.114: RC35.1 125.67,156.56 v2(125.48,156.75) 125.36,156.88 125.36,157.19 122.77,159.78 122.5,159.78 121.82,160.46 120.56,160.46 120.24,160.14 JPCMC.32
  IN1 w0.081: v2(130.87,112.55) 130.87,115.01 127.2,118.68 127.2,124.45 119.06,132.59 119.06,143.97 120.7,145.62 120.7,146.49 122.46,148.24 122.46,150.09 126.37,154 126.37,155.86 v2(125.48,156.75)
  IN3 w0.089: v2(130.87,112.55) 130.47,112.16 130.47,104.27 129.7,103.5 129.7,102.52 129.44,102.26
  IN3 w0.127: 129.44,102.26 127.8,100.61 127.8,98.9 126.38,97.49 126.38,87.34 121.32,82.28 121.32,71.65 107.81,58.13 107.81,56.39 107.35,55.94 107.35,41.03 v2(107.52,40.86)
  IN6 w0.081: v2(107.52,40.86) 107.91,40.47 111.83,40.47 113.05,39.25 120.31,39.25 121.14,38.42 179.52,38.42 185.2,44.1 185.2,51.75 188.58,55.13 192.54,55.13 196.45,59.03 199.99,59.03 202.1,56.93 v2(204.71,56.93)
  BOTTOM w0.076: CPU1.BR28 133.01,113.22 132.7,112.91 131.23,112.91 v2(130.87,112.55)
  BOTTOM w0.089: UH1.AR3 211.78,38.61 211.55,38.85 211.55,39.16 211.58,39.19 211.58,40.2 212.86,41.48 212.86,42.08
  BOTTOM w0.114: v2(204.71,56.93) 205.4,56.93 207.03,55.29 207.03,54.34 210.8,50.56 210.8,50.17 213.7,47.28 213.7,44.86 212.86,44.02 212.86,42.08
PCH_PECI: length 8.9
  BOTTOM w0.089: UH1.AL3 209.51,38.61 209.27,38.85 209.27,39.17 209.35,39.25 209.35,39.67 209.42,39.73 209.42,40.76 209.28,40.9 209.28,40.92 209.11,41.09 209.11,41.75
  BOTTOM w0.114: 209.11,41.75 v1(209.11,42.81) 209.11,44.23 211.08,46.2 RH73.1
PCH_PLTRST#: length 256
  TOP w0.089: v2(218,24.35) 215.71,24.35 215.42,24.07 UH3.1 215.42,23.36 215.34,23.27 214.89,23.27 214.77,23.39 UH3.2
  TOP w0.114: v2(200.1,123.89) 199.72,123.51 199.72,121.96 197.18,119.41 194.13,119.41 193.11,118.4 187.65,118.4 186.06,116.81 184.74,116.81 181.71,113.78 181.71,99.89 182.34,99.26 183.98,99.26 185.42,97.83 185.42,96.66 188.81,93.26 188.81,71.32 191.15,68.99 191.15,67.72 191.81,67.06 v1(191.81,65.88) 191.81,61.48 v2(191.35,61.01)
  IN1 w0.081: 197.1,41.17 194.78,41.17 192.72,43.23 192.01,43.23 191.03,44.21 191.03,50.63 190.46,51.2 190.46,60.12 v2(191.35,61.01) ; v2(160.86,171.86) 160.85,171.86 160.85,171.86 160.93,171.86 161.79,171 162.79,171 163.27,171.48 163.27,172.99 164.27,174 168.67,174 169.84,175.17 171.07,175.17 171.92,176.02 174.6,176.02 175.21,175.41 180.33,175.41 180.91,174.83 182.44,174.83 183.53,173.75 187.58,173.75 188.13,173.2 190.56,173.2 193.37,170.39 196.8,170.39 198.08,169.11 199.88,169.11 201.67,167.32 201.67,166.34 201.4,166.07 201.4,165.41 202.57,164.24 202.57,160.85 201.66,159.94 201.66,159.27 202.67,158.26 202.67,154.75 205.07,152.34 207.19,152.34 207.47,152.06 207.47,150.53 203.91,146.97 203.91,142.34 204.66,141.59 204.66,137.67 202.34,135.35 202.34,134.5 203.1,133.74 203.1,130.46 202.19,129.55 202.19,128.18 201.22,127.2 199.46,127.2 199.38,127.2 198.48,126.31 198.48,125.22 199.34,124.37 199.64,124.37 200.1,123.9 v2(200.1,123.89)
  IN1 w0.097: v2(218,24.35) 217.31,25.05 216.47,25.05 215.9,25.62 215.42,25.62 215.18,25.86 211.38,25.86 210.47,26.77 210.19,26.77 209.9,27.06 209.9,27.56 209.68,27.77 209.44,27.77 208.67,28.54 208.67,29.89 208.43,30.13 208.1,30.13 207.28,30.95 204.76,30.95 203.81,31.89 203.81,37.23 202.28,38.76 201.25,38.76 200.55,39.46 200.55,40.93 200.31,41.17 197.1,41.17
  BOTTOM w0.089: v2(218,24.35) 218.16,24.51 218.16,26.17 217.16,27.17 215.34,27.17 UH1.BB27
  BOTTOM w0.114: UG10.2 200.76,122.45 200.87,122.55 200.87,123.47 200.44,123.89 v2(200.1,123.89) ; v2(160.86,171.86) 160.85,171.86 160.85,171.86 160.58,171.86 160.47,171.98 UM3.2
PCH_PWR_EN: length 136
  TOP w0.114: v2(311.35,17.83) 311.16,17.64 311.16,14.04 RE74.1 ; v2(242.66,21.86) 242.39,21.86 241.16,20.64 241.16,20.33 240.48,19.65 240.48,18 240.92,17.56 PR300.1 ; C268.1 224.34,44.69 U18.4 225.58,44.72 v1(232.11,44.72) 233.46,43.38 233.46,41.5 235.75,39.21 235.75,38.72 235.4,38.36 234.03,38.36 233.26,37.59 233.26,35.77 233.72,35.31 236.17,35.31 238.26,33.21 238.26,31.61 239.09,30.77 239.09,22.41 238.09,21.41 238.09,19.54 v2(238.3,19.34)
  IN6 w0.081: v2(311.35,17.83) 310.76,17.24 305.57,17.24 303.45,19.36 299.19,19.36 299.02,19.19 273.48,19.19 271.85,20.82 271.67,20.82 270.93,21.57 266.24,21.57 265.12,22.7 265.12,25.1 263.02,27.19 248.72,27.19 243.39,21.86 v2(242.66,21.86) 240.14,19.34 v2(238.3,19.34)
PCH_PWROK: length 104.8
  TOP w0.114: RE75.1 CE44.1 ; CE44.1 293.14,25.46 UE5.32 ; CE44.1 293.37,25.48 293.76,25.88 v2(293.76,27.1) ; v4(225.33,33.75) 225.2,33.62 v2(224.74,33.62)
  IN3 w0.127: v2(293.76,27.1) 293.76,27.38 288.16,32.97 283.93,32.97 283.16,33.74 277.92,33.74 277.23,34.43 273.64,34.43 265.34,42.73 250.65,42.73 247.46,39.55 247.46,37.83 246.22,36.58 241.34,36.58 236.84,32.07 235.63,32.07 235.24,32.47 234.31,32.47 233.38,31.54 230.76,31.54 229.82,32.48 227.02,32.48 225.88,33.62 v2(224.74,33.62)
  IN6 w0.081: v2(224.74,33.62) 224.14,33.62 223.19,32.67 219.96,32.67 219.46,33.18 219.02,33.18 218.87,33.33 215.56,33.33 215.21,33.69 212.99,33.69 212.73,33.94 212.73,34.7 v2(213.22,35.19)
  BOTTOM w0.089: v2(213.22,35.19) 213.22,35.1 213.65,34.67 UH1.AW11
  BOTTOM w0.114: DE3.2 223.64,34.71 v2(224.74,33.62)
PCH_RTCRST#: length 160.4
  TOP w0.089: CH53.1 216.43,41.55 216.43,37.25 216.24,37.06 RH84.2 217.17,36.68 v4(217.47,36.38) 217.56,36.29 v2(217.56,35.12)
  TOP w0.114: QE5.1 285.99,22.46 285.99,24.73 v2(284.93,25.79)
  IN4 w0.089: 219.18,34.28 218.85,34.61 218.07,34.61 v2(217.56,35.12)
  IN4 w0.127: v2(284.93,25.79) 284.87,25.85 277.67,25.85 276.65,26.86 270.48,26.86 266.47,22.85 265.45,22.85 263.98,21.38 257.96,21.38 256.49,22.85 256.49,23.23 256.12,23.6 242.15,23.6 239.23,26.53 239.23,30.37 240.37,31.52 240.37,33.21 239.78,33.8 239.78,35.32 238.93,36.18 225.19,36.18 223.17,34.16 219.31,34.16 219.18,34.28
  IN6 w0.081: v2(217.56,35.12) 216.82,35.12 216.23,35.72 216.23,36.86 215.46,37.62 215.46,37.82 215.15,38.13 213.75,38.13 213.37,37.75 211.21,37.75 210.64,37.18 210.64,36.42 209.75,35.53 209.11,35.53 208.54,34.96 208.54,34.07 208.16,33.69 207.53,33.69 207.15,33.31 207.15,32.35 206.7,31.91 206.7,31.21 206.16,30.67 205.4,30.67 204.1,29.37 200.73,29.37 199.18,27.82 193.27,27.82 192.59,28.49 190.25,28.49 189.06,29.69 187.65,29.69 186.46,28.49 184.66,28.49 183.95,27.78 182.7,27.78 180.97,26.06 v2(173.94,26.06)
  BOTTOM w0.089: UH1.BC10 215.65,34.79 217.47,34.79 217.56,34.87 v2(217.56,35.12)
  BOTTOM w0.114: CLRP1.1 v2(173.94,26.06)
PCH_RTCX1: length 7.8
  BOTTOM w0.089: UH1.BC9 215.36,35.52 215.59,35.28 215.93,35.28 216.12,35.48 216.12,35.54 216.26,35.67 216.57,35.67 216.79,35.89 217.26,35.89 217.38,35.76 218.39,35.76 RH70.1
  BOTTOM w0.107: RH70.1 219.16,36.53 219.16,36.55 219.18,36.57
  BOTTOM w0.114: YH1.1 221.31,37.46 221.1,37.25 219.83,37.25 CH45.1 219.66,37.04 219.55,36.93 219.53,36.93 219.18,36.57
PCH_RTCX2: length 6.9
  BOTTOM w0.089: UH1.BD10 216.07,34.96 216.89,34.96 217.51,35.59 218.43,35.59 RH70.2
  BOTTOM w0.107: RH70.2 219.16,35.62 219.16,35.65 219.18,35.67
  BOTTOM w0.114: 219.18,35.67 CH46.1 219.81,36.3 221.13,36.3 221.31,36.11 YH1.2
PCH_SATADET#: length 100.5
  TOP w0.356: v2(126.31,19.46) 125.04,18.19 v1(125.04,16.4) 125.04,11.97 124.53,11.46 RS8.1
  TOP w0.508: v2(204.92,16.04) 204.92,16.03 204.87,15.98 RH512.1
  IN2 w0.254: 196.22,19.65 196.22,19.15 196.35,19.02 196.35,18.26 196.6,18 197.05,18 197.3,18.26 197.3,19.46 197.11,19.65 196.22,19.65
  IN2 w0.508: 196.22,19.65 195.91,19.97 194.95,19.97 193.81,18.83 193.56,18.83 193.18,18.45 190.57,18.45 189.62,17.49 183.17,17.49 180.48,20.19 169.37,20.19 168.83,19.65 148.6,19.65 147.65,20.61 127.45,20.61 v2(126.31,19.46) ; 197.3,18.26 197.56,18 198.64,18 200.22,16.42 202.45,16.42 202.82,16.04 v2(204.92,16.04)
  BOTTOM w0.203: v2(204.92,16.04) 204.92,16.26 205.34,16.68 205.53,16.68 206.07,17.22 206.07,18.09 UH1.AD44
PCH_SMBCLK: length 120.8
  TOP w0.089: RH463.2 213.57,15.6 214.27,16.3 214.27,16.97 v2(214,17.24)
  TOP w0.114: v2(178.55,55.32) 178.86,55.01 181.2,55.01 182.14,55.95 182.14,58.04 186.41,62.31 186.41,62.72 186.23,62.9 185.99,62.9 185.74,63.15 US1.4
  IN6 w0.081: v2(179.65,45.59) 179.44,45.39 179.23,45.39 179.1,45.52 179.1,45.83 180.67,47.4 180.67,53.6 179.17,55.1 178.76,55.1 v2(178.55,55.32)
  BOTTOM w0.089: v2(214,17.24) 213.76,17.49 213.76,18.02 213.51,18.27 UH1.AW44
  BOTTOM w0.114: v2(178.55,55.32) 178.31,55.09 177.81,55.09 177.37,55.53 177.37,58.29 176.69,58.96 JDIMM1.253 ; JDIMM2.253 176.69,45.91 177.62,44.99 178.42,44.99 178.8,45.37 179.43,45.37 v2(179.65,45.59) 179.88,45.36 180.74,45.36 181.3,44.8 181.3,26.07 182.13,25.24 183.65,25.24 185.81,23.08 185.81,16.42 189.67,12.55 189.67,12.05 189.82,11.9 JTP.15 189.82,10.3 189.68,10.17 189.68,7.47 190.89,6.26 200.27,6.26 202.21,8.2 202.21,9.4 203.45,10.64 209.35,10.64 210.17,11.46 214.39,11.46 215.97,13.04 215.97,15.44 215.19,16.21 214.62,16.21 214.19,16.64 214.19,17.05 v2(214,17.24)
PCH_SMBDATA: length 124.2
  TOP w0.089: RH462.2 214.32,16.1 214.45,16.22 214.45,17.11 v2(214.58,17.24) 214.58,17.62 214.7,17.74 v2(214.7,18.26)
  TOP w0.114: US1.6 187.39,65.13 187.51,65.01 187.51,64.8 186.95,64.25 186.95,63.44 186.65,63.13 186.65,62.21 182.38,57.94 182.38,55.85 181.3,54.77 178.58,54.77 v2(178.55,54.74)
  IN6 w0.081: v2(179.65,45.01) 179.47,45.18 179.14,45.18 178.89,45.43 178.89,45.92 180.46,47.49 180.46,53.52 179.08,54.9 178.7,54.9 v2(178.55,54.74)
  BOTTOM w0.089: UH1.BB43 214.7,18.58 v2(214.7,18.26)
  BOTTOM w0.114: v2(214.58,17.24) 214.4,17.06 214.4,16.72 214.7,16.42 215.28,16.42 216.21,15.48 216.21,12.94 214.49,11.22 210.27,11.22 209.45,10.4 203.55,10.4 202.45,9.3 202.45,8.1 200.37,6.02 190.79,6.02 189.44,7.37 189.44,10.18 189.32,10.3 JTP.16 189.32,11.9 189.43,12.01 189.43,12.45 185.57,16.32 185.57,22.98 183.55,25 182.03,25 181.06,25.97 181.06,44.7 180.64,45.12 179.76,45.12 v2(179.65,45.01) 179.53,45.13 178.9,45.13 178.52,44.75 177.71,44.75 177.6,44.63 177.6,43.48 177.32,43.21 177.32,40.87 176.95,40.49 176.95,40.18 176.94,40.18 JDIMM2.254 ; JDIMM1.254 176.94,53.21 177.45,53.71 177.45,54.54 177.76,54.85 178.44,54.85 v2(178.55,54.74)
PCH_SPI_CLK: length 14.5
  BOTTOM w0.114: UH4.6 226.76,16.66 226.39,16.29 225.12,16.29 224.93,16.1 224.93,15.26 224.81,15.15 224.58,15.15 224.47,15.26 224.47,17.51 224.35,17.62 224.13,17.62 224.01,17.51 224.01,15.2 223.9,15.08 223.52,15.08 223.4,15.2 223.4,19.37 RH104.1
PCH_SPI_CLK_R: length 11.3
  BOTTOM w0.089: 219.18,20.01 219.16,20.01 v1(218.37,20.8) 217.69,20.8 217.55,20.94 217.55,23.19 216.92,23.83 216.92,24.35 216.49,24.77 216.27,24.77 216,25.04 215.84,25.04 215.46,24.66 UH1.BC31
  BOTTOM w0.114: 219.18,20.01 221.65,20.01 222.08,19.58 RH104.2
PCH_SPI_CS#: length 34.3
  BOTTOM w0.114: UH1.BD31 216.11,24.66 216.23,24.54 216.45,24.54 216.72,24.27 216.72,23.75 217.36,23.11 217.36,20.86 218.72,19.51 219.52,19.51 RH74.2 219.21,18.8 219.21,18.38 219.21,18.38 219.21,14.81 218.94,14.55 v1(218.94,13.21) 219.12,13.04 219.44,13.04 219.56,13.15 219.56,13.25 219.67,13.37 219.9,13.37 220.01,13.25 220.01,13.15 220.13,13.04 220.36,13.04 220.47,13.15 220.47,13.25 220.59,13.37 220.81,13.37 220.93,13.25 220.93,13.15 221.04,13.04 221.27,13.04 221.39,13.15 221.39,13.63 221.5,13.75 221.73,13.75 221.84,13.63 221.84,13.15 221.96,13.04 222.11,13.04 222.23,13.15 222.23,13.63 222.34,13.75 222.57,13.75 222.68,13.63 222.68,13.15 222.8,13.04 223.03,13.04 223.14,13.15 223.14,13.63 223.25,13.75 223.48,13.75 223.6,13.63 223.6,13.15 223.71,13.04 223.94,13.04 224.05,13.15 224.05,13.63 224.17,13.75 224.4,13.75 224.51,13.63 224.51,13.15 224.63,13.04 224.85,13.04 224.97,13.15 224.97,13.63 225.08,13.75 225.31,13.75 225.43,13.63 225.43,13.15 225.54,13.04 225.95,13.04 226.07,13.15 226.07,13.68 225.63,14.12 UH4.1
PCH_SPI_HOLD#: length 18.2
  IN6 w0.081: v2(221.99,20.37) 221.89,20.48 220.67,20.48 220.59,20.4 220.59,20.17 220.67,20.09 221.23,20.09 221.31,20.01 221.31,19.85 221.23,19.77 220.67,19.77 220.59,19.69 220.59,19.52 220.67,19.44 220.84,19.44 220.93,19.36 220.93,19.2 220.84,19.12 220.67,19.12 220.59,19.04 220.59,18.92 220.67,18.84 221.03,18.84 221.12,18.76 221.12,18.6 221.03,18.52 220.67,18.52 220.59,18.44 220.59,18.27 220.67,18.19 221.03,18.19 221.12,18.11 221.12,17.95 221.03,17.87 220.82,17.87 220.73,17.79 220.73,17.56 220.92,17.38 222.25,17.38 v2(222.64,16.99)
  BOTTOM w0.114: UH4.7 226.63,15.39 225.81,14.57 222.75,14.57 222.64,14.69 v2(222.64,16.99) ; RPH5.4 221.86,20.5 v2(221.99,20.37)
