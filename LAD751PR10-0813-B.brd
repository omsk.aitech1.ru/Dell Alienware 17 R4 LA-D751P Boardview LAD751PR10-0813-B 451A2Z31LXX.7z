# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCIO: length 5.1
  BOTTOM w0.203: v2(154.32,101.1) 154.19,101.07 CPU1.AG12
  BOTTOM w0.508: v2(170.63,90.52) 170.95,90.2 RC2.1 ; v2(175.14,117.21) 175.14,118.4 176.35,119.6 RC30.2
  vias: v2(124.41,99.53) v2(124.88,99.97) v2(125.36,100.3) v2(125.8,100.74) v2(165.6,111.51) v2(165.6,110.94) v2(167.28,112.46) v2(168.47,89.25) v2(168.76,106.99) v2(168.76,104.56) v2(168.92,88.81) v2(169.05,91.41) v2(169.36,88.36) v2(169.42,106.2) v4(169.44,107.61)
+VCCIOP: length 18.5
  TOP w0.508: v2(122.75,122.84) 122.75,122.15 124.04,120.86 124.04,119.87 122.75,118.59 v1(122.75,117.7) v2(122.75,106.84)
  BOTTOM w0.508: PR5014.1 122.11,122.82 PC818.1 122.75,122.84 v2(122.75,122.84)
+VCCSA: length 0.9
  BOTTOM w0.508: RH201.2 173.7,123.4 v2(174.07,123.03)
  vias: v2(166.06,119.22) v2(166.05,118.58) v2(166.06,117.95) v2(166.05,117.28) v2(166.06,116.62) v2(166.05,115.98) v2(166.06,115.35) v2(166.07,122.63) v2(166.13,122.01) v2(166.13,121.38) v2(166.67,122.62) v2(166.84,119.23) v2(166.87,117.94) v2(166.84,116.63) v2(166.84,115.98) v2(167.62,116.63) v2(180.5,127.98) v2(180.5,127.35) v2(180.78,129.23) v2(180.78,128.59) v2(181.14,127.98) v2(181.14,127.35) v2(181.42,129.23) v2(181.42,128.59) v2(181.77,127.98) v2(181.77,127.35) v2(182.05,129.23) v2(182.05,128.59) v2(182.41,127.98) v2(182.41,127.35) v2(182.69,129.23) v2(182.69,128.59) v2(183.07,128) v2(183.32,129.23) v2(183.32,128.59) v2(183.87,128.92) v4(180.16,128.86)
+VCCST: length 90.7
  TOP w0.381: v2(173.63,98.01) 174.26,98.64 RH164.1
  TOP w0.508: CH108.1 167.94,114.76 RH163.1 ; v2(123.35,131.43) 123.33,131.44 123.33,132.51 123.69,132.87 PC502.1 PR501.1 PR502.1 PR503.1
  IN2 w0.508: v2(128.34,115.16) 128.08,115.16 127.57,115.67 127.57,118.66 126.12,120.11 v2(125.54,120.11)
  IN3 w0.508: v2(123.35,131.43) 126.48,128.3 126.48,121.04 v2(125.54,120.11)
  IN4 w0.508: v2(128.34,115.16) 128.08,115.16 127.64,115.59 127.64,122.45 129.49,124.3 132.28,124.3 132.79,124.81 147.1,124.81 149.48,122.43 155.35,122.43 155.96,123.05 155.96,123.53 156.58,124.15 162.42,124.15 164.43,122.14 164.6,122.14 165.11,121.63 165.11,113.95 165.93,113.13 167.21,113.13 v2(167.35,113.27)
  BOTTOM w0.203: v2(168.78,114.83) 168.78,114.99 168.58,115.19 CPU1.H30 ; v2(167.35,113.27) CPU1.J28 CPU1.H28
  BOTTOM w0.508: v2(128.34,115.16) 128.62,114.88 RH156.1 ; RH151.1 RH152.1 126.46,119.77 126.46,119.77 126.08,119.77 125.74,120.11 v2(125.54,120.11)
  vias: v2(173.18,92.74) v2(173.56,92.29) v2(173.94,91.85) v2(174.45,91.47) v2(174.9,91.02) v4(175.85,82.65)
+VCCSTG: length 104.4
  TOP w0.203: v4(173.19,113.29) 172.5,113.98 CH105.1
  TOP w0.254: v2(172.01,116.41) 172.5,115.92 CH106.1 CH105.1
  TOP w1.016: 178.25,98.14 179.08,98.14 181.87,95.35 183.72,95.35 186.69,92.38 186.69,86.25 185.49,85.06 183.33,85.06 182.13,83.85
  IN3 w0.254: v2(172.01,116.41) 171.57,116.85 170.29,116.85 169.42,115.97 v2(168.38,115.97)
  IN4 w0.508: v2(127.59,113.89) 127.59,114.7 v2(126.12,116.17) 125.93,116.17 125.91,116.19 125.86,116.19 125.42,116.63 125.42,118.24 127.01,119.83 127.01,122.71 129.23,124.94 132.02,124.94 132.59,125.51 147.3,125.51 149.78,123.03 154.85,123.03 155.33,123.51 155.33,123.79 156.66,125.13 158.06,125.13 160.09,127.16 167.71,127.16 171.01,123.86 171.97,123.86 172.47,123.35 172.47,118.29 171.84,117.65 171.32,117.65 169.58,115.92 169.07,115.92 169.02,115.97 v2(168.38,115.97)
  BOTTOM w0.203: v2(168.38,115.97) 168.38,115.93 CPU1.G30
  BOTTOM w0.254: CPU1.H29 168.43,114.4 v2(168.8,114.03)
  BOTTOM w0.508: RH165.1 126.59,115.83 126.25,116.17 v2(126.12,116.17)
  vias: v2(176.6,98.14) v2(177.24,98.14)
+VDD_TOUCH: length 0.9
  BOTTOM w0.203: v1(168.26,170.4) 167.75,170.91 v2(167.59,170.91)
  vias: v2(167.59,171.55) v2(167.86,181.97) v2(167.85,181.32)
+VDDCT_L:
  vias: v1(253.08,155.77) v2(248.67,157.51) v2(249.31,157.51) v2(256.68,157.58) v2(256.68,156.88)
GND: length 8655.8
  TOP w0.102: v2(182.62,170.54) 182.62,170.32 182.82,170.11 UT1.A16 UT1.B16 ; v2(181.59,170.53) 181.59,170.37 181.9,170.06 UT1.A14 UT1.B14 ; UT1.B20 UT1.A20 184.66,170.48 184.77,170.59 v2(184.79,170.59) ; v2(183.74,170.53) UT1.A18 UT1.B18
  TOP w0.178: v2(175.38,158.68) 175.92,159.22 UT1.AC1 UT1.AC2 ; UT1.AB16 UT1.AC16 182.82,159.1 v2(182.89,159.04) ; UT1.P2 UT1.P1 175.74,163.86 175.5,164.1 175.5,164.39 v2(175.33,164.56) ; UT1.H2 UT1.H1 ; v2(186.81,168.39) 186.81,168.38 186.43,168 UT1.E23 UT1.E22 ; UT1.K2 UT1.K1 175.58,165.7 v2(175.4,165.51) ; UT1.G22 UT1.G23 186.94,167.08 v2(187.07,167.22) ; UT1.B10 UT1.A10 180.06,170.31 v2(179.97,170.4) ; v2(185.07,158.66) 185.07,158.91 184.66,159.32 UT1.AC20 UT1.AB20 ; 188.3,170.09 187.81,170.09 187.51,169.79 186.96,169.79 186.09,168.92 UT1.C23 UT1.C22 ; v2(179.14,170.47) UT1.A8 UT1.B8 ; UT1.W22 UT1.W23 ; v2(180.98,170.38) UT1.A12 UT1.B12 ; v2(180.78,159.03) 180.78,159.05 180.79,159.06 180.79,159.23 180.98,159.41 UT1.AC12 UT1.AB12 ; UT1.AB2 UT1.AB1 175.71,160.18 175.56,160.03 175.56,159.48 v2(175.36,159.29) ; v2(181.82,159.03) 181.9,159.11 UT1.AC14 UT1.AB14 ; UT1.N23 UT1.N22 ; v2(183.84,159.05) 183.74,159.15 UT1.AC18 UT1.AB18 ; UT1.M2 UT1.M1 ; v2(179.77,159) 179.77,159.14 180.06,159.43 UT1.AC10 UT1.AB10 ; UT1.AC6 UT1.AB6 ; UT1.B6 UT1.A6 ; v2(186.48,160.47) 186.31,160.64 UT1.AA23 UT1.AA22 ; v2(186,170.4) 185.58,169.98 UT1.A22 UT1.B22 ; v2(186.57,165.23) 186.56,165.24 UT1.L23 UT1.L22 ; UT1.J22 UT1.J23 186.68,166.16 v2(186.76,166.25) ; v2(186.54,163.31) 186.45,163.4 186.04,163.4 UT1.R23 UT1.R22 ; UT1.AC8 UT1.AB8 ; v2(185.97,159.24) 185.58,159.63 UT1.AC22 UT1.AB22 ; UT1.U23 UT1.U22 ; UT1.T1 UT1.T2
  TOP w0.2: v2(247.67,95.45) 247.02,95.45 246.72,95.75
  TOP w0.203: UE5.11 301.54,21.78 v2(301.32,21.56) ; CT38.2 190.22,168.21 190.65,168.21 v2(190.81,168.04) ; UT1.Y9 179.57,160.99 179.57,161.43 UT1.W9 179.56,161.65 179.56,162.06 UT1.V9 ; UT1.Y9 179.14,160.34 UT1.AB8 178.82,160.5 178.49,160.5 178.22,160.23 UT1.AB6 ; UT1.Y9 180.06,160.5 UT1.AB10 ; v2(290.06,21.3) 290.17,21.41 UE5.35 ; UE5.94 304.74,7.15 305.02,6.86 v2(305.02,6.75) ; UA4.39 30.47,8.45 v2(29.53,8.45) ; JPCMC.19 117.47,153.87 v2(117.47,153.63) ; v2(39.06,8.8) 38.74,8.8 38.36,8.41 UA4.4 ; UT1.D5 177.4,169.01 176.94,169.01 176.75,168.82 176.75,168.37 UT1.E4 ; v2(296.88,22.46) 296.34,23 UE5.24 ; v2(305.93,16.67) 305.94,16.66 305.94,16.49 306.21,16.21 UE5.113
  TOP w0.229: DT7.2 v2(194.72,174.12) ; DT6.2 v2(197.28,174.12)
  TOP w0.25: 246.72,101.75 v2(247.67,101.75)
  TOP w0.254: CG125.2 262.77,60.07 v2(262.74,60.11) ; 195.96,107.86 RG101.2 195.25,107.86 194.93,108.17 194.93,108.59 195.12,108.78 UG16.6 ; v2(332.28,43.69) 332.48,43.69 332.74,43.95 UE6.12 ; UE10.12 319.97,58.94 v2(320.3,59.28) ; JEDP.3 v2(152.62,179.37) ; v2(193.98,111) 194.04,110.94 194.45,110.94 195.11,110.28 UG16.3 ; v2(259.53,74.33) 259.53,75.74 262.71,78.91 262.71,84.14 262.42,84.43 v2(261.12,84.43) ; 169.9,163.39 169.96,163.33 170.48,163.33 v2(170.51,163.35) ; 169.9,163.39 RT41.2 ; 169.9,163.39 RT35.2 ; v2(307.44,30.93) 307.44,31.24 308.22,32.02 UE8.7 ; v2(230.75,160.1) 230.75,160.51 230.51,160.76 UE3.18 ; v2(133.98,106.73) 133.84,106.59 133.84,105.8 RH186.2 ; v2(230.75,157.11) 230.75,156.8 230.51,156.55 UE3.7 ; DT11.2 191.65,173.72 191.95,173.42 192.25,173.42 v2(192.88,172.79) ; UE4.18 189.93,18.69 189.68,18.45 v2(189.35,18.45) ; v2(190.81,168.04) v2(190.81,167.13) 190.81,167.04 190.95,166.9 190.95,165.58 191.21,165.32 v2(191.75,165.32) v2(192.9,165.32) 193.75,165.32 v2(193.87,165.2) ; v2(214.69,24.87) 214.69,24.79 214.12,24.22 UH3.3 ; 188.3,170.09 189.67,170.09 CT37.2 ; DT13.2 194.7,176.24 194.34,176.6 194.28,176.6 v2(194.26,176.63) ; v2(224.97,111.85) 225.18,111.64 225.18,110.95 CG236.2 ; YT1.4 194.67,166.28 195.09,166.71 195.09,167.75 v2(195.53,168.18) 195.53,168.84 193.7,170.67 191.4,170.67 191.2,170.87 190.55,170.87 v2(190.38,171.04) ; DU13.3 11.36,58.76 v2(11.38,58.77) ; JIO.22 324.88,20.36 324.56,20.03 v2(324.56,19.85) ; RT34.2 172.37,162.11 v2(172.35,162.08) ; JEDP.15 v2(158.62,181.26) ; v2(166.26,181.78) 166.12,181.64 JEDP.30 ; v2(150.72,179.37) JEDP.41 ; JIO.10 324.88,14.36 324.62,14.61 v2(324.62,14.85) ; UE4.23 191.44,21.19 191.53,21.11 v2(191.54,21.11) ; JEDP.12 v2(157.12,179.37) ; v2(9.03,63.26) 9.04,63.28 DU12.3 ; JEDP.9 v2(155.62,179.37) ; v2(196.9,176.82) DT12.2 ; CH105.2 CH106.2 173.41,115.46 173.74,115.79 v2(174,115.79) ; v2(324.62,23.36) 324.63,23.36 JIO.28 ; JEDP.29 v2(165.62,181.81) ; v2(324.65,21.85) JIO.25 ; UE10.23 314.85,56.94 v2(314.59,56.67) ; UE4.7 184.61,18.69 184.52,18.79 v2(184.51,18.79) ; UE8.23 v2(305.72,39.66) ; UE8.18 v2(308.22,39.59) ; JUSBC2.A12 7.79,57.42 ; JIO.13 324.93,15.85 v2(324.59,16.2) ; v2(227.85,162.78) 227.85,162.3 228.01,162.14 UE3.23 ; RT36.2 171.27,163.89 171.15,163.77 171.15,163.56 v2(171.08,163.48) ; JEDP.6 v2(154.12,179.37) ; JUSBC2.A1 v2(8.37,62.92) ; RU2.1 19.87,44.83 UU1.14 ; DT14.2 188.16,176.54 188.82,177.2 189.81,177.2 v2(190,177.01)
  TOP w0.279: v2(5.66,57.17) 5.56,57.26 5.56,57.46 5.56,57.46 5.78,57.68 JUSBC2.B1 ; v2(8.44,57.23) 8.24,57.42 7.79,57.42
  TOP w0.3: v2(230.52,95.75) 230.61,95.84 231.83,95.84 v2(231.92,95.75) ; v2(240.32,101.45) 239.67,101.45 239.65,101.47 238.94,101.47 v2(238.92,101.45) v2(238.22,101.45) ; v2(228.42,92.95) v2(229.12,92.95) ; CG233.2 245.87,91.47 245.87,92.4 245.86,92.41 245.86,93.25 245.59,93.25 245.29,92.95 v2(245.22,92.95) v2(244.52,92.95) ; 246.01,99.41 246.01,98.65 ; v2(245.22,100.05) 244.57,100.05 v2(244.52,100.02) ; v2(228.42,95.75) v2(229.12,95.75) ; 223.59,110.25 223.27,110.25 v2(223.22,110.2) ; v2(235.42,97.15) v2(234.72,97.15) v2(233.32,97.15) v2(231.92,97.15) ; v2(229.12,91.55) v2(228.42,91.55) ; v2(245.22,101.45) v2(244.52,101.45) ; v2(238.92,100.05) v2(238.22,100.05) ; v2(244.52,97.15) v2(245.22,97.15) ; v2(234.72,100.05) v2(235.42,100.05) ; v2(235.42,94.35) v2(234.72,94.35) 234.59,94.22 233.45,94.22 v2(233.32,94.35) ; v2(230.52,94.35) 230.61,94.26 231.83,94.26 v2(231.92,94.35) ; v2(235.42,95.75) v2(234.72,95.75) 234.7,95.73 233.34,95.73 v2(233.32,95.75) ; v2(228.42,99.25) v2(229.12,99.25) ; v2(244.52,95.75) v2(245.22,95.75) 246.72,95.75 ; v2(243.12,102.85) 243.04,102.93 241.8,102.93 v2(241.72,102.85) ; v2(228.42,94.35) v2(229.12,94.35) ; v2(244.52,102.85) v2(245.22,102.85) ; v2(244.52,94.35) v2(245.22,94.35) ; v2(244.52,91.55) v2(245.22,91.55) ; v2(240.32,102.85) v2(238.92,102.85) v2(238.22,102.85) ; v2(238.92,91.55) v2(238.22,91.55)
  TOP w0.305: v2(233.79,59.86) 233.79,59.77 RG131.2 ; v2(228.42,101.45) v2(229.12,101.45) 229.52,101.85 PC6336.2 230.12,101.85 v2(230.52,101.45) 230.78,101.71 PC6307.2 231.66,101.71 v2(231.92,101.45) 232.18,101.71 PC6348.2 233.06,101.71 v2(233.32,101.45) 233.58,101.71 PC6351.2 234.46,101.71 v2(234.72,101.45) v2(235.42,101.45) 235.81,101.45 PC6413.2 236.43,101.45 v2(236.82,101.45) ; U20.5 183.6,81.64 183.3,81.95 182.84,81.95 C10.2 ; CG194.2 252.13,81.19 v2(252.17,81.15) ; v2(235.42,95.75) 235.57,95.6 PC6362.2 236.67,95.6 v2(236.82,95.75) ; PC6391.2 233.23,91.55 v2(234.72,91.55) v2(235.42,91.55) 235.6,91.55 PC6361.2 236.64,91.55 v2(236.82,91.55) ; PC6391.2 233.67,92.95 v2(234.72,92.95) v2(235.42,92.95) 235.75,92.62 PC6411.2 236.48,92.62 v2(236.82,92.95) ; PC6391.2 231.83,92.95 v2(230.52,92.95) ; PC6391.2 232.27,91.55 v2(230.52,91.55) 230.33,91.74 PC6342.2 229.31,91.74 v2(229.12,91.55) ; v2(245.22,102.85) 245.5,102.57 PC6329.2 ; PC6347.2 245.56,104.59 v2(245.22,104.25) ; v2(238.92,91.55) 238.94,91.57 PC6334.2 ; CG275.2 222.37,78.27 v2(222.5,78.4) ; v2(184.66,67.96) 184.62,67.96 ; 184.62,67.96 184.74,67.85 US1.12 ; 184.62,67.96 184.24,67.58 US1.13 ; C6.2 179.33,81.81 179.28,81.76 U19.5 ; v2(229.12,104.25) v2(228.42,104.25) ; v2(274.55,108.96) 274.59,109 RG107.2 ; v2(222.99,60.91) 222.48,60.91 RG128.2 ; CG184.2 226.21,56.93 v2(226.19,56.91) ; v2(241.19,52.91) 240.78,52.5 CG151.2 ; RE523.2 230.55,20.63 230.27,20.91 QE52.4 ; v2(274.55,94.76) 274.89,94.42 RG106.2 ; RG109.2 277.55,105.56 v2(277.6,105.51) ; v2(185.74,67.95) US1.10 ; v2(245.44,59.91) 245.55,59.8 RG127.2 ; v2(251.59,59.31) 251.61,59.33 RG56.2 ; CG230.2 224.21,109.9 223.86,110.25 223.59,110.25 ; v2(234.72,105.65) v2(235.42,105.65) 235.5,105.65 PC6408.2 236.74,105.65 v2(236.82,105.65) ; CG269.2 270.01,113.22 v2(270.55,113.76) ; v2(245.19,55.31) 245.23,55.26 CG158.2 ; v2(222.99,61.71) 222.3,61.71 CG176.2 222.23,61.64 CG367.2 ; v2(244.57,110.55) 245.21,110.55 PC6371.2 ; v2(230.52,105.65) 230.44,105.57 229.2,105.57 v2(229.12,105.65) v2(228.42,105.65) ; PC6366.2 254.9,105.5 v2(255.15,105.25) ; v2(233.99,52.11) 233.98,52.1 CG150.2 ; v2(226.19,65.71) 226.81,65.71 CG152.2 ; v2(225.39,60.11) 225.46,60.18 RG130.2 ; v2(233.99,55.31) 233.51,55.79 CG185.2 ; v2(238.92,97.15) 239.33,97.15 PC6326.2 239.89,97.15 v2(240.32,97.15) 240.66,97.15 PC6325.2 241.23,97.15 v2(241.72,97.15) 242.12,97.15 PC6367.2 242.84,96.87 v2(243.12,97.15) 243.4,97.43 PC6338.2 244.24,97.43 v2(244.52,97.15) ; CG105.2 278.55,91.2 v2(278.55,90.76) 278.51,90.72 CG91.2 ; v2(245.22,101.45) 245.48,101.71 PC6304.2 246.05,101.75 246.72,101.75 246.71,101.76 CG57.2 ; 217.76,159.66 CG246.2 ; 246.01,98.65 PC6328.2 245.46,97.39 v2(245.22,97.15) ; CG267.2 270.58,89.99 v2(270.55,89.96) ; PC6345.2 228.37,94.3 v2(228.42,94.35) ; CG106.2 280.95,99.06 v2(280.95,98.56) ; v2(237.47,111.25) 237.26,111.04 CG23.2 ; v2(274.55,78.76) 274.32,78.53 RG55.2 ; RG23.1 243.66,114.38 v2(244.05,114.77) ; v2(236.82,104.25) 236.55,104.25 PC6414.2 235.69,104.25 v2(235.42,104.25) v2(234.72,104.25) 234.62,104.35 PC6311.2 233.42,104.35 v2(233.32,104.25) 233.22,104.35 PC6310.2 232.02,104.35 v2(231.92,104.25) 231.82,104.35 PC6305.2 230.62,104.35 v2(230.52,104.25) ; v2(238.22,95.75) v2(238.92,95.75) 238.98,95.75 PC6313.2 240.24,95.75 v2(240.32,95.75) 240.32,95.74 PC6333.2 241.58,95.75 v2(241.72,95.75) 241.77,95.75 PC6301.2 243.04,95.75 v2(243.12,95.75) 243.63,95.75 PC6315.2 243.98,95.75 v2(244.52,95.75) ; v2(233.79,65.71) 233.59,65.51 CG156.2 ; v2(230.52,97.1) 230.32,97.3 PC6320.2 229.27,97.3 v2(229.12,97.15) v2(228.42,97.15) 228.26,97.31 CG237.2 227.85,96.32 v2(228.42,95.75) ; PC6321.2 243.77,104.9 v2(243.12,104.25) ; 199.96,100.85 199.96,100.85 v2(199.94,100.83) ; PC6371.2 245.87,110.52 v2(245.87,111.25) ; PC6371.2 245.17,109.82 244.54,109.82 v2(244.17,109.45) ; v2(194.26,176.63) 194.26,177.46 CT96.2 ; v2(257.04,56.91) 257.5,57.37 RG117.2 ; v2(241.99,56.91) 242.13,57.06 CG174.2 ; v2(272.95,116.96) 272.95,117.39 273.25,117.7 RG105.2 ; v2(255.12,90.55) 255.16,90.51 RG68.2 ; v2(243.12,105.65) 243.22,105.75 PC6317.2 ; v2(274.55,89.96) 274.53,89.98 CG90.2 ; v2(246.37,114.8) 245.45,114.8 PC6359.2 245.9,115.32 v2(246.19,115.32) ; PC6352.2 255.79,104.6 v2(255.81,104.58) ; v2(236.82,94.35) 236.61,94.14 PC6410.2 235.63,94.14 v2(235.42,94.35) ; v2(251.57,108.45) 251.57,109.18 PC6372.2 251.82,110.2 v2(252.27,109.75) ; RG54.2 276.14,88.37 v2(276.15,88.36) ; v2(224.97,108.35) 225.67,108.35 CG11.2 ; CG58.2 226.93,91.89 227.8,91.03 228.32,91.55 v2(228.42,91.55) ; v2(249.39,52.11) 249.15,52.34 CG137.2 ; RG129.2 238.44,57.36 v2(237.99,56.91) ; CG89.2 280.09,105.06 v2(280.15,105.11) ; CG173.2 237.35,65.07 v2(237.19,64.91) ; 245.86,93.25 245.86,94.1 PC6300.2 245.61,94.35 v2(245.22,94.35) ; v2(230.52,95.75) 230.32,95.55 PC6343.2 229.32,95.55 v2(229.12,95.75) ; v2(235.42,100.05) 235.81,100.05 PC6376.2 236.43,100.05 v2(236.82,100.05) ; RG57.2 243.58,59.31 v2(243.59,59.31) ; PC6390.2 241.61,100.1 v2(243.12,100.1) 243.33,99.89 PC6316.2 244.39,99.89 v2(244.52,100.02) ; PC6390.2 240.08,100.05 v2(238.92,100.05) ; PC6390.2 240.06,98.55 v2(238.87,98.55) ; 246.01,99.41 245.37,100.05 v2(245.22,100.05) ; v2(248.07,113.93) 248.67,114.52 PC6360.2 249.11,113.88 248.58,113.35 v2(248.07,113.35) ; RG69.2 253.87,91.55 v2(253.47,91.15) ; v2(240.32,91.55) 240.36,91.59 PC6322.2 241.68,91.59 v2(241.72,91.55) 241.76,91.59 PC6346.2 243.08,91.59 v2(243.12,91.55) 243.55,91.55 PC6314.2 244.05,91.55 v2(244.52,91.55) ; UG27.3 311.27,59.19 311.27,58.34 v2(311.35,58.26) ; v2(230.52,94.35) 230.39,94.48 PC6341.2 229.25,94.48 v2(229.12,94.35) ; v2(29.53,8.45) 29.38,8.45 29.15,8.68 28.32,8.68 27.87,8.22 CA66.1 ; QE53.4 230.27,30.62 230.55,30.35 RE527.2 ; v2(228.42,99.25) 227.82,99.25 PC6331.2 ; v2(228.42,92.95) 227.9,93.47 PC6353.2 ; RE519.2 230.55,27.11 230.27,27.39 QE51.4 ; v2(245.19,62.51) 245.21,62.53 CG154.2 ; US1.5 186.24,63.44 v2(186.31,63.36) ; v2(236.82,97.15) 236.73,97.06 PC6412.2 235.51,97.06 v2(235.42,97.15) ; v2(244.47,112.65) 244.05,112.65 CG40.2 243.87,112.47 v2(243.87,111.85) ; CG189.2 271.34,86.76 v2(271.35,86.76) ; QE49.4 230.27,24.15 230.55,23.87 RE512.2 ; US1.15 183.05,65.63 v2(182.97,65.55) 182.97,65.43 183.28,65.13 US1.16 ; v2(278.55,74.76) 278.27,74.76 RG118.2 ; CG272.2 236.52,80.25 v2(236.52,80.25) ; v2(228.42,102.85) v2(229.12,102.85) 229.21,102.94 PC6340.2 230.43,102.94 v2(230.52,102.85) 230.81,102.56 PC6306.2 231.63,102.56 v2(231.92,102.85) 232.21,102.56 PC6349.2 233.03,102.56 v2(233.32,102.85) 233.61,102.56 PC6356.2 234.43,102.56 v2(234.72,102.85) v2(235.42,102.85) 235.69,102.85 PC6377.2 236.55,102.85 v2(236.82,102.85) ; v2(257.99,61.71) 257.89,61.61 CG139.2 ; RG120.2 276.16,69.41 v2(275.6,69.41) 275.46,69.55 v2(275.46,70.57) ; CG175.2 233.41,63.74 v2(233.79,64.11) ; RG119.2 261.49,58.48 v2(261.49,57.91) ; v2(244.52,92.95) 244.48,92.91 PC6337.2 243.16,92.91 v2(243.12,92.95) 242.71,93.36 PC6368.2 242.13,93.36 v2(241.72,92.95) 241.31,93.36 PC6364.2 240.73,93.36 v2(240.32,92.95) 239.91,93.36 PC6312.2 239.34,93.36 238.93,92.95 v2(238.92,92.95) v2(238.22,92.95) ; CG99.2 274.25,109.46 v2(273.75,108.96) ; v2(246.57,112.65) 247.24,112.65 PC6370.2 247.24,111.95 v2(246.67,111.95) ; PC6339.2 243.92,102.25 v2(244.52,102.85) ; v2(222.99,64.91) 222.41,64.91 CG169.2 ; PC6354.2 253.35,105.87 v2(253.34,105.88) ; CG157.2 245.33,63.96 v2(245.19,64.11) ; v2(222.19,52.91) 222.17,52.93 CG167.2 ; v2(248.83,105.71) 248.4,106.14 PC6355.2 ; v2(234.72,100.05) v2(233.32,100.05) v2(231.92,100.05) v2(230.52,100.05) 230.48,100.01 PC6319.2
  TOP w0.356: v2(192.23,100.45) 192.19,100.49 RG24.2 ; v2(190.17,103.07) RG150.2 ; RT37.2 170.1,165.49 v2(170.57,165.96) 171.01,166.4 RT17.2 ; v2(278.91,144.88) 278.91,145.33 278.55,145.69 UG25.3 ; v2(164.66,122.71) 164.99,123.04 PC1162.2 PC1207.2 ; v2(204.35,165.32) 203.84,165.83 CT113.2 ; PQ710.1 120.58,78.55 120.79,78.77 PR730.1 ; CT56.2 186.59,158.39 v2(186.25,158.73) ; RV8.2 RV1.2 ; RE504.2 232.8,28.91 232.8,29.76 232.82,29.78 v2(232.82,29.8) ; RT18.2 176.84,156.67 v2(176.79,156.62) ; v2(222.77,108.35) 222.76,108.36 CG303.2 ; RG151.2 193.84,111 v2(193.98,111) ; CV23.2 v2(243.66,161.06) ; CG307.2 220.48,110.04 v2(220.22,110.3) 220.06,110.46 CG34.2 ; CG483.2 281.45,143.53 282.16,144.24 v2(282.16,144.57) ; v2(278.91,141.1) 278.52,141.49 UG29.3 ; v2(171.76,158.78) 171.92,158.63 RT38.2 RT11.2 ; PC1099.2 PC1161.2 166.68,124.35 v2(166.89,124.56) ; CG18.2 224.17,103.2 v2(224.17,103.45) ; RE497.2 v2(233.05,32.75) ; RE509.2 v2(233.05,26.27)
  TOP w0.381: CH124.2 144.37,101.21 v2(144.27,101.11) ; CT112.2 203.57,165.2 v2(203.64,165.26) ; PC6350.2 232.36,89.71 v2(231.92,90.15) ; v2(123.71,78.53) 124.09,78.53 124.28,78.72 UC1.3 ; RE504.2 233.92,28.66 QE47.4 ; CG459.2 197.42,101.1 197.81,100.7 v2(197.98,100.7) ; QG505.4 193.88,107.27 193.06,108.1 RH589.1 ; CG47.2 CG49.2 228.16,117.76 v2(228.1,117.82) ; v2(239.57,111.25) 239.45,111.13 CG301.2 ; UX1.3 222.22,162.18 v2(221.78,161.73) ; v2(151.27,108.36) 151.65,108.36 PC1033.2 ; RG25.2 223.97,162.4 v2(224.67,162.4) ; CG479.2 281.45,161.33 v2(281.48,161.36) ; CG56.2 243.51,88.73 PC6302.2 242.45,88.13 v2(242.07,87.75) ; CA59.2 36.01,16.37 35.82,16.56 v2(35.82,16.99) ; RA74.2 37.09,1.99 v2(37.09,2.25) ; v2(197.68,9.94) 198.89,8.73 UV22.15 ; RH184.2 132.25,111.66 v2(131.76,112.16) ; v2(269.38,35.69) 272.13,35.69 272.52,36.07 QE57.4 272.64,36.5 RE638.2 ; CH70.2 213.74,27.13 v2(214.19,27.59) ; RT62.2 198.26,160.03 197.87,159.64 v2(197.67,159.64) ; v2(246.13,113.67) 245.82,113.35 CG311.2 ; CG4.2 235.96,110.55 v2(236.17,110.55) ; v2(159.91,106.71) 159.46,106.71 PC1024.2 ; v2(148.54,108.3) 148.92,108.3 PC1032.2 ; PC1035.2 151.62,110.96 v2(151.27,110.96) ; PC1030.2 146.57,108.3 v2(146.19,108.3) ; v2(219.95,155.58) 219.95,155.3 219.67,155.02 219.07,155.02 218.75,155.34 218.75,156.3 219.58,157.12 QV97.1 ; RE497.2 233.5,32.2 233.78,31.92 QE46.4 ; v2(155.21,106.71) 154.77,106.71 PC1023.2 ; CG480.2 275.18,147.19 v2(274.85,147.52) ; RG53.2 276.06,115.27 276.08,115.29 ; v2(298.01,54.78) 297.95,54.85 PC6427.1 ; v2(230.83,29.75) RE527.2 ; v2(155.21,107.92) 154.77,107.92 PC1022.2 ; v2(241.95,114.77) 241.87,114.69 CG308.2 ; v2(270.52,34.16) 270.52,34.06 270.9,33.67 RE641.2 271.22,33.72 QE57.1 ; v2(278.44,152.75) 278.37,152.67 UG26.3 ; v2(230.64,19.97) 230.83,20.16 RE523.2 ; PC1034.2 151.61,109.63 v2(151.27,109.63) ; UG24.4 189.5,101.37 190.41,102.29 190.41,102.85 190.19,103.07 v2(190.17,103.07) ; v2(301.13,59.79) 301.13,59.45 PC6441.1 301.4,59.14 PR6420.2 ; CH109.2 170.76,114.84 171.35,115.43 v2(171.35,115.57) ; v2(313.42,59.84) 313.81,59.84 313.91,59.73 CG476.2 ; v2(217.32,41.61) 217.52,41.81 CH53.2 ; UG28.3 v2(281.59,157.05) ; v2(297.92,56.55) 297.88,56.51 PC6426.1 ; v2(103.62,54.52) 103.68,54.58 104.89,54.58 PQ202.1 ; v2(229.35,114.77) 229.33,114.79 RG38.2 ; PC1027.2 162.7,106.71 v2(162.26,106.71) ; PC6409.2 236.12,98.46 v2(236.12,99.28) ; v2(169.17,161.07) 169.39,160.85 RV8.2 ; v2(224.6,58.47) 224.6,58.46 CG373.2 ; v2(143.78,108.3) 144.22,108.3 PC1031.2 ; v2(304.94,49.42) PR6434.1 ; v2(157.56,106.71) 158,106.71 PC1021.2 ; PC1020.2 158,107.92 v2(157.56,107.92) ; UG24.1 188.16,98.07 v2(187.43,98.07) ; RU25.2 v2(295.26,64.84) ; CU29.2 30.83,46.03 30.83,45.38 30.56,45.11 UU5.3 ; CH107.2 168.81,113.13 CH110.2 ; v2(203.4,23.85) 203.4,23.66 204.1,22.97 CH3.2 ; v2(199.13,163.53) 198.68,163.53 198.45,163.29 RT83.1 ; CA11.2 37.54,27.85 36.59,26.89 v2(36.52,26.89) ; QE48.1 236.29,24.15 236.5,23.93 RE508.2 236.74,23.64 v2(236.44,23.34) ; PC1134.2 165.2,101.12 CH127.2 165.25,100.48 v2(165.3,100.43) ; v2(159.91,107.92) 159.46,107.92 PC1025.2 ; v2(237.05,29.75) 237.05,30.03 RE496.2 236.43,30.35 236.16,30.62 QE46.1 ; v2(199.23,164.1) 199.16,164.18 CT101.2 ; v2(146.08,101.11) 146.02,101.17 CH118.2 ; v2(216.38,23.44) 216.42,23.4 CH201.2 ; PQ710.4 120.91,77.25 120.58,77.59 120.58,78.55 ; v2(222.58,20.29) 223.05,20.76 RE515.2 223.5,20.76 223.78,20.48 ; PC1213.2 157.27,100.66 v2(157.06,100.46) ; CG305.2 223.82,105.15 223.57,105.4 v2(223.57,105.65) ; v2(195.53,168.18) 196.1,168.18 CT102.2 ; v2(162.26,107.92) 162.7,107.92 PC1026.2 ; v2(244.42,113.93) 243.89,113.39 CG309.2 ; CG13.2 243.15,110.69 243.71,111.25 v2(243.77,111.25) ; v2(319.03,49.44) PR9.1 ; UV22.8 195.75,4.83 196.16,5.24 ; PC1028.2 141.88,108.3 v2(141.49,108.3) ; v2(308.81,53.05) PR6404.1 ; PC1097.2 162.45,101.03 162.45,100.56 v2(162.55,100.46) ; QE47.1 236.16,27.39 236.43,27.11 RE501.2 236.74,27.07 237.02,26.79 v2(237.02,26.45) ; v2(231.45,115.32) 231.55,115.42 RG37.2 ; v2(173.61,165.18) 173.51,165.09 RT4.2 RT47.2 ; CH176.2 213.23,24.9 v2(213.29,24.85) ; v2(209.36,25.08) 209.33,25.05 RH24.2 ; v2(139.14,108.3) 139.53,108.3 PC1029.2 ; CG478.2 v2(277.36,156.48) ; v2(31.56,16.86) RA78.2 RA79.2 ; Q2410.3 195.35,19.48 v2(195.24,19.37) ; C4.2 v2(178.49,73.55) ; QE48.4 233.78,25.45 233.5,25.72 RE509.2 ; CA256.2 v2(34.49,1.45) ; CH4.2 215.31,31.99 v2(215.39,31.92) ; PC6357.2 PC6323.2 ; v2(308.52,59.49) UG23.4 ; UG23.1 v2(309.81,60.16) ; v2(230.83,26.51) RE519.2 ; v2(37.28,16.99) 37.28,16.92 36.9,16.54 CA58.2 ; v2(302.21,49.42) PR6435.1 ; v2(230.83,23.27) RE512.2 ; PC6369.2 PC6335.2
  TOP w0.4: 276.08,115.29 v2(276.15,115.36)
  TOP w0.406: C2518.2 129.52,99.44 v2(130.18,99.44) ; v2(217.31,155.6) 216.57,156.33 UG22.3 ; v2(17.8,38.49) DU2.3
  TOP w0.432: QE21.1 200.77,173.34 v2(200.77,172.55) ; v2(203.56,172.61) 203.24,172.94 QE13.1 ; QE1.1 325.27,41.32 324.84,41.75 v2(324.74,41.75) ; v2(228.97,31.96) 228.29,31.96 228.26,31.92 QE53.1 ; v2(227.58,22.92) 227.72,22.79 227.72,22.38 227.9,22.21 QE52.1 ; v2(227.44,29.51) 227.45,29.51 228.02,28.95 QE51.1 ; v2(211.44,155) 211.44,155 211.44,155.61 QG502.1 ; v2(323.41,38.78) 323.75,38.78 323.97,39.01 QE1.4 ; QG505.1 192.58,105.93 v2(192.51,106.01) ; Q34.4 v2(109.04,25.18) ; v2(191.59,109.7) 191.33,109.95 QG503.1 ; QE3.1 326.48,45.13 326.91,45.56 v2(327.16,45.56) ; QE3.4 324.86,43.4 v2(324.62,43.4) ; v2(227.52,26.29) 228.02,25.79 QE49.1 ; v2(322.64,43.75) QE4.4 ; Q34.1 107.74,22.8 v2(108.09,23.15) ; v2(327.87,40.1) 327.87,40.41 327.75,40.53 Q9.1 ; v2(319.89,43.82) Q7.4 ; Q8.4 321.24,38.83 v2(320.93,38.51) ; v2(225.94,23.27) QE50.1 ; v2(327.29,40.11) 327.04,40.11 326.45,39.51 Q9.4 ; QG503.4 189.42,111.63 188.32,111.63 188.31,111.62 v2(188.29,111.62) ; QE4.1 323.94,45.08 v2(324.34,45.48) ; 223.78,20.48 224.45,20.48 QE50.4 ; v2(323.35,41.12) 323.28,41.05 Q8.1 ; Q29.1 118.22,22.74 118.35,22.87 v2(118.35,23.15) ; Q28.4 v2(114.18,25.11) ; QG504.4 v2(190.19,106.12) ; v2(188.07,105.62) 188.46,105.62 188.89,105.19 QG504.1 ; v2(113.17,23.21) 112.88,22.93 Q28.1 ; QE22.1 205.71,172.65 v2(205.69,172.63) ; v2(119.52,25.11) Q29.4 ; v2(321.19,45.75) Q7.1
  TOP w0.457: JLOGO.16 236.92,165.84 v2(237.63,165.13) ; v2(217.83,38.63) 217.77,38.68 217.77,39.4 217.86,39.48 217.86,40.63 CH187.2 ; UE1.3 315.4,8.18 315.66,7.92 CE57.2 ; v2(146.55,166.42) 145.9,166.42 CE79.2 ; CD73.2 140.92,54.32 141.18,54.59 v2(141.73,54.59)
  TOP w0.508: v2(193.03,93.25) 193.04,93.26 CG200.2 ; v2(167.91,97.76) 167.9,97.75 CH126.2 ; PC6323.2 v2(253.06,119.6) ; CG140.2 280.11,70.07 v2(280.15,70.11) ; CG349.2 254.16,52.74 v2(253.99,52.91) ; v2(257.99,63.31) 257.92,63.38 CG352.2 ; v2(119.86,58.67) 119.53,59 CD79.2 ; v2(216.82,20.8) RH199.2 ; v2(217.8,159.7) 217.76,159.66 217.76,158.92 QV97.4 ; CG354.2 273.03,82.05 v2(272.95,81.96) ; v2(195.43,77.45) 195.6,77.28 CG206.2 ; v2(190.81,168.04) 190.92,168.15 191.77,168.15 YT1.2 ; CG435.2 CG353.2 253.32,60.78 v2(253.19,60.91) ; C623.2 C621.2 330.45,30.38 v2(330.02,29.94) ; YT1.4 194.14,165.69 193.87,165.42 v2(193.87,165.2) ; CD9.2 180.97,61.71 181.05,61.63 v2(181.17,61.63) ; PC119.2 54.93,30.99 PC118.2 53.94,30.34 v2(53.73,30.13) ; CD70.2 153.5,59.11 153.5,58.24 152.99,57.74 v2(152.85,57.74) ; CG324.2 278.49,112.92 v2(278.55,112.86) ; RH455.1 220.81,19.97 220.19,19.35 v2(220.19,18.61) ; C2521.2 177.92,76.46 178.48,75.91 v2(178.49,75.91) ; CE6.2 v2(322.63,5.64) ; CG429.2 250.06,53.64 v2(249.99,53.71) ; v2(324.59,8.96) JIO.31 ; RG163.2 197.61,76.87 v2(197.03,77.45) ; v2(126.3,75.12) 126.15,74.97 CH197.2 ; CL36.1 CL37.2 v2(255.85,157.87) ; CN25.2 v2(318.19,36.96) ; CG398.2 205.39,93.26 CG199.2 205.38,92.95 205.03,92.59 v2(205.03,92.45) ; CG452.2 221.41,54.91 CG457.2 222.02,54.9 v2(222.04,54.91) ; v2(310.65,14.26) 310.48,14.26 CE40.1 ; CA8.2 32.2,35.58 v2(31.71,35.08) ; CG428.2 CG351.2 254.33,57.23 v2(254.01,56.91) ; v2(287.01,22.77) QE5.3 288.47,22.23 RE650.2 ; CL32.1 CL35.2 v2(249.94,157.83) ; JFAN1.5 109.72,64.18 v2(111.01,62.9) ; v2(257.44,157.89) CL38.1 CL39.2 ; v2(318.58,19.36) CU11.2 317.93,20.17 317.55,20.56 CE9.2 ; QE2.3 310.45,6.42 v2(310.84,6.81) ; v2(148.15,175.93) 148.52,176.29 JEDP.43 ; v2(142.31,162.53) 142.68,162.9 CE82.2 ; CD7.2 139.47,58.72 v4(138.34,58.72) v2(137.53,58.72) ; CG187.2 CG186.2 190.57,74.9 v2(190.83,74.64) ; CE80.2 143.87,166.49 v2(144.19,166.17) ; CE29.2 296.98,26.82 v2(296.5,27.3) ; CV484.2 127.77,155.61 v2(128.34,156.18) ; v2(169.42,112.45) 169.28,112.31 CH110.2 ; v2(276.95,96.36) 277.08,96.36 277.59,95.85 CG413.2 277.59,94.81 CG421.2 ; v2(270.55,73.96) 270.57,73.98 CG138.2 CG359.2 ; RH580.2 206.62,38.34 v2(206.57,38.39) ; RA80.2 26.49,15.08 v2(26.3,14.89) ; CG420.2 268.54,96.97 v2(269.15,96.36) 268.63,95.84 CG417.2 ; RA9.2 36.6,26.55 36.52,26.63 v2(36.52,26.89) ; CM31.2 127.38,152.9 v2(127.96,152.31) ; PC112.2 v2(63.05,48.45) ; PD3.1 v2(78.5,7.59) ; v2(237.99,52.91) 238.05,52.85 CG379.2 ; CD10.2 180.81,62.92 v2(181.17,63.28) ; PR26.1 294.14,6.45 v2(293.67,6.92) 293.21,6.45 PC13.1 ; CG414.2 277.55,100.81 CG336.2 CG338.2 v2(277.55,98.26) ; v2(203.27,108.91) 202.98,108.62 RG93.1 ; v2(303.52,46.39) 303.52,46.94 PC6416.2 ; CG198.2 192.91,77.34 v2(193.03,77.45) ; CG406.2 CG196.2 202.65,70.23 v2(202.63,70.25) ; v2(151.58,101.1) 151.36,101.1 151.19,100.92 CH119.2 ; v2(227.95,43.6) 227.49,43.14 U18.2 ; v2(315.67,53.63) 315.4,53.89 CE63.1 ; v2(318.65,51.61) 318.37,51.89 PQ2.3 ; PQ8203.1 277.47,150.53 v2(277.65,150.35) ; JTOBII.8 159.86,167.32 v2(158.87,168.31) ; CG213.2 201.01,73.44 v2(201.03,73.45) ; v2(270.15,104.91) 270.04,104.8 CG326.2 ; PC549.1 170.6,147.24 v2(170.77,147.06) ; CS7.2 181.67,67.32 182.03,67.68 v2(182.71,67.68) ; v2(277.4,65.82) PC6374.2 ; v2(26.96,9.72) 27.05,9.63 27.37,9.63 27.57,9.42 CA62.2 CA63.2 ; CG89.2 280.07,104.32 CG333.2 ; 274.54,90.66 275.09,90.66 275.38,90.95 CG423.2 ; 274.54,90.66 CG412.2 ; 274.54,90.66 CG90.2 ; C29.2 192.34,12.9 191.6,12.16 v2(190.38,12.16) ; v2(193.03,74.25) 193.04,74.26 CG212.2 ; v2(202.86,25.89) 202.76,25.99 CH183.2 ; v2(278.82,161.04) 277.92,161.94 CG482.2 ; C10.2 182.77,82.65 v2(183.27,82.65) ; CA53.2 39.44,6.12 39.95,5.61 v2(39.95,4.29) 39.26,4.97 CA54.2 39.02,4.92 39.02,4.69 38.46,4.13 CA254.2 ; JFAN2.4 287.12,78.43 v2(287.27,78.58) ; CG439.2 259.65,58.45 v2(259.59,58.51) ; v2(121.04,48.48) 121.12,48.56 CD83.2 ; v2(237.99,55.31) 238.02,55.34 CG380.2 ; v2(261.79,52.91) 261.91,52.79 CG344.2 262.49,52.8 CG427.2 ; CE51.2 310.14,9.11 v2(310.66,8.59) ; CG361.2 271.65,70.46 v2(271.75,70.56) ; CL14.2 268.22,168.26 v2(267.62,168.26) ; v2(274.52,20.42) C625.2 C628.2 ; CG453.2 219.44,52.18 219.67,52.41 CG171.2 219.1,52.8 v2(218.99,52.91) ; CG342.2 271.32,97.99 v2(271.35,97.96) ; v2(172.02,178.82) JEDP.42 ; v2(271.75,104.91) 271.75,104.1 272.37,103.47 CG314.2 ; PC218.2 107.54,53.38 PQ202.4 v2(106.89,52.55) ; CG356.2 270.48,78.69 v2(270.55,78.76) ; CD72.2 152.17,52.63 152.88,53.35 152.88,53.41 v2(153.01,53.53) ; RD29.2 177.5,55.16 177.03,54.69 v2(176.71,54.69) ; v2(192.23,98.05) 192.19,98.09 CG389.2 191.3,98.08 CG470.2 ; v2(122.12,81.95) 122.06,82.01 120.47,82.01 v4(118.63,80.18) 117.73,79.27 PC724.2 ; CG475.2 v2(195.89,103.55) 195.88,103.55 CG384.2 ; v2(198.18,89) 197.8,89.38 RG157.2 ; v2(269.75,81.96) 269.74,81.97 CG355.2 ; v2(288.44,72.74) 288.69,72.99 CF5.2 ; v2(197.03,93.4) 197.61,93.98 RG159.2 197.62,94.02 CG473.2 ; v2(214.99,52.11) 214.99,51.81 214.7,51.53 CG372.2 CG371.2 ; v2(305.57,29.29) RE162.2 ; CH185.2 205.11,29.83 v2(205.18,29.76) ; CD19.2 130.19,46.44 v2(130.82,45.82) ; v2(168.42,40.4) CD81.2 ; PR572.1 v2(141.42,140.88) ; v2(123.37,133.79) PC502.2 ; CD24.2 150.2,43.97 v2(150.41,43.75) ; CH195.2 134.57,115.48 v2(134.62,115.42) ; v2(115.58,37.72) 114.79,38.5 CD22.2 ; CG399.2 CG197.2 193.73,69.51 v2(193.83,69.6) ; CH186.2 212.98,30.8 v2(213.3,31.11) ; JFAN2.6 v2(284.27,84.41) ; CG403.2 198.46,79.69 v2(198.63,79.85) ; CE4.1 v2(317.74,5.64) ; RE83.2 310.08,23.89 v2(310.08,23.04) 310.08,23.05 CE32.1 ; v2(130.57,116.58) 130.49,116.58 129.98,116.07 CH194.2 ; RH135.1 221.29,30.36 221.69,29.96 v2(221.94,29.96) ; v2(206.74,34.85) 206.69,34.9 206.33,34.9 CH188.2 ; v2(280.15,109.76) 280.18,109.8 CG330.2 ; CE42.2 305.53,5.16 v2(305.94,5.57) ; CA23.2 33.98,23.79 v2(34.5,23.27) ; CA38.2 37.27,38.02 v2(37.47,37.81) ; v2(204.8,107.98) 204.34,108.44 RG90.1 ; v2(195.72,9.87) 196.16,9.43 196.16,5.24 ; PC5020.2 147.47,149.41 v2(147.2,149.13) ; v2(187.54,25.58) RE37.2 RE27.2 ; PQ8203.4 279.19,148.92 v2(279.19,148.61) ; RA77.2 CA60.2 35.12,16.92 v2(35.19,16.99) ; v2(301,43.78) 301,42.58 300.72,42.3 CM13.2 ; v2(192.23,79.85) 192.22,79.85 CG202.2 191.54,79.79 CG400.2 ; CE30.2 CE41.2 304.55,26.82 v2(304.66,26.94) ; RG162.2 197.74,81.36 v2(197.83,81.45) ; CG472.2 199.67,92.5 CG204.2 200.98,92.5 v2(201.03,92.45) ; CE81.2 154.94,164.13 v2(155.11,164.31) 155.01,164.31 154.56,164.76 JTOBII.1 ; PC511.2 130.07,135.15 v2(130.69,134.53) ; CH193.2 172.07,101.39 v2(172.01,101.45) ; CD4.2 CD3.2 v2(181.29,60.63) ; CG397.2 203.53,93.14 CG201.2 203.54,92.57 v2(203.43,92.45) ; v2(204.38,33.44) 204.06,33.76 CH82.2 ; v2(128.15,151.68) 127.86,151.39 CM29.2 ; CG444.2 CG442.2 CG447.2 226.95,52.75 v2(226.79,52.91) ; CA55.2 27,5.62 v2(27,5.87) ; CG156.2 233.09,65.49 CG375.2 ; v2(157.06,100.46) 156.95,100.57 CH125.2 ; CG449.2 221.38,56.67 CG443.2 221.91,56.64 v2(222.04,56.51) ; CD6.2 144.09,59.17 145.14,58.12 v2(145.62,58.12) ; CG468.2 191.35,90.19 CG217.2 191.4,90.08 v2(192.23,89.25) ; CV374.2 165.33,162.78 v2(165.73,163.19) ; PC8218.2 243.32,37.85 v2(243.25,37.93) ; CG458.2 201.7,92.58 v2(201.83,92.45) ; CE14.2 323.67,15.58 CE13.2 323.67,16.83 v2(324.04,17.2) ; CG360.2 277,72.31 v2(276.95,72.36) ; v2(272.15,94.76) 272.2,94.72 CG340.2 272.14,93.94 CG422.2 ; CM15.2 v2(315.73,38.65) ; v2(202.23,100.65) 202,100.88 CG395.2 ; CG456.2 226.57,57.99 v2(226.49,57.91) ; v2(197.38,166.26) 197.65,166.53 198.26,166.53 ; v2(52.19,24.69) PC718.1 52.97,24.67 PC720.1 ; C268.2 v2(225.26,46.5) ; v2(332.05,38.18) 331.92,38.31 CE55.1 ; v2(155.34,36.88) 155.35,36.89 RH212.2 RH210.2 ; v2(253.19,51.31) 253.13,51.26 CG430.2 253.13,49.79 CG440.2 ; v2(205.83,70.25) 205.83,70.25 CG210.2 205.81,69.55 CG401.2 ; v2(223.19,51.31) 223.31,51.19 CG448.2 223.31,49.7 CG454.2 223.27,49.64 CG450.2 CG451.2 ; CT88.2 194.18,163.67 v2(194.08,163.77) ; CG378.2 237.83,61.67 CG153.2 237.22,61.68 v2(237.19,61.71) ; RA82.2 27.43,12.41 v2(27.06,12.41) ; CG474.2 RG88.1 199.65,111.82 v2(199.35,112.12) ; v2(281.75,70.11) 281.85,70.01 CG358.2 ; 140.66,46.39 141.55,46.39 142.26,45.68 142.26,43.57 v2(142.15,43.46) ; v2(172.34,58.71) 172.54,58.71 173.12,59.29 CD1.2 ; RH589.1 192.21,108.17 191.59,108.79 v2(191.59,109.7) 191.74,109.54 CG487.2 ; v2(226.83,153.91) 226.55,153.63 RE44.2 RE42.2 ; v2(166.6,165.59) 166.95,165.24 DV4.1 ; CD75.2 124.92,53.47 v2(124.79,53.61) ; CG460.2 193.77,101.78 CG215.2 193.8,101.13 v2(193.83,101.1) ; v2(182.4,46.21) CD31.2 ; CU45.2 322.63,19.6 v2(323.16,20.14) ; v2(213.28,21.18) 213,21.47 CH200.2 ; v2(182.4,49.39) CD28.2 ; v2(29.6,42.64) 29.03,42.64 28.93,42.74 CU26.2 ; v2(324.43,11.65) 324.05,12.03 CE18.2 CE17.2 323.66,12.93 CE16.2 ; PQ8.3 76.14,8.92 v2(76.65,9.43) ; v2(18.87,40.93) 18.96,40.93 19.46,41.43 CU7.2 19.41,41.65 RU3.1 ; v2(202.74,11.79) 203.09,11.44 JWDB.4 ; v2(161.25,163.07) 161.25,163.81 161.97,164.54 DV2.1 ; CU48.2 316.4,24.42 v2(316.86,24.87) CU16.2 ; v2(257.19,52.91) 257.1,52.83 CG347.2 ; CG339.2 278.06,93.32 v2(278.55,93.81) ; v2(244.53,14.19) 244.12,14.6 PR306.2 ; CG346.2 249.38,55.32 v2(249.39,55.31) ; v2(63.45,45.45) 63.45,45.75 PR116.2 ; v2(274.55,113.76) 274.71,113.6 CG329.2 CG331.2 ; R180.2 192.08,18.27 C2509.2 191.56,17.75 v2(191.46,17.75) 191.46,17.3 191.08,16.93 C2508.2 ; PC6428.2 v2(284.83,52.08) ; C2520.2 183.18,76.32 v2(182.95,76.55) C7.2 ; PC217.2 103.37,51.19 v2(104.02,51.19) ; CS1.2 v2(127.45,7.97) ; v2(236.17,164.94) 235.92,165.19 JLOGO.15 ; CG438.2 257.92,60.84 v2(257.99,60.91) ; RG116.2 v2(274.32,84.34) ; v2(169.46,50.42) 168.49,51.39 CD74.2 ; v2(217.37,50.53) 217.38,50.54 CG364.2 ; CA85.2 35.82,24.09 v2(36.22,23.68) ; v2(174.26,178.66) 174.22,178.63 JEDP.44 ; JFAN1.4 103.12,64.29 103.63,64.8 v2(105.1,64.8) ; CG316.2 v2(273.68,65.98) ; CE25.2 188.74,24.98 188.23,25.49 v2(188.22,25.49) ; PR813.1 237.17,40.69 236.66,40.18 236.61,40.18 v2(236.55,40.11) ; CG471.2 CG393.2 CG195.2 199.96,100.85 ; PC588.1 184.17,145.13 v2(186,145.13) ; CG446.2 227.5,54.52 CG445.2 226.82,54.54 v2(226.79,54.51) ; CG318.2 232.45,60.29 v2(232.64,60.11) 232.64,59.93 232.13,59.42 CG374.2 ; v2(242.01,20.1) 241.63,19.72 PR303.1 ; CH52.2 217.1,30.83 v2(217.24,30.98) ; v2(199.43,71.85) 199.44,71.86 200.08,71.86 RG450.2 ; DA8.1 49.14,7.54 49.54,7.14 v2(49.54,6.38) ; v2(181.17,62.33) 181.3,62.45 CS2.2 ; v2(274.84,23.37) 275,23.21 C620.2 C627.2 ; CG424.2 277.34,90.95 CG91.2 ; v2(301.44,28.67) 301.29,28.52 CE36.2 301.24,27.71 CE34.2 CE45.2 ; v2(280.55,93.81) 280.73,93.63 CG415.2 ; RE29.2 RE30.2 v2(182.95,20.42) ; CG402.2 196.01,74.47 v2(196.23,74.25) ; CG238.2 225.57,114.29 v2(225.12,114.75) ; v2(195.43,69.6) 195.43,69.47 195.72,69.18 CG216.2 ; PR539.2 129.09,144.57 129.54,144.13 PC519.2 130.01,144.13 v2(130.38,144.49) ; CE24.2 RE31.2 223.97,157.64 223.47,157.13 v2(223.47,156.81) ; v2(137.42,48.52) 137.75,48.85 CD91.2 CD92.2 ; CE38.2 v2(310.65,19.51) ; v2(174.49,181.36) CV14.2 ; RU2.1 18.12,45.29 v2(17.73,45.69) ; v2(275.35,97.96) 275.33,97.98 RG108.2 ; v2(271.35,116.96) 271.43,117.05 CG328.2 ; CD21.2 v2(135.26,40.93) ; CE15.2 324.44,14.67 v2(324.62,14.85) ; CD26.2 143.59,39.86 v2(144.06,40.33) ; v2(31,33.18) 30.74,33.43 RA6.2 ; v2(235.59,58.51) 235.59,58.5 CG381.2 ; v2(195.03,93.4) 195,93.43 CG205.2 ; v2(36.65,33.81) 36.96,33.51 CA40.2 ; PC300.2 PR308.2 240.67,15.15 240.16,14.63 240.16,14.09 240.15,14.09 v2(240.15,14.09) ; C639.2 C640.2 v2(243.4,8.32) ; CE3.2 v2(316.79,5.64) ; CL15.2 v2(267.65,169.37) ; RA4.2 25.54,14.89 v2(25.6,14.83) ; v2(233.97,51.31) 234.18,51.1 CG377.2 ; v2(169.41,103.81) 169.37,103.77 CH102.2 ; CG192.2 197.05,74.28 v2(197.03,74.25) ; CH192.2 216.37,16.48 216.87,16.98 216.95,16.98 v2(217.5,17.53) ; v2(286.84,24.48) CE31.1 ; v2(253.19,64.91) 253.22,64.94 CG124.2 CG432.2 ; v2(32.63,38) CA9.2 31.96,38.84 CA10.2 ; CS6.2 v2(126.37,8.6) ; v2(162.92,45.95) 163.21,46.24 CD20.2 ; CE46.2 v2(296.36,5.02) ; v2(180.03,147.01) 180.03,146.68 180.54,146.17 PC5018.2 ; v2(167.21,105.78) 167.62,106.19 CH103.2 ; RD30.2 155.66,48.54 v2(155.65,48.55) ; v2(278.55,109.76) 278.41,109.91 CG327.2 ; v2(147.25,164.03) 147.72,164.5 UE12.2 ; v2(309.65,54.9) 309.85,55.09 PR6413.1 ; PR711.2 60.14,17.58 60.65,17.08 v2(60.74,17.08) ; v2(72.14,7.57) 72.12,7.6 71.4,7.6 PQ4.3 ; RH88.1 212.67,36.79 v2(212.17,37.28) ; RE645.1 320.16,25.83 v2(320.3,25.69) CU17.2 ; v2(193.03,96.45) 193.01,96.44 CG396.2 193.05,95.73 CG461.2 193.04,94.8 CG469.2 ; v2(150.91,57.48) 150.65,57.48 150.01,58.12 CD5.2 ; v2(203.91,12.54) 203.91,12.29 204.71,11.48 205.91,11.48 206.27,11.84 206.27,11.85 206.28,11.87 JWDB.6 ; v2(277.4,67.09) PC6375.2 ; v2(148.8,52.31) 150.01,52.31 CD71.2 ; v2(122.12,81.31) 121.96,81.15 121.21,81.15 v4(121.04,80.99) 120.79,80.74 PR730.1 ; CM12.2 v2(301.8,44.07) ; v2(221.04,160.28) 221.43,159.89 221.89,159.89 RX4.2 ; v2(324.65,25.05) 324.75,25.05 324.95,25.25 JIO.32 ; v2(274.55,73.96) 274.62,74.03 CG362.2 ; v2(270.55,94.76) 270.46,94.67 CG341.2 270.47,93.97 CG425.2 ; v2(261.79,54.51) 261.84,54.57 CG141.2 262.48,54.59 CG434.2 ; C638.2 v2(241.63,8.35) ; v2(278.86,138.64) 279.21,138.98 280.21,138.98 280.56,138.62 PR6064.1 PR6065.1 ; 139.26,46.39 139.26,45.64 139.11,45.49 v2(139.11,44.56) ; v2(86.05,9.87) 86.05,11.21 v4(85.68,11.58) 85.54,11.72 83.7,11.72 83.4,12.02 PD2.1 ; PC11.2 65.13,14.52 v2(64.69,14.08) ; 180.86,52.04 v2(181.74,52.04) ; v2(106.63,57.38) 106.63,58.26 107.58,59.21 CF4.2 ; CL34.1 CL33.2 v2(247.91,157.72) ; CG431.2 257.48,65.26 257.83,64.91 v2(257.99,64.91) ; CG267.2 270.58,91.68 CG419.2 ; CE57.2 315.66,7.22 315.86,7.02 v2(315.86,6.7) ; v2(276.49,99.51) 276.32,99.68 CG313.2 ; v2(249.39,56.11) 249.34,56.15 CG345.2 ; CL31.2 268.17,159.8 268.66,159.3 QL3.3 ; v2(209,18.73) 209.36,18.36 CH191.2 ; v2(158.38,167.84) 158.38,167.04 157.76,166.42 JTOBII.5 ; RE649.1 19.05,51.58 19.76,50.87 v2(19.76,50.58) ; v2(249.99,64.11) 249.96,64.08 CG135.2 ; CG366.2 CG370.2 216.88,51.37 217.39,51.87 v2(217.39,52.11) ; v2(20.79,48.88) 21.15,48.51 CU47.2 ; v2(281.45,66.33) 280.69,67.09 PC6445.2 ; v2(281.08,161.92) 280.73,162.27 CG481.2 ; RG58.2 219.77,60.08 CG365.2 218.91,60.84 CG170.2 218.24,60.85 v2(218.19,60.91) ; v2(206.8,19.69) 206.8,19.14 206.33,18.68 CH190.2 ; CL13.2 268.37,166.14 v2(267.9,166.61) 268.32,167.02 CL12.2 ; CE58.2 v2(313.98,20.63) ; CG418.2 273.17,85.97 CG337.2 273.19,86.53 v2(272.95,86.76) ; v2(327.03,42.7) 327.03,42.51 326.77,42.25 CE56.2 ; CG467.2 203.84,102.55 CG190.2 203.84,100.67 v2(203.83,100.65) ; CD76.2 134.69,53.03 v2(134.61,53.03) ; CE43.2 310.6,17.73 v2(310.7,17.83) ; CE1.2 v2(318.69,5.64) ; CA57.2 v2(27.63,5.94) ; CG239.2 224.25,117.67 224.25,119.04 v2(224.11,119.19) ; v2(31.28,36.79) CA7.2 ; CU28.2 v2(31.9,46.45) ; v2(56.52,15.2) PC721.2 56.54,15.91 PC716.1 ; CE28.2 289.87,7.21 v2(289.43,6.76) 288.96,7.23 RE66.1 ; PC6444.2 v2(279.92,65.82) ; JTOBII.7 154.06,167.05 v2(154.21,167.2) ; CG464.2 201.01,95.7 CG463.2 CG211.2 201.04,97.24 v2(201.03,97.25) ; v2(155.54,40.26) 155.35,40.07 CD29.2 ; DA5.1 v2(22.45,17.11) ; CH104.2 167.52,111.38 v2(167.16,111.74) ; v2(272.15,78.82) 272.15,78.26 CG357.2 ; v2(198.62,29.95) 198.62,29.46 198.64,29.45 CH180.2 ; v2(29.79,23.28) 30.23,22.83 RA16.2 ; C618.2 C617.2 332.86,47.39 v2(332.28,47.97) ; v2(310.63,15.82) CE27.2 ; CG437.2 256.29,49.77 CG436.2 256.29,51.28 v2(256.17,51.4) ; v2(137.41,50.51) 137.43,50.53 CD69.2 ; v2(38.87,34.56) CA39.2 ; CD77.2 157.94,50.78 158.12,50.6 v2(158.12,50.55) ; CH120.2 173.2,99.09 v2(173.55,99.44) ; v2(253.44,117) PC6369.2 ; v2(204.23,70.25) 204.02,70.05 CG407.2 ; PC803.2 241.47,41.87 241.97,42.37 241.97,43.19 241.82,43.34 v2(241.82,43.53) ; RC35.2 RC348.2 127.79,157.7 v2(128.34,157.7) ; v2(154.81,45.94) 154.4,46.34 CD25.2 ; CG332.2 CG325.2 270.44,109.07 v2(270.55,108.96) ; v2(202.7,12.92) 202.7,12.74 201.83,11.87 JWDB.5 ; CL22.2 272.96,166.91 v2(273.49,166.38) ; v2(157.36,40.42) 157.36,40.35 158.01,39.71 CD80.2 ; C2522.2 228.9,41.21 v2(229.62,40.48) ; CG462.2 CG193.2 205.03,96.49 v2(205.03,97.25) ; v2(27.05,13.06) RA81.2 ; v2(16.79,29.92) RA1.2 ; CV375.2 v2(170.87,181.77) ; 180.86,50.77 v2(181.54,50.77) ; RL3.2 v2(275.99,158.71) ; CD78.2 130.13,58.72 v2(130.16,58.69) ; RE75.2 CE44.2 v2(293.11,27.1) ; v2(139.85,54.38) 139.7,54.38 139.22,53.91 139.22,53.06 139.47,52.82 CD8.2 ; CG169.2 221.31,65.25 CG455.2 ; v2(262.72,157.5) CL28.2 CL29.2 ; v2(100.27,70.33) JFAN1.6 ; v2(150.49,40.32) 150.95,39.86 CD86.2 ; RG95.1 221.95,113.81 221.82,113.95 v2(221.47,113.95) ; v2(247.09,14.51) 247.09,14.57 247.6,15.08 PC308.2 ; v2(182.4,48.18) CD27.2 ; CH174.2 211.08,36.34 v2(211.09,36.33) 211.1,36.34 RH90.1 ; CE62.2 v2(312.91,56.6) ; v2(140,40.63) 140.48,40.14 CD23.2 ; CG191.2 197.06,96.49 v2(197.03,96.45) 196.8,96.22 CG394.2 ; v2(200.03,70) 200.05,69.98 RG161.2 ; CH189.2 210.94,38.69 v2(211.25,38.38) ; CG376.2 232.43,55.56 v2(232.82,55.18) ; CE59.2 v2(319.64,5.64) ; PR6066.1 PR6067.1 280.56,134.89 v2(280.44,134.77) ; PD1.1 v2(321.89,49.23) ; v2(153.41,101.06) 153.23,101.23 CH122.2 ; v2(172.16,43.28) 171.97,43.47 CD82.2 ; QU1.3 v2(295.19,62.34) ; PR28.1 v2(77.37,9.43) ; RD39.2 RD38.2 176.04,35.83 175.62,36.26 175.62,37.59 v2(175.73,37.7) ; v2(286.08,11.08) LE2.1 ; v2(258.79,51.31) 258.76,51.28 CG348.2 258.77,50.57 CG426.2 ; v2(314.23,24.13) 314.64,24.13 314.92,24.4 CU46.2 ; CG410.2 268.73,89.22 CG411.2 268.75,88.76 v2(269.15,88.36) ; CG404.2 205.27,73.69 v2(205.03,73.45) ; PC12.2 v2(68.88,5.84) ; v2(279.15,49.69) 278.81,49.34 PC6440.2 ; v2(188.86,168.82) CT38.2 ; RA76.2 30.16,1.95 29.98,2.13 CA257.2 29.4,2.43 v2(29.28,2.32) ; PC208.2 PC216.2 v2(86.56,36.06) ; 195.96,107.86 196.07,107.86 v2(196.54,107.39) ; CM10.2 v2(302.88,43.85) ; PR700.1 v2(62.84,31.84) ; v2(130.1,157.7) 129.43,157.04 RH497.1 ; v2(147.01,43.91) 147.77,44.67 CD85.2 ; CG369.2 219.23,56.79 v2(219.11,56.91) ; v2(272.15,73.96) 272.31,74.12 CG363.2 ; v2(126.49,12.36) CS16.2 ; v2(163.37,58.8) 164.09,59.52 CD2.2 ; CS5.2 v2(125.48,8.6) ; v2(210.33,29.74) 211.01,29.74 CH80.2 CH173.2 ; DA7.1 v2(47.59,11.54) ; v2(186.19,131.42) 186.7,131.42 187.2,131.92 PR582.1 ; v2(315.1,6.7) SW1.1 ; v2(190.38,171.04) 189.92,170.58 CT37.2 ; RH209.2 CD18.2 RH211.2 153.91,53.57 v2(153.48,53.99) ; RG557.2 v2(311.35,58.26) ; C622.2 v2(332.75,49.24) ; CG317.2 226.77,62.95 226.33,62.51 v2(226.19,62.51) ; RG453.2 199.46,98.83 v2(199.43,98.85) ; CG106.2 CG334.2 ; CG335.2 274.74,93.97 RG106.2 ; v2(182.75,133.14) 183.12,133.51 183.65,133.51 ; CU29.2 v2(30.62,47.09) ; v2(266.52,31.79) 266.52,29.33 266.1,28.91 PC8210.2 ; CE60.2 v2(320.85,5.64) ; CG188.2 206.83,71.45 v2(206.43,71.85) ; CG408.2 198.05,69.88 v2(198.18,70) ; 194.9,182.25 CT94.1 ; v2(309.83,45.5) RM31.2 ; RA7.2 v2(17.24,1.8) ; JFAN2.5 v2(293.72,80.09) ; PR562.1 v2(154.52,136.45) ; CG405.2 191.39,72.6 CG214.2 192.22,71.86 v2(192.23,71.85) ; v2(156.23,37.75) RD40.2 ; CG350.2 256.92,54.85 v2(256.99,54.91) ; v2(179.85,83.19) 179.33,82.67 C6.2 ; RT108.2 v2(319.92,52.72) ; v2(327.15,6.75) JIO.33 ; v2(204.67,112.11) 204.21,112.11 203.7,111.6 RG91.1 203.09,111.28 RG94.1 ; v2(328.47,28.58) JIO.34 ; v2(269.75,97.96) 269.54,98.17 CG343.2 CG416.2 ; CL27.2 v2(242.07,169.12) ; CM14.2 v2(315.54,43.44) ; CE7.2 v2(321.74,5.64) ; v2(249.99,62.51) 249.82,62.34 CG433.2 249.32,62.35 CG441.2 ; RE163.2 v2(300.36,31.97) ; v2(182.4,47.1) CD30.2
  GND1 w0.203: H7.1 269.07,152.84 ; H7.1 271.41,150.5 ; H7.1 270.77,148.8 ; H7.1 269.07,148.16 ; H7.1 267.37,148.8 ; H7.1 267.37,152.2 ; H7.1 266.73,150.5 ; H7.1 270.77,152.2 ; JUSBC1.3 197.82,177.47 ; JUSBC1.3 197.82,178.7 ; JUSBC1.3 197.82,179.93 ; JUSBC1.3 196.27,177.47 ; JUSBC1.3 197.04,179.93 ; JUSBC1.3 197.04,177.47 ; JUSBC1.3 196.27,179.93 ; 144.22,177.71 JCDRA.50 ; JCDRA.50 145.17,176.15 ; JCDRA.50 146.12,179.27 ; JCDRA.50 146.12,176.15 ; JCDRA.50 146.12,177.71 ; JCDRA.50 144.22,179.27 ; JCDRA.50 145.17,179.27 ; JCDRA.50 144.22,176.15 ; JHDMI.5 214.58,173.84 ; JHDMI.5 214.12,174.88 ; JHDMI.5 213.66,174.76 ; JHDMI.5 213.66,173.84 ; JHDMI.5 214.58,174.76 ; JHDMI.5 214.12,173.72 ; H13.1 201.81,154.53 ; H13.1 201.81,152 ; H13.1 197.33,154.53 ; H13.1 199.57,154.53 ; H13.1 199.57,149.47 ; H13.1 197.33,152 ; H13.1 197.33,149.47 ; H13.1 201.81,149.47 ; JUSB1.14 7.71,45.8 ; JUSB1.14 6.2,46.66 ; JUSB1.14 4.69,46.66 ; JUSB1.14 4.69,45.8 ; JUSB1.14 7.71,46.66 ; JDP.13 236.54,172.03 ; JDP.13 236.07,173.07 ; JDP.13 235.49,172.49 ; JDP.13 235.61,172.03 ; JDP.13 236.54,172.95 ; JDP.13 236.07,171.91 ; JDP.13 235.61,172.95 ; 91.45,55.48 H19.1 ; H19.1 94.29,55.48 ; H19.1 92.87,54.97 ; H19.1 90.94,56.9 ; H19.1 92.87,58.83 ; H19.1 91.45,58.32 ; H19.1 94.29,58.32 ; H19.1 94.8,56.9 ; JHDMI.17 220.12,174.88 ; JHDMI.17 219.66,174.76 ; JHDMI.17 220.58,174.76 ; JHDMI.17 219.66,173.84 ; JHDMI.17 220.58,173.84 ; JHDMI.17 220.12,173.72 ; 22.07,2.27 H16.1 ; H16.1 23.49,5.62 ; H16.1 22.07,6.13 ; H16.1 20.65,2.78 ; H16.1 20.14,4.2 ; H16.1 23.49,2.78 ; H16.1 20.65,5.62 ; H16.1 24,4.2 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 197.04,182.33 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 196.21,183.75 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 197.87,182.33 ; JUSBC1.4 196.21,185.17 ; JUSBC1.4 196.21,182.33 ; JUSBC2.5 6.35,65.4 ; JUSBC2.5 5.63,65.4 ; JUSBC2.5 7.07,63.39 ; JUSBC2.5 7.07,65.4 ; JUSBC2.5 5.63,64.3 ; JUSBC2.5 6.35,63.39 ; JUSBC2.5 5.63,63.39 ; H2.1 124.37,92.6 ; H2.1 122.67,88.56 ; H2.1 122.67,93.24 ; H2.1 120.33,90.9 ; H2.1 124.37,89.2 ; H2.1 120.97,89.2 ; H2.1 125.01,90.9 ; H2.1 120.97,92.6 ; H9.1 7.99,49.38 ; H9.1 6.57,48.87 ; H9.1 5.15,52.22 ; H9.1 5.15,49.38 ; H9.1 8.5,50.8 ; H9.1 6.57,52.73 ; H9.1 4.64,50.8 ; H9.1 7.99,52.22 ; 188.4,177.47 JUSBC1.1 ; JUSBC1.1 189.18,177.47 ; JUSBC1.1 189.18,179.93 ; JUSBC1.1 187.62,178.7 ; JUSBC1.1 187.62,177.47 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 188.4,179.93 ; 143.15,172.92 H17.1 ; H17.1 144.57,169.57 ; H17.1 145.99,172.92 ; H17.1 146.5,171.5 ; H17.1 145.99,170.08 ; H17.1 143.15,170.08 ; H17.1 144.57,173.43 ; H17.1 142.64,171.5 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 189.23,183.75 ; JUSBC1.2 188.4,185.17 ; JUSBC1.2 187.57,183.75 ; JUSBC1.2 187.57,182.33 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 188.4,182.33 ; JUSBC1.2 189.23,182.33 ; H21.1 263.49,7.92 ; H21.1 264,6.5 ; H21.1 260.14,6.5 ; H21.1 262.07,8.43 ; H21.1 260.65,7.92 ; H21.1 260.65,5.08 ; H21.1 263.49,5.08 ; H21.1 262.07,4.57 ; H6.1 179.67,8.43 ; H6.1 178.25,5.08 ; H6.1 177.74,6.5 ; H6.1 181.6,6.5 ; H6.1 181.09,7.92 ; H6.1 179.67,4.57 ; H6.1 181.09,5.08 ; H6.1 178.25,7.92 ; 203.37,50.2 H4.1 ; H4.1 202.73,48.5 ; H4.1 205.07,46.16 ; H4.1 206.77,50.2 ; H4.1 205.07,50.84 ; H4.1 206.77,46.8 ; H4.1 207.41,48.5 ; H4.1 203.37,46.8 ; JUSBC2.4 1.8,56.81 ; JUSBC2.4 3.22,55.15 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 1.8,55.15 ; JUSBC2.4 0.38,55.98 ; JUSBC2.4 0.38,56.81 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 0.38,55.15 ; JDP.24 230.35,170.34 ; JDP.24 228.8,170.34 ; JDP.24 228.8,171.65 ; JDP.24 229.57,170.34 ; JDP.24 229.57,172.96 ; JDP.24 228.8,172.96 ; JDP.24 230.35,171.65 ; 181.8,181.52 H15.1 ; H15.1 181.29,180.1 ; H15.1 184.64,181.52 ; H15.1 185.15,180.1 ; H15.1 184.64,178.68 ; H15.1 181.8,178.68 ; H15.1 183.22,182.03 ; H15.1 183.22,178.17 ; JUSB1.11 14.96,32.36 ; JUSB1.11 16.71,32.36 ; JUSB1.11 13.21,30.64 ; JUSB1.11 13.21,32.36 ; JUSB1.11 13.21,31.5 ; JUSB1.11 16.71,31.5 ; JUSB1.11 14.96,30.64 ; JUSB1.11 16.71,30.64 ; 26.14,54 H10.1 ; H10.1 30,54 ; H10.1 29.49,55.42 ; H10.1 29.49,52.58 ; H10.1 26.65,52.58 ; H10.1 26.65,55.42 ; H10.1 28.07,55.93 ; H10.1 28.07,52.07 ; 296.45,74.83 H20.1 ; H20.1 297.87,78.18 ; H20.1 299.29,74.83 ; H20.1 299.8,76.25 ; H20.1 296.45,77.67 ; H20.1 299.29,77.67 ; H20.1 295.94,76.25 ; H20.1 297.87,74.32 ; H23.1 270.45,4.26 ; H23.1 265.49,6.5 ; H23.1 265.49,4.26 ; H23.1 270.45,8.74 ; H23.1 265.49,8.74 ; H23.1 270.45,6.5 ; H23.1 267.97,8.74 ; H23.1 267.97,4.26 ; JHDMI.23 226.7,182.05 ; JHDMI.23 224.84,180.77 ; JHDMI.23 224.84,182.05 ; JHDMI.23 225.77,180.77 ; JHDMI.23 226.7,180.77 ; JHDMI.23 225.77,183.33 ; JHDMI.23 226.7,183.33 ; JHDMI.23 224.84,183.33 ; 5.62,55.2 JUSBC2.3 ; JUSBC2.3 6.85,55.2 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 5.62,56.76 ; JUSBC2.3 8.08,56.76 ; JUSBC2.3 8.08,55.98 ; JUSBC2.3 5.62,55.98 ; H8.1 6.49,68.38 ; H8.1 3.65,71.22 ; H8.1 6.49,71.22 ; H8.1 5.07,71.73 ; H8.1 3.65,68.38 ; H8.1 7,69.8 ; H8.1 5.07,67.87 ; H8.1 3.14,69.8 ; JDP.19 238.24,173.23 ; JDP.19 237.77,174.27 ; JDP.19 237.31,174.15 ; JDP.19 238.36,173.69 ; JDP.19 237.31,173.23 ; JDP.19 238.24,174.15 ; JDP.19 237.77,173.11 ; 181.67,88.06 H3.1 ; H3.1 180.04,88.67 ; H3.1 179.43,90.3 ; H3.1 183.3,88.67 ; H3.1 180.04,91.93 ; H3.1 183.91,90.3 ; H3.1 183.3,91.93 ; H3.1 181.67,92.54 ; H5.1 276.07,45.84 ; H5.1 277.77,45.2 ; H5.1 273.73,43.5 ; H5.1 276.07,41.16 ; H5.1 274.37,45.2 ; H5.1 277.77,41.8 ; H5.1 274.37,41.8 ; H5.1 278.41,43.5 ; 20.44,13.13 H11.1 ; H11.1 23.7,9.87 ; H11.1 20.44,9.87 ; H11.1 22.07,9.26 ; H11.1 23.7,13.13 ; H11.1 19.83,11.5 ; H11.1 22.07,13.74 ; H11.1 24.31,11.5 ; H18.1 103.49,5.08 ; H18.1 104,6.5 ; H18.1 100.14,6.5 ; H18.1 102.07,8.43 ; H18.1 102.07,4.57 ; H18.1 103.49,7.92 ; H18.1 100.65,5.08 ; H18.1 100.65,7.92 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 7.07,57.21 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 5.63,57.21 ; JUSBC2.6 6.35,55.2 ; JUSBC2.6 5.63,55.2 ; JUSBC2.6 7.07,55.2 ; JLAN.14 263.65,178.19 ; JLAN.14 262.74,176.43 ; JLAN.14 262.74,179.94 ; JLAN.14 263.65,179.94 ; JLAN.14 261.82,179.94 ; JLAN.14 263.65,176.43 ; JLAN.14 261.82,176.43 ; JLAN.14 261.82,178.19 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 0.38,65.45 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 0.38,63.79 ; JUSBC2.2 3.22,64.62 ; JUSBC2.2 1.8,63.79 ; JUSBC2.2 0.38,64.62 ; JUSBC2.2 1.8,65.45 ; JHDMI.2 212.62,173.33 ; JHDMI.2 212.16,172.29 ; JHDMI.2 212.16,173.21 ; JHDMI.2 213.08,172.29 ; JHDMI.2 212.04,172.75 ; JHDMI.2 212.62,172.17 ; JHDMI.2 213.08,173.21 ; JUSB1.4 17.14,34.99 ; JUSB1.4 15.96,34.99 ; JUSB1.4 17.31,34.4 ; JUSB1.4 16.55,33.64 ; JUSB1.4 17.14,33.81 ; JUSB1.4 15.96,33.81 ; JUSB1.4 15.79,34.4 ; JUSB1.4 16.55,35.16 ; 228.8,177.96 JDP.23 ; JDP.23 230.35,177.96 ; JDP.23 228.8,176.65 ; JDP.23 230.35,175.34 ; JDP.23 229.57,177.96 ; JDP.23 230.35,176.65 ; JDP.23 229.57,175.34 ; JDP.23 228.8,175.34 ; H22.1 199.29,54.18 ; H22.1 197.87,53.67 ; H22.1 197.87,57.53 ; H22.1 196.45,54.18 ; H22.1 199.8,55.6 ; H22.1 199.29,57.02 ; H22.1 195.94,55.6 ; H22.1 196.45,57.02 ; 13.21,44.3 JUSB1.12 ; JUSB1.12 14.96,45.16 ; JUSB1.12 16.71,45.16 ; JUSB1.12 16.71,43.44 ; JUSB1.12 16.71,44.3 ; JUSB1.12 14.96,43.44 ; JUSB1.12 13.21,43.44 ; JUSB1.12 13.21,45.16 ; 144.22,183.87 JCDRA.49 ; JCDRA.49 145.17,180.75 ; JCDRA.49 146.12,183.87 ; JCDRA.49 144.22,182.31 ; JCDRA.49 146.12,180.75 ; JCDRA.49 144.22,180.75 ; JCDRA.49 145.17,183.87 ; JCDRA.49 146.12,182.31 ; 239.8,171.65 JDP.22 ; JDP.22 241.35,172.96 ; JDP.22 241.35,171.65 ; JDP.22 241.35,170.34 ; JDP.22 240.57,170.34 ; JDP.22 239.8,170.34 ; JDP.22 240.57,172.96 ; 5.62,63.84 JUSBC2.1 ; JUSBC2.1 8.08,63.84 ; JUSBC2.1 8.08,64.62 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 5.62,64.62 ; JUSBC2.1 5.62,65.4 ; 232.37,173.11 JDP.1 ; JDP.1 231.79,173.69 ; JDP.1 232.84,173.23 ; JDP.1 231.91,174.15 ; JDP.1 231.91,173.23 ; JDP.1 232.84,174.15 ; JDP.1 232.37,174.27 ; 239.8,177.96 JDP.21 ; JDP.21 240.57,175.34 ; JDP.21 241.35,177.96 ; JDP.21 240.57,177.96 ; JDP.21 241.35,176.65 ; JDP.21 239.8,176.65 ; JDP.21 239.8,175.34 ; JDP.21 241.35,175.34 ; JPCMC.36 121.57,154.76 ; JPCMC.36 119.77,154.08 ; JPCMC.36 119.77,159.04 ; JPCMC.36 117.97,154.76 ; JPCMC.36 122.25,156.56 ; JPCMC.36 117.97,158.36 ; H1.1 161.87,157.3 ; H1.1 158.47,157.3 ; H1.1 160.17,153.26 ; H1.1 157.83,155.6 ; H1.1 158.47,153.9 ; H1.1 160.17,157.94 ; H1.1 161.87,153.9 ; H1.1 162.51,155.6 ; JUSBC1.6 197.82,178.48 ; JUSBC1.6 196.72,179.92 ; JUSBC1.6 197.82,179.92 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 195.81,178.48 ; JUSBC1.6 195.81,179.2 ; JUSBC1.6 195.81,179.92 ; JDP.7 234.07,173.07 ; JDP.7 233.61,172.95 ; JDP.7 234.54,172.95 ; JDP.7 234.66,172.49 ; JDP.7 233.61,172.03 ; JDP.7 234.07,171.91 ; JDP.7 234.54,172.03 ; 200.29,180.1 H14.1 ; H14.1 202.22,178.17 ; H14.1 204.15,180.1 ; H14.1 200.8,178.68 ; H14.1 203.64,178.68 ; H14.1 202.22,182.03 ; H14.1 203.64,181.52 ; H14.1 200.8,181.52 ; 187.62,178.48 JUSBC1.5 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 187.62,179.92 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 187.62,179.2 ; JUSBC1.5 189.63,179.2 ; JUSBC1.5 188.73,179.92 ; JUSB1.7 15.81,37.9 ; JUSB1.7 15.64,38.49 ; JUSB1.7 14.29,37.9 ; JUSB1.7 14.46,38.49 ; JUSB1.7 15.64,37.31 ; JUSB1.7 15.05,37.14 ; JUSB1.7 14.46,37.31 ; JUSB1.7 15.05,38.66 ; 217.12,173.72 JHDMI.11 ; JHDMI.11 217.58,174.76 ; JHDMI.11 216.66,173.84 ; JHDMI.11 216.66,174.76 ; JHDMI.11 217.58,173.84 ; JHDMI.11 217.12,174.88 ; 222.94,171.32 JHDMI.22 ; JHDMI.22 222.94,173.88 ; JHDMI.22 222.94,172.6 ; JHDMI.22 223.87,171.32 ; JHDMI.22 223.87,173.88 ; JHDMI.22 224.8,171.32 ; JHDMI.22 224.8,172.6 ; JHDMI.22 224.8,173.88 ; 176.72,179.27 JCDRA.47 ; JCDRA.47 178.62,176.15 ; JCDRA.47 177.67,179.27 ; JCDRA.47 177.67,176.15 ; JCDRA.47 176.72,176.15 ; JCDRA.47 176.72,177.71 ; JCDRA.47 178.62,177.71 ; JCDRA.47 178.62,179.27 ; JHDMI.21 208.4,179.52 ; JHDMI.21 207.47,182.08 ; JHDMI.21 208.4,180.8 ; JHDMI.21 206.54,179.52 ; JHDMI.21 208.4,182.08 ; JHDMI.21 206.54,180.8 ; JHDMI.21 207.47,179.52 ; JHDMI.21 206.54,182.08 ; 274.75,172.02 H12.1 ; H12.1 276.17,172.53 ; H12.1 277.59,172.02 ; H12.1 276.17,168.67 ; H12.1 274.24,170.6 ; H12.1 278.1,170.6 ; H12.1 277.59,169.18 ; H12.1 274.75,169.18 ; 215.62,172.17 JHDMI.8 ; JHDMI.8 215.16,172.29 ; JHDMI.8 215.16,173.21 ; JHDMI.8 216.08,173.21 ; JHDMI.8 215.62,173.33 ; JHDMI.8 216.08,172.29 ; 242.77,178.19 JLAN.16 ; JLAN.16 243.69,176.43 ; JLAN.16 244.6,178.19 ; JLAN.16 242.77,176.43 ; JLAN.16 242.77,179.94 ; JLAN.16 243.69,179.94 ; JLAN.16 244.6,176.43 ; JLAN.16 244.6,179.94 ; 4.69,30 JUSB1.13 ; JUSB1.13 6.2,29.14 ; JUSB1.13 7.71,30 ; JUSB1.13 7.71,29.14 ; JUSB1.13 4.69,29.14 ; 208.44,172.6 JHDMI.20 ; JHDMI.20 210.3,173.88 ; JHDMI.20 210.3,171.32 ; JHDMI.20 209.37,173.88 ; JHDMI.20 210.3,172.6 ; JHDMI.20 208.44,171.32 ; JHDMI.20 208.44,173.88 ; JHDMI.20 209.37,171.32 ; JCDRA.48 177.67,183.87 ; JCDRA.48 177.67,180.75 ; JCDRA.48 178.62,183.87 ; JCDRA.48 178.62,180.75 ; JCDRA.48 178.62,182.31 ; JCDRA.48 176.72,183.87 ; JCDRA.48 176.72,182.31 ; JCDRA.48 176.72,180.75
  IN1 w0.1: 239.97,83.78 239.97,84.12 239.97,84.12
  IN1 w0.127: v2(251.47,97.85) 251.17,97.55 250.77,97.55
  IN1 w0.15: 239.97,84.12 239.97,84.28 v2(239.68,84.57) ; v2(250.07,97.85) 250.26,97.85 250.55,97.55 250.77,97.55 ; v2(235.5,83.86) 235.77,84.13 235.77,85.05 v2(236.07,85.35) ; v2(237.57,83.95) 237.57,83.72 v2(238.04,83.25) 237.9,83.11 237.9,82.18 v2(237.79,82.08) ; v2(250.24,104.05) 250.43,103.85 251.17,103.85 v2(251.47,103.55) ; v2(224.04,86.58) 224.04,86.78 223.77,87.05 ; v2(251.99,99.53) 251.87,99.65 250.89,99.65 v2(250.74,99.5) 250.29,99.95 v2(250.07,99.95) ; v2(224.17,87.35) UG9.K8 223.77,87.05 ; v2(248.49,86.24) 248.41,86.16 248.41,85.34 v2(248.55,85.2) ; v2(223.43,83.73) 223.4,83.73 v2(222.93,83.27) 222.93,83.01 v2(223.46,82.48) 222.88,81.9 v2(222.88,81.86) 223.19,81.55 223.19,80.77 v2(222.92,80.5) 223.24,80.18 223.24,79.19 v2(223.12,79.07) 222.5,78.46 v2(222.5,78.4) ; 239.97,83.78 240.12,83.63 v2(240.12,83.4) 240.12,82.9 v2(239.67,82.45) 239.67,82.09 v2(239.87,81.89) ; v2(220.4,86.96) 220.52,86.85 v2(221.54,86.85) 221.74,87.05 UG9.K6 v2(222.77,87.35) 223.07,87.05 223.77,87.05 ; v2(238.07,84.79) 237.87,85 237.87,85.08 237.87,85.08 237.87,85.42 237.87,85.42 237.87,85.56 238.05,85.74 v2(238.05,86.11) 238.01,86.11 237.87,86.25 v2(237.87,87.75) ; v2(242.35,83.25) 242.35,83.37 v2(241.91,83.81) 241.91,83.99 v2(242.47,84.55) 242.47,84.9 v2(242.24,85.13) 242.24,85.83 v2(242.39,85.97) 242.39,86.73 v2(242.37,86.75)
  IN1 w0.2: v2(246.5,83.78) 246.14,83.78 v2(245.97,83.95) ; v2(251.57,90.95) 252.02,91.4 v2(252.02,91.45)
  IN1 w0.25: v2(249.67,85.97) 249.91,85.97 250.15,85.73 250.15,85.23 v2(250.74,84.64) 250.74,84.49 v2(250.14,83.9) ; v2(237.57,83.95) 238.07,84.45 v2(238.07,84.79) ; v2(250.07,97.85) 249.59,97.37 v2(249.32,97.37) 249.1,97.15 v2(248.77,97.15) 248.74,97.18 v2(248.74,97.85) ; v2(248.55,85.2) 248.55,84.67 v2(248.67,84.55) 248.67,84.05 v2(248.77,83.95) 248.11,83.95 v2(248.06,83.9) ; v2(235.5,83.86) v2(235.97,83.39) 235.97,83.1 v2(235.43,82.56) 235.43,82.19 v2(235.62,82) ; v2(283.47,94.62) 283.21,94.62 v2(282.55,93.96)
  IN1 w0.254: v2(259.53,74.33) 259.53,74.01 259.72,73.82 260.99,73.82
  IN1 w0.3: v2(249.67,85.97) 249.27,86.37 248.62,86.37 v2(248.49,86.24) ; v2(235.46,86.68) 235.47,86.67 v2(235.47,85.95) v2(236.07,85.35)
  IN1 w0.381: v2(251.47,97.25) v2(251.47,97.85)
  IN1 w0.508: 260.99,73.82 263.72,73.82 268.15,69.4 268.15,53.79 264.04,49.69 248.45,49.69 247.02,48.25 v2(247.02,48)
  GND2 w0.203: JDP.21 241.35,175.34 ; JDP.21 241.35,176.65 ; JDP.21 239.8,176.65 ; JDP.21 240.57,175.34 ; JDP.21 240.57,177.96 ; JDP.21 241.35,177.96 ; JDP.21 239.8,177.96 ; JDP.21 239.8,175.34 ; 5.63,64.3 JUSBC2.5 ; JUSBC2.5 7.07,65.4 ; JUSBC2.5 5.63,63.39 ; JUSBC2.5 7.07,63.39 ; JUSBC2.5 6.35,63.39 ; JUSBC2.5 5.63,65.4 ; JUSBC2.5 6.35,65.4 ; H23.1 267.97,8.74 ; H23.1 267.97,4.26 ; H23.1 265.49,6.5 ; H23.1 270.45,4.26 ; H23.1 265.49,8.74 ; H23.1 270.45,8.74 ; H23.1 265.49,4.26 ; H23.1 270.45,6.5 ; JDP.24 230.35,170.34 ; JDP.24 228.8,172.96 ; JDP.24 229.57,170.34 ; JDP.24 230.35,171.65 ; JDP.24 228.8,171.65 ; JDP.24 228.8,170.34 ; JDP.24 229.57,172.96 ; 5.07,67.87 H8.1 ; H8.1 7,69.8 ; H8.1 3.14,69.8 ; H8.1 3.65,71.22 ; H8.1 5.07,71.73 ; H8.1 6.49,71.22 ; H8.1 6.49,68.38 ; H8.1 3.65,68.38 ; JCDRA.48 178.62,182.31 ; JCDRA.48 176.72,180.75 ; JCDRA.48 177.67,183.87 ; JCDRA.48 178.62,183.87 ; JCDRA.48 177.67,180.75 ; JCDRA.48 178.62,180.75 ; JCDRA.48 176.72,182.31 ; JCDRA.48 176.72,183.87 ; 120.97,89.2 H2.1 ; H2.1 120.33,90.9 ; H2.1 125.01,90.9 ; H2.1 122.67,93.24 ; H2.1 124.37,89.2 ; H2.1 120.97,92.6 ; H2.1 124.37,92.6 ; H2.1 122.67,88.56 ; JHDMI.20 210.3,171.32 ; JHDMI.20 209.37,171.32 ; JHDMI.20 208.44,171.32 ; JHDMI.20 208.44,172.6 ; JHDMI.20 209.37,173.88 ; JHDMI.20 208.44,173.88 ; JHDMI.20 210.3,172.6 ; JHDMI.20 210.3,173.88 ; 214.12,173.72 JHDMI.5 ; JHDMI.5 213.66,174.76 ; JHDMI.5 214.58,174.76 ; JHDMI.5 213.66,173.84 ; JHDMI.5 214.12,174.88 ; JHDMI.5 214.58,173.84 ; 0.38,63.79 JUSBC2.2 ; JUSBC2.2 1.8,63.79 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 3.22,64.62 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 0.38,64.62 ; JUSBC2.2 0.38,65.45 ; JHDMI.17 220.58,173.84 ; JHDMI.17 220.12,174.88 ; JHDMI.17 220.12,173.72 ; JHDMI.17 219.66,174.76 ; JHDMI.17 219.66,173.84 ; JHDMI.17 220.58,174.76 ; 296.45,74.83 H20.1 ; H20.1 295.94,76.25 ; H20.1 297.87,78.18 ; H20.1 299.8,76.25 ; H20.1 296.45,77.67 ; H20.1 297.87,74.32 ; H20.1 299.29,74.83 ; H20.1 299.29,77.67 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 5.63,55.2 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 7.07,57.21 ; JUSBC2.6 6.35,55.2 ; JUSBC2.6 5.63,57.21 ; JUSBC2.6 7.07,55.2 ; 13.21,32.36 JUSB1.11 ; JUSB1.11 16.71,31.5 ; JUSB1.11 13.21,30.64 ; JUSB1.11 16.71,32.36 ; JUSB1.11 13.21,31.5 ; JUSB1.11 14.96,32.36 ; JUSB1.11 16.71,30.64 ; JUSB1.11 14.96,30.64 ; 195.81,178.48 JUSBC1.6 ; JUSBC1.6 197.82,179.92 ; JUSBC1.6 196.72,179.92 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 195.81,179.2 ; JUSBC1.6 195.81,179.92 ; JUSBC1.6 197.82,178.48 ; JUSB1.14 7.71,46.66 ; JUSB1.14 4.69,46.66 ; JUSB1.14 7.71,45.8 ; JUSB1.14 6.2,46.66 ; JUSB1.14 4.69,45.8 ; 199.57,149.47 H13.1 ; H13.1 197.33,149.47 ; H13.1 197.33,154.53 ; H13.1 199.57,154.53 ; H13.1 201.81,154.53 ; H13.1 197.33,152 ; H13.1 201.81,149.47 ; H13.1 201.81,152 ; H10.1 28.07,55.93 ; H10.1 30,54 ; H10.1 26.14,54 ; H10.1 26.65,52.58 ; H10.1 29.49,55.42 ; H10.1 28.07,52.07 ; H10.1 29.49,52.58 ; H10.1 26.65,55.42 ; H14.1 203.64,181.52 ; H14.1 203.64,178.68 ; H14.1 202.22,178.17 ; H14.1 200.8,181.52 ; H14.1 204.15,180.1 ; H14.1 200.29,180.1 ; H14.1 202.22,182.03 ; H14.1 200.8,178.68 ; H3.1 183.3,88.67 ; H3.1 179.43,90.3 ; H3.1 181.67,88.06 ; H3.1 183.3,91.93 ; H3.1 183.91,90.3 ; H3.1 181.67,92.54 ; H3.1 180.04,88.67 ; H3.1 180.04,91.93 ; 223.87,171.32 JHDMI.22 ; JHDMI.22 222.94,172.6 ; JHDMI.22 222.94,171.32 ; JHDMI.22 224.8,173.88 ; JHDMI.22 223.87,173.88 ; JHDMI.22 224.8,171.32 ; JHDMI.22 222.94,173.88 ; JHDMI.22 224.8,172.6 ; 145.17,176.15 JCDRA.50 ; JCDRA.50 146.12,177.71 ; JCDRA.50 144.22,179.27 ; JCDRA.50 146.12,179.27 ; JCDRA.50 145.17,179.27 ; JCDRA.50 144.22,177.71 ; JCDRA.50 146.12,176.15 ; JCDRA.50 144.22,176.15 ; 231.79,173.69 JDP.1 ; JDP.1 232.37,173.11 ; JDP.1 231.91,173.23 ; JDP.1 232.84,173.23 ; JDP.1 231.91,174.15 ; JDP.1 232.37,174.27 ; JDP.1 232.84,174.15 ; JDP.19 238.24,174.15 ; JDP.19 237.31,174.15 ; JDP.19 237.77,173.11 ; JDP.19 237.77,174.27 ; JDP.19 238.36,173.69 ; JDP.19 238.24,173.23 ; JDP.19 237.31,173.23 ; 15.96,34.99 JUSB1.4 ; JUSB1.4 15.96,33.81 ; JUSB1.4 15.79,34.4 ; JUSB1.4 16.55,33.64 ; JUSB1.4 17.14,33.81 ; JUSB1.4 17.31,34.4 ; JUSB1.4 16.55,35.16 ; JUSB1.4 17.14,34.99 ; H22.1 197.87,57.53 ; H22.1 199.8,55.6 ; H22.1 196.45,57.02 ; H22.1 199.29,57.02 ; H22.1 195.94,55.6 ; H22.1 196.45,54.18 ; H22.1 197.87,53.67 ; H22.1 199.29,54.18 ; JCDRA.49 145.17,183.87 ; JCDRA.49 144.22,180.75 ; JCDRA.49 146.12,180.75 ; JCDRA.49 144.22,183.87 ; JCDRA.49 146.12,183.87 ; JCDRA.49 145.17,180.75 ; JCDRA.49 144.22,182.31 ; JCDRA.49 146.12,182.31 ; H17.1 145.99,170.08 ; H17.1 144.57,173.43 ; H17.1 145.99,172.92 ; H17.1 142.64,171.5 ; H17.1 143.15,172.92 ; H17.1 144.57,169.57 ; H17.1 143.15,170.08 ; H17.1 146.5,171.5 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 196.21,183.75 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 196.21,182.33 ; JUSBC1.4 196.21,185.17 ; JUSBC1.4 197.04,182.33 ; JUSBC1.4 197.87,182.33 ; 187.62,177.47 JUSBC1.1 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 188.4,179.93 ; JUSBC1.1 188.4,177.47 ; JUSBC1.1 189.18,179.93 ; JUSBC1.1 189.18,177.47 ; JUSBC1.1 187.62,178.7 ; 233.61,172.03 JDP.7 ; JDP.7 234.54,172.95 ; JDP.7 233.61,172.95 ; JDP.7 234.07,171.91 ; JDP.7 234.54,172.03 ; JDP.7 234.07,173.07 ; JDP.7 234.66,172.49 ; 274.24,170.6 H12.1 ; H12.1 276.17,172.53 ; H12.1 276.17,168.67 ; H12.1 277.59,169.18 ; H12.1 274.75,169.18 ; H12.1 274.75,172.02 ; H12.1 277.59,172.02 ; H12.1 278.1,170.6 ; 102.07,4.57 H18.1 ; H18.1 100.65,7.92 ; H18.1 103.49,7.92 ; H18.1 103.49,5.08 ; H18.1 104,6.5 ; H18.1 100.65,5.08 ; H18.1 102.07,8.43 ; H18.1 100.14,6.5 ; H11.1 23.7,13.13 ; H11.1 22.07,9.26 ; H11.1 22.07,13.74 ; H11.1 19.83,11.5 ; H11.1 23.7,9.87 ; H11.1 20.44,13.13 ; H11.1 20.44,9.87 ; H11.1 24.31,11.5 ; 212.16,172.29 JHDMI.2 ; JHDMI.2 212.62,173.33 ; JHDMI.2 213.08,172.29 ; JHDMI.2 212.04,172.75 ; JHDMI.2 213.08,173.21 ; JHDMI.2 212.16,173.21 ; JHDMI.2 212.62,172.17 ; 274.37,41.8 H5.1 ; H5.1 278.41,43.5 ; H5.1 276.07,45.84 ; H5.1 277.77,45.2 ; H5.1 274.37,45.2 ; H5.1 273.73,43.5 ; H5.1 276.07,41.16 ; H5.1 277.77,41.8 ; JUSBC1.3 197.82,179.93 ; JUSBC1.3 197.04,177.47 ; JUSBC1.3 197.82,178.7 ; JUSBC1.3 196.27,179.93 ; JUSBC1.3 196.27,177.47 ; JUSBC1.3 197.82,177.47 ; JUSBC1.3 197.04,179.93 ; JUSB1.12 16.71,43.44 ; JUSB1.12 16.71,45.16 ; JUSB1.12 14.96,45.16 ; JUSB1.12 14.96,43.44 ; JUSB1.12 13.21,45.16 ; JUSB1.12 13.21,43.44 ; JUSB1.12 13.21,44.3 ; JUSB1.12 16.71,44.3 ; JLAN.16 244.6,179.94 ; JLAN.16 243.69,179.94 ; JLAN.16 244.6,176.43 ; JLAN.16 243.69,176.43 ; JLAN.16 242.77,176.43 ; JLAN.16 242.77,178.19 ; JLAN.16 242.77,179.94 ; JLAN.16 244.6,178.19 ; 6.85,55.2 JUSBC2.3 ; JUSBC2.3 8.08,56.76 ; JUSBC2.3 5.62,55.2 ; JUSBC2.3 8.08,55.98 ; JUSBC2.3 5.62,56.76 ; JUSBC2.3 5.62,55.98 ; JUSBC2.3 8.08,55.2 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 0.38,56.81 ; JUSBC2.4 1.8,56.81 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 1.8,55.15 ; JUSBC2.4 3.22,55.15 ; JUSBC2.4 0.38,55.15 ; JUSBC2.4 0.38,55.98 ; 176.72,176.15 JCDRA.47 ; JCDRA.47 176.72,177.71 ; JCDRA.47 177.67,179.27 ; JCDRA.47 178.62,176.15 ; JCDRA.47 178.62,179.27 ; JCDRA.47 177.67,176.15 ; JCDRA.47 176.72,179.27 ; JCDRA.47 178.62,177.71 ; H1.1 161.87,157.3 ; H1.1 161.87,153.9 ; H1.1 157.83,155.6 ; H1.1 158.47,153.9 ; H1.1 160.17,157.94 ; H1.1 160.17,153.26 ; H1.1 158.47,157.3 ; H1.1 162.51,155.6 ; JDP.22 241.35,171.65 ; JDP.22 240.57,170.34 ; JDP.22 241.35,172.96 ; JDP.22 241.35,170.34 ; JDP.22 239.8,171.65 ; JDP.22 240.57,172.96 ; JDP.22 239.8,170.34 ; 4.69,29.14 JUSB1.13 ; JUSB1.13 7.71,29.14 ; JUSB1.13 4.69,30 ; JUSB1.13 7.71,30 ; JUSB1.13 6.2,29.14 ; 117.97,154.76 JPCMC.36 ; JPCMC.36 119.77,154.08 ; JPCMC.36 122.25,156.56 ; JPCMC.36 117.97,158.36 ; JPCMC.36 119.77,159.04 ; JPCMC.36 121.57,154.76 ; JLAN.14 263.65,178.19 ; JLAN.14 263.65,179.94 ; JLAN.14 261.82,176.43 ; JLAN.14 261.82,179.94 ; JLAN.14 262.74,179.94 ; JLAN.14 262.74,176.43 ; JLAN.14 263.65,176.43 ; JLAN.14 261.82,178.19 ; JUSBC1.2 189.23,183.75 ; JUSBC1.2 187.57,182.33 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 188.4,185.17 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 189.23,182.33 ; JUSBC1.2 188.4,182.33 ; JUSBC1.2 187.57,183.75 ; 267.37,148.8 H7.1 ; H7.1 270.77,148.8 ; H7.1 269.07,148.16 ; H7.1 267.37,152.2 ; H7.1 271.41,150.5 ; H7.1 266.73,150.5 ; H7.1 270.77,152.2 ; H7.1 269.07,152.84 ; 20.14,4.2 H16.1 ; H16.1 20.65,5.62 ; H16.1 23.49,5.62 ; H16.1 24,4.2 ; H16.1 20.65,2.78 ; H16.1 23.49,2.78 ; H16.1 22.07,6.13 ; H16.1 22.07,2.27 ; 5.62,65.4 JUSBC2.1 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 8.08,63.84 ; JUSBC2.1 5.62,63.84 ; JUSBC2.1 5.62,64.62 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 8.08,64.62 ; JHDMI.8 216.08,172.29 ; JHDMI.8 215.62,172.17 ; JHDMI.8 215.16,173.21 ; JHDMI.8 216.08,173.21 ; JHDMI.8 215.16,172.29 ; JHDMI.8 215.62,173.33 ; 187.62,179.2 JUSBC1.5 ; JUSBC1.5 187.62,178.48 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 189.63,179.2 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 187.62,179.92 ; JUSBC1.5 188.73,179.92 ; JDP.13 236.54,172.03 ; JDP.13 235.61,172.95 ; JDP.13 235.61,172.03 ; JDP.13 236.54,172.95 ; JDP.13 236.07,171.91 ; JDP.13 236.07,173.07 ; JDP.13 235.49,172.49 ; H6.1 181.6,6.5 ; H6.1 179.67,8.43 ; H6.1 179.67,4.57 ; H6.1 178.25,7.92 ; H6.1 177.74,6.5 ; H6.1 178.25,5.08 ; H6.1 181.09,5.08 ; H6.1 181.09,7.92 ; H4.1 207.41,48.5 ; H4.1 202.73,48.5 ; H4.1 205.07,50.84 ; H4.1 203.37,50.2 ; H4.1 205.07,46.16 ; H4.1 206.77,46.8 ; H4.1 206.77,50.2 ; H4.1 203.37,46.8 ; 207.47,179.52 JHDMI.21 ; JHDMI.21 207.47,182.08 ; JHDMI.21 208.4,180.8 ; JHDMI.21 206.54,180.8 ; JHDMI.21 206.54,179.52 ; JHDMI.21 208.4,182.08 ; JHDMI.21 208.4,179.52 ; JHDMI.21 206.54,182.08 ; 228.8,177.96 JDP.23 ; JDP.23 229.57,177.96 ; JDP.23 229.57,175.34 ; JDP.23 230.35,177.96 ; JDP.23 228.8,176.65 ; JDP.23 230.35,175.34 ; JDP.23 230.35,176.65 ; JDP.23 228.8,175.34 ; 260.65,5.08 H21.1 ; H21.1 263.49,5.08 ; H21.1 260.14,6.5 ; H21.1 263.49,7.92 ; H21.1 262.07,8.43 ; H21.1 260.65,7.92 ; H21.1 262.07,4.57 ; H21.1 264,6.5 ; JHDMI.11 217.58,174.76 ; JHDMI.11 216.66,174.76 ; JHDMI.11 217.12,174.88 ; JHDMI.11 217.12,173.72 ; JHDMI.11 216.66,173.84 ; JHDMI.11 217.58,173.84 ; 91.45,55.48 H19.1 ; H19.1 92.87,58.83 ; H19.1 94.29,55.48 ; H19.1 91.45,58.32 ; H19.1 94.29,58.32 ; H19.1 90.94,56.9 ; H19.1 92.87,54.97 ; H19.1 94.8,56.9 ; JHDMI.23 225.77,183.33 ; JHDMI.23 224.84,180.77 ; JHDMI.23 226.7,180.77 ; JHDMI.23 224.84,182.05 ; JHDMI.23 226.7,183.33 ; JHDMI.23 225.77,180.77 ; JHDMI.23 224.84,183.33 ; JHDMI.23 226.7,182.05 ; H15.1 184.64,178.68 ; H15.1 181.8,181.52 ; H15.1 181.29,180.1 ; H15.1 181.8,178.68 ; H15.1 184.64,181.52 ; H15.1 183.22,178.17 ; H15.1 183.22,182.03 ; H15.1 185.15,180.1 ; 14.46,38.49 JUSB1.7 ; JUSB1.7 15.64,37.31 ; JUSB1.7 15.05,38.66 ; JUSB1.7 14.46,37.31 ; JUSB1.7 15.64,38.49 ; JUSB1.7 15.81,37.9 ; JUSB1.7 14.29,37.9 ; JUSB1.7 15.05,37.14 ; 5.15,52.22 H9.1 ; H9.1 7.99,52.22 ; H9.1 4.64,50.8 ; H9.1 6.57,52.73 ; H9.1 6.57,48.87 ; H9.1 5.15,49.38 ; H9.1 7.99,49.38 ; H9.1 8.5,50.8
  IN2 w0.508: v2(29.79,23.28) 29.79,23.59 30.87,24.67 33.85,24.67 34.77,25.58 v2(34.77,25.61)
  GND3 w0.203: 13.21,30.64 JUSB1.11 ; JUSB1.11 16.71,30.64 ; JUSB1.11 14.96,30.64 ; JUSB1.11 16.71,31.5 ; JUSB1.11 13.21,31.5 ; JUSB1.11 14.96,32.36 ; JUSB1.11 13.21,32.36 ; JUSB1.11 16.71,32.36 ; 19.83,11.5 H11.1 ; H11.1 20.44,13.13 ; H11.1 23.7,9.87 ; H11.1 24.31,11.5 ; H11.1 22.07,9.26 ; H11.1 20.44,9.87 ; H11.1 23.7,13.13 ; H11.1 22.07,13.74 ; 1.8,55.15 JUSBC2.4 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 1.8,56.81 ; JUSBC2.4 0.38,56.81 ; JUSBC2.4 0.38,55.98 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 0.38,55.15 ; JUSBC2.4 3.22,55.15 ; 195.81,178.48 JUSBC1.6 ; JUSBC1.6 195.81,179.92 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 195.81,179.2 ; JUSBC1.6 197.82,179.92 ; JUSBC1.6 196.72,179.92 ; JUSBC1.6 197.82,178.48 ; 15.79,34.4 JUSB1.4 ; JUSB1.4 16.55,35.16 ; JUSB1.4 17.31,34.4 ; JUSB1.4 15.96,34.99 ; JUSB1.4 17.14,34.99 ; JUSB1.4 16.55,33.64 ; JUSB1.4 15.96,33.81 ; JUSB1.4 17.14,33.81 ; H7.1 269.07,152.84 ; H7.1 271.41,150.5 ; H7.1 269.07,148.16 ; H7.1 270.77,152.2 ; H7.1 270.77,148.8 ; H7.1 266.73,150.5 ; H7.1 267.37,148.8 ; H7.1 267.37,152.2 ; JDP.23 230.35,177.96 ; JDP.23 230.35,175.34 ; JDP.23 228.8,175.34 ; JDP.23 229.57,175.34 ; JDP.23 229.57,177.96 ; JDP.23 230.35,176.65 ; JDP.23 228.8,177.96 ; JDP.23 228.8,176.65 ; 260.65,5.08 H21.1 ; H21.1 264,6.5 ; H21.1 263.49,7.92 ; H21.1 262.07,8.43 ; H21.1 260.65,7.92 ; H21.1 260.14,6.5 ; H21.1 263.49,5.08 ; H21.1 262.07,4.57 ; 233.61,172.95 JDP.7 ; JDP.7 234.66,172.49 ; JDP.7 234.07,171.91 ; JDP.7 234.54,172.95 ; JDP.7 233.61,172.03 ; JDP.7 234.54,172.03 ; JDP.7 234.07,173.07 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 187.57,182.33 ; JUSBC1.2 188.4,185.17 ; JUSBC1.2 189.23,183.75 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 188.4,182.33 ; JUSBC1.2 187.57,183.75 ; JUSBC1.2 189.23,182.33 ; JDP.22 240.57,172.96 ; JDP.22 241.35,172.96 ; JDP.22 239.8,170.34 ; JDP.22 240.57,170.34 ; JDP.22 241.35,170.34 ; JDP.22 241.35,171.65 ; JDP.22 239.8,171.65 ; 183.22,178.17 H15.1 ; H15.1 181.8,178.68 ; H15.1 184.64,181.52 ; H15.1 181.29,180.1 ; H15.1 181.8,181.52 ; H15.1 184.64,178.68 ; H15.1 183.22,182.03 ; H15.1 185.15,180.1 ; JHDMI.23 226.7,182.05 ; JHDMI.23 224.84,182.05 ; JHDMI.23 224.84,180.77 ; JHDMI.23 224.84,183.33 ; JHDMI.23 226.7,180.77 ; JHDMI.23 226.7,183.33 ; JHDMI.23 225.77,180.77 ; JHDMI.23 225.77,183.33 ; 242.77,178.19 JLAN.16 ; JLAN.16 244.6,178.19 ; JLAN.16 242.77,176.43 ; JLAN.16 243.69,176.43 ; JLAN.16 242.77,179.94 ; JLAN.16 244.6,176.43 ; JLAN.16 244.6,179.94 ; JLAN.16 243.69,179.94 ; JCDRA.48 178.62,182.31 ; JCDRA.48 178.62,183.87 ; JCDRA.48 176.72,180.75 ; JCDRA.48 177.67,180.75 ; JCDRA.48 176.72,183.87 ; JCDRA.48 177.67,183.87 ; JCDRA.48 178.62,180.75 ; JCDRA.48 176.72,182.31 ; H13.1 199.57,154.53 ; H13.1 199.57,149.47 ; H13.1 201.81,154.53 ; H13.1 201.81,152 ; H13.1 197.33,149.47 ; H13.1 197.33,152 ; H13.1 201.81,149.47 ; H13.1 197.33,154.53 ; JUSBC1.1 189.18,177.47 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 188.4,179.93 ; JUSBC1.1 188.4,177.47 ; JUSBC1.1 187.62,178.7 ; JUSBC1.1 187.62,177.47 ; JUSBC1.1 189.18,179.93 ; 3.65,71.22 H8.1 ; H8.1 3.65,68.38 ; H8.1 5.07,67.87 ; H8.1 6.49,68.38 ; H8.1 5.07,71.73 ; H8.1 6.49,71.22 ; H8.1 3.14,69.8 ; H8.1 7,69.8 ; JDP.21 241.35,177.96 ; JDP.21 241.35,175.34 ; JDP.21 239.8,177.96 ; JDP.21 241.35,176.65 ; JDP.21 240.57,177.96 ; JDP.21 240.57,175.34 ; JDP.21 239.8,176.65 ; JDP.21 239.8,175.34 ; 187.62,178.48 JUSBC1.5 ; JUSBC1.5 187.62,179.2 ; JUSBC1.5 189.63,179.2 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 187.62,179.92 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 188.73,179.92 ; 197.04,177.47 JUSBC1.3 ; JUSBC1.3 197.04,179.93 ; JUSBC1.3 196.27,179.93 ; JUSBC1.3 196.27,177.47 ; JUSBC1.3 197.82,177.47 ; JUSBC1.3 197.82,178.7 ; JUSBC1.3 197.82,179.93 ; 179.43,90.3 H3.1 ; H3.1 181.67,92.54 ; H3.1 180.04,91.93 ; H3.1 180.04,88.67 ; H3.1 183.3,91.93 ; H3.1 183.3,88.67 ; H3.1 181.67,88.06 ; H3.1 183.91,90.3 ; JHDMI.21 208.4,180.8 ; JHDMI.21 208.4,179.52 ; JHDMI.21 208.4,182.08 ; JHDMI.21 206.54,179.52 ; JHDMI.21 207.47,182.08 ; JHDMI.21 206.54,182.08 ; JHDMI.21 207.47,179.52 ; JHDMI.21 206.54,180.8 ; 235.49,172.49 JDP.13 ; JDP.13 235.61,172.03 ; JDP.13 236.54,172.03 ; JDP.13 235.61,172.95 ; JDP.13 236.07,173.07 ; JDP.13 236.07,171.91 ; JDP.13 236.54,172.95 ; 213.66,173.84 JHDMI.5 ; JHDMI.5 214.58,173.84 ; JHDMI.5 214.58,174.76 ; JHDMI.5 214.12,173.72 ; JHDMI.5 214.12,174.88 ; JHDMI.5 213.66,174.76 ; 5.62,63.84 JUSBC2.1 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 5.62,64.62 ; JUSBC2.1 8.08,63.84 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 8.08,64.62 ; JUSBC2.1 5.62,65.4 ; 120.33,90.9 H2.1 ; H2.1 124.37,92.6 ; H2.1 120.97,92.6 ; H2.1 122.67,88.56 ; H2.1 125.01,90.9 ; H2.1 120.97,89.2 ; H2.1 124.37,89.2 ; H2.1 122.67,93.24 ; H20.1 297.87,78.18 ; H20.1 299.8,76.25 ; H20.1 299.29,74.83 ; H20.1 299.29,77.67 ; H20.1 297.87,74.32 ; H20.1 295.94,76.25 ; H20.1 296.45,77.67 ; H20.1 296.45,74.83 ; H12.1 277.59,169.18 ; H12.1 274.24,170.6 ; H12.1 274.75,172.02 ; H12.1 278.1,170.6 ; H12.1 277.59,172.02 ; H12.1 274.75,169.18 ; H12.1 276.17,172.53 ; H12.1 276.17,168.67 ; JHDMI.20 210.3,171.32 ; JHDMI.20 210.3,173.88 ; JHDMI.20 208.44,171.32 ; JHDMI.20 209.37,173.88 ; JHDMI.20 210.3,172.6 ; JHDMI.20 208.44,173.88 ; JHDMI.20 208.44,172.6 ; JHDMI.20 209.37,171.32 ; 6.35,55.2 JUSBC2.6 ; JUSBC2.6 5.63,57.21 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 7.07,57.21 ; JUSBC2.6 5.63,55.2 ; JUSBC2.6 7.07,55.2 ; H4.1 206.77,50.2 ; H4.1 205.07,50.84 ; H4.1 203.37,46.8 ; H4.1 206.77,46.8 ; H4.1 203.37,50.2 ; H4.1 202.73,48.5 ; H4.1 205.07,46.16 ; H4.1 207.41,48.5 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 0.38,65.45 ; JUSBC2.2 0.38,63.79 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 0.38,64.62 ; JUSBC2.2 3.22,64.62 ; JUSBC2.2 1.8,63.79 ; JHDMI.22 224.8,173.88 ; JHDMI.22 222.94,172.6 ; JHDMI.22 223.87,171.32 ; JHDMI.22 224.8,172.6 ; JHDMI.22 222.94,171.32 ; JHDMI.22 222.94,173.88 ; JHDMI.22 224.8,171.32 ; JHDMI.22 223.87,173.88 ; 26.65,52.58 H10.1 ; H10.1 26.65,55.42 ; H10.1 29.49,52.58 ; H10.1 26.14,54 ; H10.1 29.49,55.42 ; H10.1 30,54 ; H10.1 28.07,52.07 ; H10.1 28.07,55.93 ; 178.25,7.92 H6.1 ; H6.1 181.09,7.92 ; H6.1 179.67,8.43 ; H6.1 177.74,6.5 ; H6.1 181.09,5.08 ; H6.1 179.67,4.57 ; H6.1 181.6,6.5 ; H6.1 178.25,5.08 ; JDP.1 232.37,174.27 ; JDP.1 231.79,173.69 ; JDP.1 232.37,173.11 ; JDP.1 232.84,174.15 ; JDP.1 232.84,173.23 ; JDP.1 231.91,173.23 ; JDP.1 231.91,174.15 ; 91.45,58.32 H19.1 ; H19.1 90.94,56.9 ; H19.1 94.29,55.48 ; H19.1 92.87,58.83 ; H19.1 94.8,56.9 ; H19.1 92.87,54.97 ; H19.1 91.45,55.48 ; H19.1 94.29,58.32 ; 276.07,41.16 H5.1 ; H5.1 277.77,45.2 ; H5.1 278.41,43.5 ; H5.1 274.37,45.2 ; H5.1 274.37,41.8 ; H5.1 273.73,43.5 ; H5.1 277.77,41.8 ; H5.1 276.07,45.84 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 8.08,56.76 ; JUSBC2.3 8.08,55.98 ; JUSBC2.3 5.62,56.76 ; JUSBC2.3 5.62,55.2 ; JUSBC2.3 6.85,55.2 ; JUSBC2.3 5.62,55.98 ; JCDRA.50 145.17,179.27 ; JCDRA.50 146.12,177.71 ; JCDRA.50 146.12,179.27 ; JCDRA.50 144.22,179.27 ; JCDRA.50 146.12,176.15 ; JCDRA.50 144.22,176.15 ; JCDRA.50 144.22,177.71 ; JCDRA.50 145.17,176.15 ; H17.1 145.99,172.92 ; H17.1 146.5,171.5 ; H17.1 142.64,171.5 ; H17.1 143.15,172.92 ; H17.1 143.15,170.08 ; H17.1 145.99,170.08 ; H17.1 144.57,173.43 ; H17.1 144.57,169.57 ; 144.22,180.75 JCDRA.49 ; JCDRA.49 145.17,183.87 ; JCDRA.49 145.17,180.75 ; JCDRA.49 146.12,182.31 ; JCDRA.49 146.12,183.87 ; JCDRA.49 144.22,183.87 ; JCDRA.49 146.12,180.75 ; JCDRA.49 144.22,182.31 ; H22.1 197.87,57.53 ; H22.1 196.45,57.02 ; H22.1 199.29,54.18 ; H22.1 195.94,55.6 ; H22.1 197.87,53.67 ; H22.1 199.8,55.6 ; H22.1 196.45,54.18 ; H22.1 199.29,57.02 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 196.21,183.75 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 196.21,185.17 ; JUSBC1.4 197.87,182.33 ; JUSBC1.4 196.21,182.33 ; JUSBC1.4 197.04,182.33 ; 6.35,63.39 JUSBC2.5 ; JUSBC2.5 5.63,64.3 ; JUSBC2.5 7.07,63.39 ; JUSBC2.5 6.35,65.4 ; JUSBC2.5 5.63,63.39 ; JUSBC2.5 5.63,65.4 ; JUSBC2.5 7.07,65.4 ; 200.8,178.68 H14.1 ; H14.1 202.22,178.17 ; H14.1 203.64,178.68 ; H14.1 200.8,181.52 ; H14.1 202.22,182.03 ; H14.1 200.29,180.1 ; H14.1 203.64,181.52 ; H14.1 204.15,180.1 ; JUSB1.14 6.2,46.66 ; JUSB1.14 4.69,46.66 ; JUSB1.14 7.71,46.66 ; JUSB1.14 4.69,45.8 ; JUSB1.14 7.71,45.8 ; JHDMI.2 213.08,172.29 ; JHDMI.2 212.16,172.29 ; JHDMI.2 212.62,173.33 ; JHDMI.2 212.62,172.17 ; JHDMI.2 213.08,173.21 ; JHDMI.2 212.16,173.21 ; JHDMI.2 212.04,172.75 ; H18.1 102.07,8.43 ; H18.1 102.07,4.57 ; H18.1 103.49,7.92 ; H18.1 103.49,5.08 ; H18.1 104,6.5 ; H18.1 100.14,6.5 ; H18.1 100.65,7.92 ; H18.1 100.65,5.08 ; H23.1 267.97,8.74 ; H23.1 270.45,6.5 ; H23.1 265.49,8.74 ; H23.1 270.45,4.26 ; H23.1 265.49,6.5 ; H23.1 270.45,8.74 ; H23.1 265.49,4.26 ; H23.1 267.97,4.26 ; 20.65,5.62 H16.1 ; H16.1 24,4.2 ; H16.1 23.49,5.62 ; H16.1 20.14,4.2 ; H16.1 22.07,2.27 ; H16.1 22.07,6.13 ; H16.1 20.65,2.78 ; H16.1 23.49,2.78 ; 261.82,179.94 JLAN.14 ; JLAN.14 263.65,179.94 ; JLAN.14 261.82,178.19 ; JLAN.14 262.74,179.94 ; JLAN.14 261.82,176.43 ; JLAN.14 263.65,178.19 ; JLAN.14 263.65,176.43 ; JLAN.14 262.74,176.43 ; 219.66,173.84 JHDMI.17 ; JHDMI.17 220.12,174.88 ; JHDMI.17 220.58,174.76 ; JHDMI.17 220.12,173.72 ; JHDMI.17 220.58,173.84 ; JHDMI.17 219.66,174.76 ; JUSB1.13 7.71,29.14 ; JUSB1.13 6.2,29.14 ; JUSB1.13 7.71,30 ; JUSB1.13 4.69,29.14 ; JUSB1.13 4.69,30 ; H9.1 6.57,52.73 ; H9.1 4.64,50.8 ; H9.1 5.15,52.22 ; H9.1 6.57,48.87 ; H9.1 7.99,52.22 ; H9.1 5.15,49.38 ; H9.1 7.99,49.38 ; H9.1 8.5,50.8 ; 160.17,153.26 H1.1 ; H1.1 162.51,155.6 ; H1.1 158.47,157.3 ; H1.1 157.83,155.6 ; H1.1 158.47,153.9 ; H1.1 161.87,153.9 ; H1.1 161.87,157.3 ; H1.1 160.17,157.94 ; 217.12,173.72 JHDMI.11 ; JHDMI.11 216.66,173.84 ; JHDMI.11 217.58,174.76 ; JHDMI.11 217.58,173.84 ; JHDMI.11 217.12,174.88 ; JHDMI.11 216.66,174.76 ; 237.31,174.15 JDP.19 ; JDP.19 237.31,173.23 ; JDP.19 238.24,173.23 ; JDP.19 238.36,173.69 ; JDP.19 237.77,174.27 ; JDP.19 238.24,174.15 ; JDP.19 237.77,173.11 ; 176.72,179.27 JCDRA.47 ; JCDRA.47 176.72,176.15 ; JCDRA.47 177.67,179.27 ; JCDRA.47 177.67,176.15 ; JCDRA.47 178.62,176.15 ; JCDRA.47 178.62,179.27 ; JCDRA.47 178.62,177.71 ; JCDRA.47 176.72,177.71 ; 228.8,170.34 JDP.24 ; JDP.24 228.8,172.96 ; JDP.24 230.35,171.65 ; JDP.24 228.8,171.65 ; JDP.24 230.35,170.34 ; JDP.24 229.57,170.34 ; JDP.24 229.57,172.96 ; JPCMC.36 119.77,159.04 ; JPCMC.36 122.25,156.56 ; JPCMC.36 119.77,154.08 ; JPCMC.36 117.97,154.76 ; JPCMC.36 117.97,158.36 ; JPCMC.36 121.57,154.76 ; 215.16,172.29 JHDMI.8 ; JHDMI.8 215.62,173.33 ; JHDMI.8 215.62,172.17 ; JHDMI.8 215.16,173.21 ; JHDMI.8 216.08,172.29 ; JHDMI.8 216.08,173.21 ; 15.05,37.14 JUSB1.7 ; JUSB1.7 15.81,37.9 ; JUSB1.7 15.64,38.49 ; JUSB1.7 14.46,38.49 ; JUSB1.7 15.64,37.31 ; JUSB1.7 14.46,37.31 ; JUSB1.7 14.29,37.9 ; JUSB1.7 15.05,38.66 ; 13.21,43.44 JUSB1.12 ; JUSB1.12 16.71,45.16 ; JUSB1.12 14.96,43.44 ; JUSB1.12 16.71,43.44 ; JUSB1.12 16.71,44.3 ; JUSB1.12 13.21,44.3 ; JUSB1.12 13.21,45.16 ; JUSB1.12 14.96,45.16
  GND4 w0.203: 260.65,7.92 H21.1 ; H21.1 260.14,6.5 ; H21.1 263.49,5.08 ; H21.1 262.07,4.57 ; H21.1 263.49,7.92 ; H21.1 264,6.5 ; H21.1 262.07,8.43 ; H21.1 260.65,5.08 ; H6.1 181.09,5.08 ; H6.1 181.6,6.5 ; H6.1 178.25,5.08 ; H6.1 177.74,6.5 ; H6.1 179.67,4.57 ; H6.1 181.09,7.92 ; H6.1 179.67,8.43 ; H6.1 178.25,7.92 ; JUSBC2.4 3.22,55.15 ; JUSBC2.4 0.38,55.98 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 0.38,55.15 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 1.8,55.15 ; JUSBC2.4 0.38,56.81 ; JUSBC2.4 1.8,56.81 ; 14.46,37.31 JUSB1.7 ; JUSB1.7 14.46,38.49 ; JUSB1.7 15.05,38.66 ; JUSB1.7 15.64,37.31 ; JUSB1.7 14.29,37.9 ; JUSB1.7 15.05,37.14 ; JUSB1.7 15.64,38.49 ; JUSB1.7 15.81,37.9 ; H15.1 185.15,180.1 ; H15.1 184.64,178.68 ; H15.1 183.22,182.03 ; H15.1 184.64,181.52 ; H15.1 181.29,180.1 ; H15.1 183.22,178.17 ; H15.1 181.8,181.52 ; H15.1 181.8,178.68 ; JHDMI.23 225.77,183.33 ; JHDMI.23 226.7,180.77 ; JHDMI.23 224.84,182.05 ; JHDMI.23 224.84,180.77 ; JHDMI.23 225.77,180.77 ; JHDMI.23 224.84,183.33 ; JHDMI.23 226.7,182.05 ; JHDMI.23 226.7,183.33 ; 237.31,174.15 JDP.19 ; JDP.19 238.36,173.69 ; JDP.19 238.24,174.15 ; JDP.19 237.31,173.23 ; JDP.19 237.77,173.11 ; JDP.19 237.77,174.27 ; JDP.19 238.24,173.23 ; JCDRA.47 178.62,176.15 ; JCDRA.47 178.62,177.71 ; JCDRA.47 177.67,176.15 ; JCDRA.47 176.72,176.15 ; JCDRA.47 177.67,179.27 ; JCDRA.47 178.62,179.27 ; JCDRA.47 176.72,177.71 ; JCDRA.47 176.72,179.27 ; JHDMI.2 212.62,173.33 ; JHDMI.2 212.16,173.21 ; JHDMI.2 213.08,173.21 ; JHDMI.2 212.62,172.17 ; JHDMI.2 213.08,172.29 ; JHDMI.2 212.16,172.29 ; JHDMI.2 212.04,172.75 ; H12.1 276.17,172.53 ; H12.1 274.75,172.02 ; H12.1 274.75,169.18 ; H12.1 278.1,170.6 ; H12.1 277.59,169.18 ; H12.1 276.17,168.67 ; H12.1 274.24,170.6 ; H12.1 277.59,172.02 ; 177.67,180.75 JCDRA.48 ; JCDRA.48 176.72,183.87 ; JCDRA.48 176.72,180.75 ; JCDRA.48 176.72,182.31 ; JCDRA.48 178.62,182.31 ; JCDRA.48 178.62,183.87 ; JCDRA.48 177.67,183.87 ; JCDRA.48 178.62,180.75 ; H23.1 267.97,8.74 ; H23.1 270.45,4.26 ; H23.1 265.49,4.26 ; H23.1 265.49,6.5 ; H23.1 270.45,6.5 ; H23.1 270.45,8.74 ; H23.1 267.97,4.26 ; H23.1 265.49,8.74 ; H19.1 92.87,58.83 ; H19.1 91.45,55.48 ; H19.1 90.94,56.9 ; H19.1 94.29,58.32 ; H19.1 94.29,55.48 ; H19.1 91.45,58.32 ; H19.1 94.8,56.9 ; H19.1 92.87,54.97 ; H9.1 6.57,52.73 ; H9.1 6.57,48.87 ; H9.1 5.15,52.22 ; H9.1 4.64,50.8 ; H9.1 7.99,49.38 ; H9.1 7.99,52.22 ; H9.1 5.15,49.38 ; H9.1 8.5,50.8 ; 6.35,55.2 JUSBC2.6 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 7.07,55.2 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 5.63,57.21 ; JUSBC2.6 5.63,55.2 ; JUSBC2.6 7.07,57.21 ; 16.55,33.64 JUSB1.4 ; JUSB1.4 17.31,34.4 ; JUSB1.4 15.79,34.4 ; JUSB1.4 16.55,35.16 ; JUSB1.4 15.96,34.99 ; JUSB1.4 17.14,33.81 ; JUSB1.4 15.96,33.81 ; JUSB1.4 17.14,34.99 ; JCDRA.49 146.12,180.75 ; JCDRA.49 145.17,180.75 ; JCDRA.49 144.22,182.31 ; JCDRA.49 146.12,182.31 ; JCDRA.49 146.12,183.87 ; JCDRA.49 144.22,183.87 ; JCDRA.49 145.17,183.87 ; JCDRA.49 144.22,180.75 ; JCDRA.50 146.12,176.15 ; JCDRA.50 144.22,176.15 ; JCDRA.50 144.22,177.71 ; JCDRA.50 146.12,177.71 ; JCDRA.50 146.12,179.27 ; JCDRA.50 145.17,179.27 ; JCDRA.50 145.17,176.15 ; JCDRA.50 144.22,179.27 ; 187.62,177.47 JUSBC1.1 ; JUSBC1.1 189.18,179.93 ; JUSBC1.1 187.62,178.7 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 189.18,177.47 ; JUSBC1.1 188.4,177.47 ; JUSBC1.1 188.4,179.93 ; H1.1 162.51,155.6 ; H1.1 158.47,153.9 ; H1.1 161.87,153.9 ; H1.1 160.17,157.94 ; H1.1 160.17,153.26 ; H1.1 158.47,157.3 ; H1.1 157.83,155.6 ; H1.1 161.87,157.3 ; H3.1 183.3,91.93 ; H3.1 180.04,88.67 ; H3.1 179.43,90.3 ; H3.1 181.67,88.06 ; H3.1 180.04,91.93 ; H3.1 181.67,92.54 ; H3.1 183.3,88.67 ; H3.1 183.91,90.3 ; 203.37,50.2 H4.1 ; H4.1 206.77,50.2 ; H4.1 205.07,50.84 ; H4.1 202.73,48.5 ; H4.1 206.77,46.8 ; H4.1 207.41,48.5 ; H4.1 203.37,46.8 ; H4.1 205.07,46.16 ; H18.1 104,6.5 ; H18.1 100.65,7.92 ; H18.1 103.49,7.92 ; H18.1 100.65,5.08 ; H18.1 102.07,8.43 ; H18.1 103.49,5.08 ; H18.1 102.07,4.57 ; H18.1 100.14,6.5 ; JHDMI.21 208.4,180.8 ; JHDMI.21 207.47,182.08 ; JHDMI.21 207.47,179.52 ; JHDMI.21 206.54,182.08 ; JHDMI.21 206.54,179.52 ; JHDMI.21 206.54,180.8 ; JHDMI.21 208.4,182.08 ; JHDMI.21 208.4,179.52 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 6.85,55.2 ; JUSBC2.3 5.62,55.2 ; JUSBC2.3 8.08,56.76 ; JUSBC2.3 5.62,55.98 ; JUSBC2.3 8.08,55.98 ; JUSBC2.3 5.62,56.76 ; JPCMC.36 119.77,159.04 ; JPCMC.36 122.25,156.56 ; JPCMC.36 119.77,154.08 ; JPCMC.36 117.97,158.36 ; JPCMC.36 121.57,154.76 ; JPCMC.36 117.97,154.76 ; JDP.24 230.35,170.34 ; JDP.24 228.8,170.34 ; JDP.24 229.57,172.96 ; JDP.24 228.8,171.65 ; JDP.24 230.35,171.65 ; JDP.24 228.8,172.96 ; JDP.24 229.57,170.34 ; H5.1 276.07,45.84 ; H5.1 273.73,43.5 ; H5.1 278.41,43.5 ; H5.1 274.37,41.8 ; H5.1 277.77,45.2 ; H5.1 274.37,45.2 ; H5.1 276.07,41.16 ; H5.1 277.77,41.8 ; 6.35,63.39 JUSBC2.5 ; JUSBC2.5 5.63,64.3 ; JUSBC2.5 7.07,65.4 ; JUSBC2.5 5.63,63.39 ; JUSBC2.5 7.07,63.39 ; JUSBC2.5 6.35,65.4 ; JUSBC2.5 5.63,65.4 ; H10.1 29.49,52.58 ; H10.1 26.14,54 ; H10.1 26.65,55.42 ; H10.1 28.07,55.93 ; H10.1 29.49,55.42 ; H10.1 30,54 ; H10.1 26.65,52.58 ; H10.1 28.07,52.07 ; 13.21,30.64 JUSB1.11 ; JUSB1.11 16.71,32.36 ; JUSB1.11 13.21,31.5 ; JUSB1.11 13.21,32.36 ; JUSB1.11 16.71,31.5 ; JUSB1.11 14.96,30.64 ; JUSB1.11 14.96,32.36 ; JUSB1.11 16.71,30.64 ; JLAN.14 263.65,178.19 ; JLAN.14 263.65,176.43 ; JLAN.14 262.74,179.94 ; JLAN.14 263.65,179.94 ; JLAN.14 262.74,176.43 ; JLAN.14 261.82,179.94 ; JLAN.14 261.82,176.43 ; JLAN.14 261.82,178.19 ; JDP.7 234.54,172.03 ; JDP.7 234.07,171.91 ; JDP.7 233.61,172.95 ; JDP.7 234.66,172.49 ; JDP.7 234.07,173.07 ; JDP.7 234.54,172.95 ; JDP.7 233.61,172.03 ; 6.2,29.14 JUSB1.13 ; JUSB1.13 4.69,30 ; JUSB1.13 7.71,30 ; JUSB1.13 4.69,29.14 ; JUSB1.13 7.71,29.14 ; JHDMI.5 214.58,173.84 ; JHDMI.5 214.58,174.76 ; JHDMI.5 213.66,174.76 ; JHDMI.5 214.12,173.72 ; JHDMI.5 213.66,173.84 ; JHDMI.5 214.12,174.88 ; 240.57,170.34 JDP.22 ; JDP.22 239.8,170.34 ; JDP.22 239.8,171.65 ; JDP.22 241.35,172.96 ; JDP.22 241.35,171.65 ; JDP.22 241.35,170.34 ; JDP.22 240.57,172.96 ; JDP.23 230.35,176.65 ; JDP.23 228.8,177.96 ; JDP.23 229.57,177.96 ; JDP.23 228.8,176.65 ; JDP.23 228.8,175.34 ; JDP.23 230.35,175.34 ; JDP.23 229.57,175.34 ; JDP.23 230.35,177.96 ; 5.62,63.84 JUSBC2.1 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 8.08,63.84 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 5.62,64.62 ; JUSBC2.1 5.62,65.4 ; JUSBC2.1 8.08,64.62 ; 195.81,178.48 JUSBC1.6 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 197.82,178.48 ; JUSBC1.6 197.82,179.92 ; JUSBC1.6 196.72,179.92 ; JUSBC1.6 195.81,179.2 ; JUSBC1.6 195.81,179.92 ; JHDMI.20 210.3,173.88 ; JHDMI.20 209.37,171.32 ; JHDMI.20 210.3,171.32 ; JHDMI.20 208.44,173.88 ; JHDMI.20 208.44,171.32 ; JHDMI.20 209.37,173.88 ; JHDMI.20 210.3,172.6 ; JHDMI.20 208.44,172.6 ; 231.91,173.23 JDP.1 ; JDP.1 232.37,174.27 ; JDP.1 232.84,174.15 ; JDP.1 231.91,174.15 ; JDP.1 232.84,173.23 ; JDP.1 232.37,173.11 ; JDP.1 231.79,173.69 ; H17.1 144.57,173.43 ; H17.1 146.5,171.5 ; H17.1 145.99,170.08 ; H17.1 145.99,172.92 ; H17.1 142.64,171.5 ; H17.1 143.15,172.92 ; H17.1 143.15,170.08 ; H17.1 144.57,169.57 ; 122.67,88.56 H2.1 ; H2.1 124.37,92.6 ; H2.1 122.67,93.24 ; H2.1 120.97,92.6 ; H2.1 120.97,89.2 ; H2.1 120.33,90.9 ; H2.1 125.01,90.9 ; H2.1 124.37,89.2 ; JHDMI.17 220.58,173.84 ; JHDMI.17 220.12,174.88 ; JHDMI.17 220.12,173.72 ; JHDMI.17 219.66,174.76 ; JHDMI.17 220.58,174.76 ; JHDMI.17 219.66,173.84 ; JLAN.16 244.6,178.19 ; JLAN.16 242.77,176.43 ; JLAN.16 243.69,176.43 ; JLAN.16 242.77,179.94 ; JLAN.16 243.69,179.94 ; JLAN.16 244.6,179.94 ; JLAN.16 244.6,176.43 ; JLAN.16 242.77,178.19 ; H14.1 203.64,178.68 ; H14.1 200.8,178.68 ; H14.1 204.15,180.1 ; H14.1 200.29,180.1 ; H14.1 202.22,182.03 ; H14.1 202.22,178.17 ; H14.1 203.64,181.52 ; H14.1 200.8,181.52 ; 239.8,177.96 JDP.21 ; JDP.21 241.35,176.65 ; JDP.21 241.35,177.96 ; JDP.21 240.57,175.34 ; JDP.21 239.8,175.34 ; JDP.21 241.35,175.34 ; JDP.21 239.8,176.65 ; JDP.21 240.57,177.96 ; JDP.13 236.54,172.03 ; JDP.13 236.07,171.91 ; JDP.13 236.07,173.07 ; JDP.13 235.61,172.03 ; JDP.13 236.54,172.95 ; JDP.13 235.61,172.95 ; JDP.13 235.49,172.49 ; 20.65,2.78 H16.1 ; H16.1 20.65,5.62 ; H16.1 20.14,4.2 ; H16.1 22.07,6.13 ; H16.1 23.49,2.78 ; H16.1 23.49,5.62 ; H16.1 22.07,2.27 ; H16.1 24,4.2 ; H20.1 299.29,77.67 ; H20.1 295.94,76.25 ; H20.1 299.8,76.25 ; H20.1 297.87,78.18 ; H20.1 296.45,77.67 ; H20.1 297.87,74.32 ; H20.1 299.29,74.83 ; H20.1 296.45,74.83 ; JHDMI.8 215.62,173.33 ; JHDMI.8 215.16,173.21 ; JHDMI.8 216.08,173.21 ; JHDMI.8 215.16,172.29 ; JHDMI.8 216.08,172.29 ; JHDMI.8 215.62,172.17 ; H7.1 270.77,152.2 ; H7.1 267.37,148.8 ; H7.1 269.07,148.16 ; H7.1 266.73,150.5 ; H7.1 269.07,152.84 ; H7.1 267.37,152.2 ; H7.1 271.41,150.5 ; H7.1 270.77,148.8 ; JHDMI.11 217.58,173.84 ; JHDMI.11 217.12,173.72 ; JHDMI.11 216.66,173.84 ; JHDMI.11 216.66,174.76 ; JHDMI.11 217.12,174.88 ; JHDMI.11 217.58,174.76 ; 196.21,185.17 JUSBC1.4 ; JUSBC1.4 196.21,182.33 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 197.04,182.33 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 197.87,182.33 ; JUSBC1.4 196.21,183.75 ; 4.69,45.8 JUSB1.14 ; JUSB1.14 4.69,46.66 ; JUSB1.14 6.2,46.66 ; JUSB1.14 7.71,46.66 ; JUSB1.14 7.71,45.8 ; 187.62,178.48 JUSBC1.5 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 187.62,179.2 ; JUSBC1.5 188.73,179.92 ; JUSBC1.5 187.62,179.92 ; JUSBC1.5 189.63,179.2 ; 188.4,182.33 JUSBC1.2 ; JUSBC1.2 187.57,183.75 ; JUSBC1.2 189.23,183.75 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 187.57,182.33 ; JUSBC1.2 188.4,185.17 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 189.23,182.33 ; JHDMI.22 224.8,173.88 ; JHDMI.22 222.94,173.88 ; JHDMI.22 222.94,172.6 ; JHDMI.22 224.8,171.32 ; JHDMI.22 223.87,171.32 ; JHDMI.22 222.94,171.32 ; JHDMI.22 223.87,173.88 ; JHDMI.22 224.8,172.6 ; H13.1 201.81,154.53 ; H13.1 197.33,152 ; H13.1 201.81,152 ; H13.1 199.57,154.53 ; H13.1 197.33,149.47 ; H13.1 199.57,149.47 ; H13.1 197.33,154.53 ; H13.1 201.81,149.47 ; 3.14,69.8 H8.1 ; H8.1 7,69.8 ; H8.1 5.07,71.73 ; H8.1 6.49,68.38 ; H8.1 6.49,71.22 ; H8.1 3.65,68.38 ; H8.1 3.65,71.22 ; H8.1 5.07,67.87 ; 20.44,13.13 H11.1 ; H11.1 19.83,11.5 ; H11.1 23.7,13.13 ; H11.1 22.07,9.26 ; H11.1 22.07,13.74 ; H11.1 24.31,11.5 ; H11.1 23.7,9.87 ; H11.1 20.44,9.87 ; 0.38,63.79 JUSBC2.2 ; JUSBC2.2 3.22,64.62 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 1.8,63.79 ; JUSBC2.2 0.38,65.45 ; JUSBC2.2 0.38,64.62 ; JUSBC2.2 3.22,63.79 ; 13.21,44.3 JUSB1.12 ; JUSB1.12 14.96,43.44 ; JUSB1.12 16.71,44.3 ; JUSB1.12 16.71,43.44 ; JUSB1.12 13.21,45.16 ; JUSB1.12 14.96,45.16 ; JUSB1.12 13.21,43.44 ; JUSB1.12 16.71,45.16 ; 196.45,57.02 H22.1 ; H22.1 195.94,55.6 ; H22.1 196.45,54.18 ; H22.1 199.8,55.6 ; H22.1 199.29,54.18 ; H22.1 197.87,57.53 ; H22.1 199.29,57.02 ; H22.1 197.87,53.67 ; JUSBC1.3 197.04,179.93 ; JUSBC1.3 197.04,177.47 ; JUSBC1.3 197.82,178.7 ; JUSBC1.3 196.27,179.93 ; JUSBC1.3 196.27,177.47 ; JUSBC1.3 197.82,177.47 ; JUSBC1.3 197.82,179.93
  IN5 w0.203: JCDRA.48 178.62,183.87 ; JCDRA.48 176.72,180.75 ; JCDRA.48 177.67,180.75 ; JCDRA.48 176.72,182.31 ; JCDRA.48 177.67,183.87 ; JCDRA.48 178.62,180.75 ; JCDRA.48 178.62,182.31 ; JCDRA.48 176.72,183.87 ; 187.62,177.47 JUSBC1.1 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 189.18,177.47 ; JUSBC1.1 189.18,179.93 ; JUSBC1.1 187.62,178.7 ; JUSBC1.1 188.4,177.47 ; JUSBC1.1 188.4,179.93 ; 215.16,173.21 JHDMI.8 ; JHDMI.8 215.16,172.29 ; JHDMI.8 215.62,173.33 ; JHDMI.8 216.08,172.29 ; JHDMI.8 215.62,172.17 ; JHDMI.8 216.08,173.21 ; 144.22,180.75 JCDRA.49 ; JCDRA.49 146.12,183.87 ; JCDRA.49 146.12,180.75 ; JCDRA.49 144.22,183.87 ; JCDRA.49 146.12,182.31 ; JCDRA.49 145.17,180.75 ; JCDRA.49 145.17,183.87 ; JCDRA.49 144.22,182.31 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 7.07,55.2 ; JUSBC2.6 5.63,57.21 ; JUSBC2.6 6.35,55.2 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 5.63,55.2 ; JUSBC2.6 7.07,57.21 ; 13.21,43.44 JUSB1.12 ; JUSB1.12 16.71,44.3 ; JUSB1.12 13.21,45.16 ; JUSB1.12 13.21,44.3 ; JUSB1.12 14.96,45.16 ; JUSB1.12 14.96,43.44 ; JUSB1.12 16.71,43.44 ; JUSB1.12 16.71,45.16 ; H9.1 7.99,49.38 ; H9.1 7.99,52.22 ; H9.1 4.64,50.8 ; H9.1 5.15,49.38 ; H9.1 8.5,50.8 ; H9.1 5.15,52.22 ; H9.1 6.57,52.73 ; H9.1 6.57,48.87 ; 5.63,63.39 JUSBC2.5 ; JUSBC2.5 6.35,63.39 ; JUSBC2.5 6.35,65.4 ; JUSBC2.5 5.63,65.4 ; JUSBC2.5 5.63,64.3 ; JUSBC2.5 7.07,65.4 ; JUSBC2.5 7.07,63.39 ; 233.61,172.95 JDP.7 ; JDP.7 234.54,172.95 ; JDP.7 234.07,173.07 ; JDP.7 234.66,172.49 ; JDP.7 234.54,172.03 ; JDP.7 233.61,172.03 ; JDP.7 234.07,171.91 ; 4.69,29.14 JUSB1.13 ; JUSB1.13 6.2,29.14 ; JUSB1.13 7.71,30 ; JUSB1.13 4.69,30 ; JUSB1.13 7.71,29.14 ; 242.77,178.19 JLAN.16 ; JLAN.16 244.6,176.43 ; JLAN.16 243.69,176.43 ; JLAN.16 242.77,176.43 ; JLAN.16 244.6,178.19 ; JLAN.16 243.69,179.94 ; JLAN.16 244.6,179.94 ; JLAN.16 242.77,179.94 ; 14.46,38.49 JUSB1.7 ; JUSB1.7 15.05,38.66 ; JUSB1.7 15.64,38.49 ; JUSB1.7 14.46,37.31 ; JUSB1.7 14.29,37.9 ; JUSB1.7 15.64,37.31 ; JUSB1.7 15.81,37.9 ; JUSB1.7 15.05,37.14 ; JUSBC1.6 197.82,178.48 ; JUSBC1.6 196.72,179.92 ; JUSBC1.6 197.82,179.92 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 195.81,179.92 ; JUSBC1.6 195.81,179.2 ; JUSBC1.6 195.81,178.48 ; 239.8,175.34 JDP.21 ; JDP.21 241.35,175.34 ; JDP.21 241.35,177.96 ; JDP.21 239.8,177.96 ; JDP.21 240.57,175.34 ; JDP.21 239.8,176.65 ; JDP.21 241.35,176.65 ; JDP.21 240.57,177.96 ; H8.1 6.49,71.22 ; H8.1 3.65,68.38 ; H8.1 5.07,71.73 ; H8.1 3.14,69.8 ; H8.1 7,69.8 ; H8.1 3.65,71.22 ; H8.1 5.07,67.87 ; H8.1 6.49,68.38 ; 187.57,182.33 JUSBC1.2 ; JUSBC1.2 187.57,183.75 ; JUSBC1.2 188.4,185.17 ; JUSBC1.2 189.23,182.33 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 188.4,182.33 ; JUSBC1.2 189.23,183.75 ; 212.62,172.17 JHDMI.2 ; JHDMI.2 212.04,172.75 ; JHDMI.2 212.16,172.29 ; JHDMI.2 213.08,172.29 ; JHDMI.2 212.16,173.21 ; JHDMI.2 212.62,173.33 ; JHDMI.2 213.08,173.21 ; JLAN.14 262.74,179.94 ; JLAN.14 262.74,176.43 ; JLAN.14 261.82,178.19 ; JLAN.14 263.65,178.19 ; JLAN.14 261.82,176.43 ; JLAN.14 263.65,176.43 ; JLAN.14 261.82,179.94 ; JLAN.14 263.65,179.94 ; 236.07,171.91 JDP.13 ; JDP.13 236.54,172.03 ; JDP.13 235.61,172.95 ; JDP.13 236.54,172.95 ; JDP.13 235.49,172.49 ; JDP.13 236.07,173.07 ; JDP.13 235.61,172.03 ; JDP.19 238.24,173.23 ; JDP.19 238.36,173.69 ; JDP.19 238.24,174.15 ; JDP.19 237.31,173.23 ; JDP.19 237.77,174.27 ; JDP.19 237.31,174.15 ; JDP.19 237.77,173.11 ; JHDMI.21 208.4,179.52 ; JHDMI.21 208.4,182.08 ; JHDMI.21 206.54,179.52 ; JHDMI.21 208.4,180.8 ; JHDMI.21 206.54,180.8 ; JHDMI.21 207.47,179.52 ; JHDMI.21 207.47,182.08 ; JHDMI.21 206.54,182.08 ; H12.1 278.1,170.6 ; H12.1 274.24,170.6 ; H12.1 276.17,168.67 ; H12.1 277.59,169.18 ; H12.1 274.75,169.18 ; H12.1 277.59,172.02 ; H12.1 276.17,172.53 ; H12.1 274.75,172.02 ; 213.66,173.84 JHDMI.5 ; JHDMI.5 213.66,174.76 ; JHDMI.5 214.12,173.72 ; JHDMI.5 214.58,174.76 ; JHDMI.5 214.12,174.88 ; JHDMI.5 214.58,173.84 ; 196.27,177.47 JUSBC1.3 ; JUSBC1.3 197.04,179.93 ; JUSBC1.3 196.27,179.93 ; JUSBC1.3 197.82,177.47 ; JUSBC1.3 197.82,178.7 ; JUSBC1.3 197.82,179.93 ; JUSBC1.3 197.04,177.47 ; 0.38,55.15 JUSBC2.4 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 0.38,55.98 ; JUSBC2.4 3.22,55.15 ; JUSBC2.4 1.8,55.15 ; JUSBC2.4 0.38,56.81 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 1.8,56.81 ; 6.85,55.2 JUSBC2.3 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 5.62,56.76 ; JUSBC2.3 5.62,55.2 ; JUSBC2.3 8.08,56.76 ; JUSBC2.3 5.62,55.98 ; JUSBC2.3 8.08,55.98 ; JUSBC1.4 197.87,182.33 ; JUSBC1.4 196.21,182.33 ; JUSBC1.4 196.21,185.17 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 196.21,183.75 ; JUSBC1.4 197.04,182.33 ; H15.1 184.64,181.52 ; H15.1 181.29,180.1 ; H15.1 185.15,180.1 ; H15.1 183.22,182.03 ; H15.1 183.22,178.17 ; H15.1 181.8,181.52 ; H15.1 184.64,178.68 ; H15.1 181.8,178.68 ; 228.8,175.34 JDP.23 ; JDP.23 230.35,175.34 ; JDP.23 228.8,177.96 ; JDP.23 230.35,177.96 ; JDP.23 229.57,175.34 ; JDP.23 229.57,177.96 ; JDP.23 228.8,176.65 ; JDP.23 230.35,176.65 ; H14.1 203.64,181.52 ; H14.1 204.15,180.1 ; H14.1 203.64,178.68 ; H14.1 202.22,182.03 ; H14.1 200.29,180.1 ; H14.1 200.8,178.68 ; H14.1 202.22,178.17 ; H14.1 200.8,181.52 ; 267.37,148.8 H7.1 ; H7.1 270.77,152.2 ; H7.1 269.07,152.84 ; H7.1 269.07,148.16 ; H7.1 267.37,152.2 ; H7.1 271.41,150.5 ; H7.1 266.73,150.5 ; H7.1 270.77,148.8 ; 232.37,173.11 JDP.1 ; JDP.1 232.84,174.15 ; JDP.1 231.91,173.23 ; JDP.1 231.91,174.15 ; JDP.1 232.37,174.27 ; JDP.1 232.84,173.23 ; JDP.1 231.79,173.69 ; JHDMI.22 224.8,173.88 ; JHDMI.22 224.8,172.6 ; JHDMI.22 222.94,172.6 ; JHDMI.22 222.94,173.88 ; JHDMI.22 223.87,173.88 ; 224.84,182.05 JHDMI.23 ; JHDMI.23 226.7,183.33 ; JHDMI.23 225.77,183.33 ; JHDMI.23 226.7,182.05 ; JHDMI.23 225.77,180.77 ; JHDMI.23 226.7,180.77 ; JHDMI.23 224.84,180.77 ; JHDMI.23 224.84,183.33 ; JDP.24 229.57,172.96 ; JDP.24 230.35,171.65 ; JDP.24 228.8,172.96 ; JDP.24 228.8,171.65 ; JHDMI.17 220.58,174.76 ; JHDMI.17 220.58,173.84 ; JHDMI.17 220.12,174.88 ; JHDMI.17 220.12,173.72 ; JHDMI.17 219.66,173.84 ; JHDMI.17 219.66,174.76 ; JUSBC1.5 189.63,179.2 ; JUSBC1.5 187.62,179.92 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 188.73,179.92 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 187.62,178.48 ; JUSBC1.5 187.62,179.2 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 8.08,64.62 ; JUSBC2.1 8.08,63.84 ; JUSBC2.1 5.62,63.84 ; JUSBC2.1 5.62,65.4 ; JUSBC2.1 5.62,64.62 ; 216.66,174.76 JHDMI.11 ; JHDMI.11 216.66,173.84 ; JHDMI.11 217.58,173.84 ; JHDMI.11 217.58,174.76 ; JHDMI.11 217.12,173.72 ; JHDMI.11 217.12,174.88 ; 0.38,64.62 JUSBC2.2 ; JUSBC2.2 0.38,63.79 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 3.22,64.62 ; JUSBC2.2 1.8,63.79 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 0.38,65.45 ; 15.96,34.99 JUSB1.4 ; JUSB1.4 15.79,34.4 ; JUSB1.4 16.55,35.16 ; JUSB1.4 17.31,34.4 ; JUSB1.4 15.96,33.81 ; JUSB1.4 17.14,33.81 ; JUSB1.4 17.14,34.99 ; JUSB1.4 16.55,33.64 ; JUSB1.11 16.71,30.64 ; JUSB1.11 16.71,31.5 ; JUSB1.11 14.96,32.36 ; JUSB1.11 16.71,32.36 ; JUSB1.11 13.21,31.5 ; JUSB1.11 13.21,32.36 ; JUSB1.11 14.96,30.64 ; JUSB1.11 13.21,30.64 ; JCDRA.50 146.12,176.15 ; JCDRA.50 144.22,176.15 ; JCDRA.50 146.12,177.71 ; JCDRA.50 145.17,179.27 ; JCDRA.50 146.12,179.27 ; JCDRA.50 144.22,179.27 ; JCDRA.50 145.17,176.15 ; JCDRA.50 144.22,177.71 ; 4.69,45.8 JUSB1.14 ; JUSB1.14 4.69,46.66 ; JUSB1.14 6.2,46.66 ; JUSB1.14 7.71,45.8 ; JUSB1.14 7.71,46.66 ; 176.72,177.71 JCDRA.47 ; JCDRA.47 177.67,179.27 ; JCDRA.47 178.62,176.15 ; JCDRA.47 176.72,176.15 ; JCDRA.47 176.72,179.27 ; JCDRA.47 177.67,176.15 ; JCDRA.47 178.62,177.71 ; JCDRA.47 178.62,179.27 ; JHDMI.20 210.3,172.6 ; JHDMI.20 208.44,172.6 ; JHDMI.20 209.37,173.88 ; JHDMI.20 208.44,173.88 ; JHDMI.20 210.3,173.88 ; JDP.22 241.35,172.96 ; JDP.22 240.57,172.96 ; JDP.22 241.35,171.65 ; JDP.22 239.8,171.65
  GND5 w0.203: 26.14,54 H10.1 ; H10.1 28.07,52.07 ; H10.1 29.49,55.42 ; H10.1 28.07,55.93 ; H10.1 30,54 ; H10.1 26.65,55.42 ; H10.1 29.49,52.58 ; H10.1 26.65,52.58 ; 265.49,8.74 H23.1 ; H23.1 265.49,4.26 ; H23.1 265.49,6.5 ; H23.1 267.97,8.74 ; H23.1 270.45,4.26 ; H23.1 270.45,8.74 ; H23.1 267.97,4.26 ; H23.1 270.45,6.5 ; 215.16,172.29 JHDMI.8 ; JHDMI.8 216.08,172.29 ; JHDMI.8 215.62,172.17 ; JHDMI.8 215.62,173.33 ; JHDMI.8 215.16,173.21 ; JHDMI.8 216.08,173.21 ; JPCMC.36 121.57,154.76 ; JPCMC.36 119.77,159.04 ; JPCMC.36 117.97,154.76 ; JPCMC.36 119.77,154.08 ; JPCMC.36 122.25,156.56 ; JPCMC.36 117.97,158.36 ; 228.8,170.34 JDP.24 ; JDP.24 230.35,171.65 ; JDP.24 229.57,172.96 ; JDP.24 228.8,171.65 ; JDP.24 229.57,170.34 ; JDP.24 230.35,170.34 ; JDP.24 228.8,172.96 ; H8.1 6.49,68.38 ; H8.1 3.65,71.22 ; H8.1 5.07,71.73 ; H8.1 6.49,71.22 ; H8.1 5.07,67.87 ; H8.1 3.14,69.8 ; H8.1 7,69.8 ; H8.1 3.65,68.38 ; 239.8,176.65 JDP.21 ; JDP.21 241.35,177.96 ; JDP.21 241.35,175.34 ; JDP.21 240.57,175.34 ; JDP.21 240.57,177.96 ; JDP.21 239.8,175.34 ; JDP.21 241.35,176.65 ; JDP.21 239.8,177.96 ; 0.38,55.98 JUSBC2.4 ; JUSBC2.4 0.38,55.15 ; JUSBC2.4 3.22,55.15 ; JUSBC2.4 0.38,56.81 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 1.8,56.81 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 1.8,55.15 ; JDP.19 238.36,173.69 ; JDP.19 237.31,173.23 ; JDP.19 238.24,174.15 ; JDP.19 238.24,173.23 ; JDP.19 237.77,174.27 ; JDP.19 237.31,174.15 ; JDP.19 237.77,173.11 ; JCDRA.47 178.62,177.71 ; JCDRA.47 176.72,179.27 ; JCDRA.47 177.67,179.27 ; JCDRA.47 176.72,177.71 ; JCDRA.47 178.62,176.15 ; JCDRA.47 178.62,179.27 ; JCDRA.47 177.67,176.15 ; JCDRA.47 176.72,176.15 ; 187.62,177.47 JUSBC1.1 ; JUSBC1.1 188.4,177.47 ; JUSBC1.1 189.18,179.93 ; JUSBC1.1 188.4,179.93 ; JUSBC1.1 187.62,179.93 ; JUSBC1.1 187.62,178.7 ; JUSBC1.1 189.18,177.47 ; 195.81,179.92 JUSBC1.6 ; JUSBC1.6 197.82,178.48 ; JUSBC1.6 196.72,179.92 ; JUSBC1.6 195.81,178.48 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 195.81,179.2 ; JUSBC1.6 197.82,179.92 ; JLAN.16 243.69,179.94 ; JLAN.16 244.6,176.43 ; JLAN.16 242.77,176.43 ; JLAN.16 242.77,178.19 ; JLAN.16 242.77,179.94 ; JLAN.16 243.69,176.43 ; JLAN.16 244.6,178.19 ; JLAN.16 244.6,179.94 ; 295.94,76.25 H20.1 ; H20.1 297.87,74.32 ; H20.1 297.87,78.18 ; H20.1 296.45,74.83 ; H20.1 299.8,76.25 ; H20.1 299.29,74.83 ; H20.1 299.29,77.67 ; H20.1 296.45,77.67 ; JHDMI.11 217.58,174.76 ; JHDMI.11 216.66,174.76 ; JHDMI.11 216.66,173.84 ; JHDMI.11 217.58,173.84 ; JHDMI.11 217.12,174.88 ; JHDMI.11 217.12,173.72 ; 200.8,178.68 H14.1 ; H14.1 204.15,180.1 ; H14.1 203.64,181.52 ; H14.1 203.64,178.68 ; H14.1 200.29,180.1 ; H14.1 202.22,178.17 ; H14.1 200.8,181.52 ; H14.1 202.22,182.03 ; 143.15,172.92 H17.1 ; H17.1 146.5,171.5 ; H17.1 144.57,173.43 ; H17.1 145.99,172.92 ; H17.1 144.57,169.57 ; H17.1 142.64,171.5 ; H17.1 143.15,170.08 ; H17.1 145.99,170.08 ; 20.44,9.87 H11.1 ; H11.1 23.7,9.87 ; H11.1 19.83,11.5 ; H11.1 22.07,13.74 ; H11.1 24.31,11.5 ; H11.1 20.44,13.13 ; H11.1 23.7,13.13 ; H11.1 22.07,9.26 ; 181.8,181.52 H15.1 ; H15.1 185.15,180.1 ; H15.1 183.22,182.03 ; H15.1 184.64,178.68 ; H15.1 181.8,178.68 ; H15.1 181.29,180.1 ; H15.1 183.22,178.17 ; H15.1 184.64,181.52 ; 203.37,46.8 H4.1 ; H4.1 206.77,50.2 ; H4.1 206.77,46.8 ; H4.1 202.73,48.5 ; H4.1 205.07,46.16 ; H4.1 203.37,50.2 ; H4.1 205.07,50.84 ; H4.1 207.41,48.5 ; 5.62,56.76 JUSBC2.3 ; JUSBC2.3 5.62,55.98 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 6.85,55.2 ; JUSBC2.3 8.08,55.98 ; JUSBC2.3 5.62,55.2 ; JUSBC2.3 8.08,56.76 ; JDP.22 240.57,172.96 ; JDP.22 239.8,170.34 ; JDP.22 241.35,171.65 ; JDP.22 239.8,171.65 ; JDP.22 241.35,170.34 ; JDP.22 241.35,172.96 ; JDP.22 240.57,170.34 ; 176.72,182.31 JCDRA.48 ; JCDRA.48 178.62,183.87 ; JCDRA.48 177.67,180.75 ; JCDRA.48 176.72,183.87 ; JCDRA.48 177.67,183.87 ; JCDRA.48 176.72,180.75 ; JCDRA.48 178.62,180.75 ; JCDRA.48 178.62,182.31 ; 234.07,171.91 JDP.7 ; JDP.7 234.54,172.03 ; JDP.7 234.07,173.07 ; JDP.7 234.66,172.49 ; JDP.7 234.54,172.95 ; JDP.7 233.61,172.95 ; JDP.7 233.61,172.03 ; 14.96,43.44 JUSB1.12 ; JUSB1.12 14.96,45.16 ; JUSB1.12 13.21,45.16 ; JUSB1.12 16.71,43.44 ; JUSB1.12 16.71,45.16 ; JUSB1.12 13.21,43.44 ; JUSB1.12 16.71,44.3 ; JUSB1.12 13.21,44.3 ; 5.63,64.3 JUSBC2.5 ; JUSBC2.5 7.07,65.4 ; JUSBC2.5 7.07,63.39 ; JUSBC2.5 6.35,65.4 ; JUSBC2.5 5.63,65.4 ; JUSBC2.5 6.35,63.39 ; JUSBC2.5 5.63,63.39 ; H22.1 197.87,57.53 ; H22.1 196.45,54.18 ; H22.1 199.8,55.6 ; H22.1 195.94,55.6 ; H22.1 199.29,54.18 ; H22.1 199.29,57.02 ; H22.1 196.45,57.02 ; H22.1 197.87,53.67 ; H18.1 103.49,5.08 ; H18.1 100.14,6.5 ; H18.1 100.65,5.08 ; H18.1 100.65,7.92 ; H18.1 104,6.5 ; H18.1 102.07,8.43 ; H18.1 103.49,7.92 ; H18.1 102.07,4.57 ; 196.27,179.93 JUSBC1.3 ; JUSBC1.3 197.04,179.93 ; JUSBC1.3 197.82,179.93 ; JUSBC1.3 196.27,177.47 ; JUSBC1.3 197.04,177.47 ; JUSBC1.3 197.82,177.47 ; JUSBC1.3 197.82,178.7 ; JUSB1.4 17.31,34.4 ; JUSB1.4 15.96,34.99 ; JUSB1.4 16.55,35.16 ; JUSB1.4 17.14,34.99 ; JUSB1.4 17.14,33.81 ; JUSB1.4 15.96,33.81 ; JUSB1.4 16.55,33.64 ; JUSB1.4 15.79,34.4 ; JUSBC1.5 188.73,179.92 ; JUSBC1.5 189.63,179.2 ; JUSBC1.5 187.62,178.48 ; JUSBC1.5 187.62,179.92 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 187.62,179.2 ; JCDRA.49 146.12,183.87 ; JCDRA.49 145.17,180.75 ; JCDRA.49 146.12,180.75 ; JCDRA.49 146.12,182.31 ; JCDRA.49 145.17,183.87 ; JCDRA.49 144.22,183.87 ; JCDRA.49 144.22,182.31 ; JCDRA.49 144.22,180.75 ; 14.29,37.9 JUSB1.7 ; JUSB1.7 15.81,37.9 ; JUSB1.7 14.46,37.31 ; JUSB1.7 15.05,38.66 ; JUSB1.7 14.46,38.49 ; JUSB1.7 15.64,38.49 ; JUSB1.7 15.64,37.31 ; JUSB1.7 15.05,37.14 ; JHDMI.17 220.12,174.88 ; JHDMI.17 220.58,174.76 ; JHDMI.17 219.66,173.84 ; JHDMI.17 220.12,173.72 ; JHDMI.17 220.58,173.84 ; JHDMI.17 219.66,174.76 ; H7.1 269.07,152.84 ; H7.1 269.07,148.16 ; H7.1 267.37,152.2 ; H7.1 270.77,152.2 ; H7.1 270.77,148.8 ; H7.1 267.37,148.8 ; H7.1 266.73,150.5 ; H7.1 271.41,150.5 ; H21.1 264,6.5 ; H21.1 263.49,5.08 ; H21.1 262.07,8.43 ; H21.1 260.65,5.08 ; H21.1 260.14,6.5 ; H21.1 262.07,4.57 ; H21.1 260.65,7.92 ; H21.1 263.49,7.92 ; H12.1 277.59,172.02 ; H12.1 278.1,170.6 ; H12.1 276.17,168.67 ; H12.1 276.17,172.53 ; H12.1 274.75,172.02 ; H12.1 277.59,169.18 ; H12.1 274.75,169.18 ; H12.1 274.24,170.6 ; 5.15,49.38 H9.1 ; H9.1 6.57,52.73 ; H9.1 8.5,50.8 ; H9.1 6.57,48.87 ; H9.1 7.99,49.38 ; H9.1 7.99,52.22 ; H9.1 5.15,52.22 ; H9.1 4.64,50.8 ; JCDRA.50 146.12,177.71 ; JCDRA.50 145.17,176.15 ; JCDRA.50 146.12,179.27 ; JCDRA.50 144.22,177.71 ; JCDRA.50 146.12,176.15 ; JCDRA.50 144.22,176.15 ; JCDRA.50 144.22,179.27 ; JCDRA.50 145.17,179.27 ; 208.44,172.6 JHDMI.20 ; JHDMI.20 208.44,173.88 ; JHDMI.20 210.3,171.32 ; JHDMI.20 210.3,173.88 ; JHDMI.20 208.44,171.32 ; JHDMI.20 209.37,171.32 ; JHDMI.20 209.37,173.88 ; JHDMI.20 210.3,172.6 ; H5.1 276.07,45.84 ; H5.1 277.77,41.8 ; H5.1 274.37,41.8 ; H5.1 276.07,41.16 ; H5.1 273.73,43.5 ; H5.1 277.77,45.2 ; H5.1 274.37,45.2 ; H5.1 278.41,43.5 ; JHDMI.22 224.8,172.6 ; JHDMI.22 224.8,171.32 ; JHDMI.22 223.87,173.88 ; JHDMI.22 223.87,171.32 ; JHDMI.22 222.94,173.88 ; JHDMI.22 224.8,173.88 ; JHDMI.22 222.94,171.32 ; JHDMI.22 222.94,172.6 ; 5.63,55.2 JUSBC2.6 ; JUSBC2.6 7.07,57.21 ; JUSBC2.6 5.63,57.21 ; JUSBC2.6 6.35,55.2 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 7.07,55.2 ; JDP.1 232.84,173.23 ; JDP.1 231.91,174.15 ; JDP.1 232.37,174.27 ; JDP.1 232.84,174.15 ; JDP.1 232.37,173.11 ; JDP.1 231.79,173.69 ; JDP.1 231.91,173.23 ; 5.62,65.4 JUSBC2.1 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 8.08,64.62 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 5.62,63.84 ; JUSBC2.1 5.62,64.62 ; JUSBC2.1 8.08,63.84 ; H1.1 161.87,157.3 ; H1.1 160.17,153.26 ; H1.1 161.87,153.9 ; H1.1 160.17,157.94 ; H1.1 158.47,157.3 ; H1.1 162.51,155.6 ; H1.1 158.47,153.9 ; H1.1 157.83,155.6 ; 196.21,182.33 JUSBC1.4 ; JUSBC1.4 197.04,182.33 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 196.21,183.75 ; JUSBC1.4 197.87,182.33 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 196.21,185.17 ; JHDMI.2 213.08,172.29 ; JHDMI.2 213.08,173.21 ; JHDMI.2 212.04,172.75 ; JHDMI.2 212.16,173.21 ; JHDMI.2 212.16,172.29 ; JHDMI.2 212.62,172.17 ; JHDMI.2 212.62,173.33 ; 90.94,56.9 H19.1 ; H19.1 91.45,55.48 ; H19.1 94.8,56.9 ; H19.1 91.45,58.32 ; H19.1 92.87,58.83 ; H19.1 94.29,55.48 ; H19.1 94.29,58.32 ; H19.1 92.87,54.97 ; JDP.23 230.35,177.96 ; JDP.23 228.8,176.65 ; JDP.23 229.57,177.96 ; JDP.23 230.35,176.65 ; JDP.23 228.8,175.34 ; JDP.23 229.57,175.34 ; JDP.23 228.8,177.96 ; JDP.23 230.35,175.34 ; JUSB1.11 16.71,30.64 ; JUSB1.11 13.21,32.36 ; JUSB1.11 13.21,30.64 ; JUSB1.11 16.71,31.5 ; JUSB1.11 14.96,30.64 ; JUSB1.11 14.96,32.36 ; JUSB1.11 16.71,32.36 ; JUSB1.11 13.21,31.5 ; JHDMI.23 225.77,183.33 ; JHDMI.23 226.7,180.77 ; JHDMI.23 226.7,183.33 ; JHDMI.23 225.77,180.77 ; JHDMI.23 224.84,183.33 ; JHDMI.23 226.7,182.05 ; JHDMI.23 224.84,182.05 ; JHDMI.23 224.84,180.77 ; 261.82,178.19 JLAN.14 ; JLAN.14 261.82,179.94 ; JLAN.14 262.74,179.94 ; JLAN.14 263.65,178.19 ; JLAN.14 262.74,176.43 ; JLAN.14 263.65,176.43 ; JLAN.14 261.82,176.43 ; JLAN.14 263.65,179.94 ; JHDMI.21 208.4,179.52 ; JHDMI.21 207.47,182.08 ; JHDMI.21 206.54,182.08 ; JHDMI.21 206.54,180.8 ; JHDMI.21 208.4,182.08 ; JHDMI.21 207.47,179.52 ; JHDMI.21 208.4,180.8 ; JHDMI.21 206.54,179.52 ; 181.67,88.06 H3.1 ; H3.1 183.3,88.67 ; H3.1 180.04,88.67 ; H3.1 179.43,90.3 ; H3.1 183.91,90.3 ; H3.1 183.3,91.93 ; H3.1 181.67,92.54 ; H3.1 180.04,91.93 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 0.38,64.62 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 0.38,63.79 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 0.38,65.45 ; JUSBC2.2 1.8,63.79 ; JUSBC2.2 3.22,64.62 ; H6.1 181.09,5.08 ; H6.1 181.6,6.5 ; H6.1 181.09,7.92 ; H6.1 178.25,7.92 ; H6.1 177.74,6.5 ; H6.1 179.67,4.57 ; H6.1 179.67,8.43 ; H6.1 178.25,5.08 ; JHDMI.5 214.58,173.84 ; JHDMI.5 214.58,174.76 ; JHDMI.5 213.66,174.76 ; JHDMI.5 214.12,173.72 ; JHDMI.5 213.66,173.84 ; JHDMI.5 214.12,174.88 ; 4.69,29.14 JUSB1.13 ; JUSB1.13 7.71,29.14 ; JUSB1.13 4.69,30 ; JUSB1.13 7.71,30 ; JUSB1.13 6.2,29.14 ; 197.33,154.53 H13.1 ; H13.1 201.81,152 ; H13.1 197.33,149.47 ; H13.1 197.33,152 ; H13.1 201.81,149.47 ; H13.1 199.57,154.53 ; H13.1 199.57,149.47 ; H13.1 201.81,154.53 ; JDP.13 236.07,173.07 ; JDP.13 235.61,172.03 ; JDP.13 236.07,171.91 ; JDP.13 235.61,172.95 ; JDP.13 236.54,172.03 ; JDP.13 235.49,172.49 ; JDP.13 236.54,172.95 ; H2.1 125.01,90.9 ; H2.1 122.67,93.24 ; H2.1 120.33,90.9 ; H2.1 120.97,89.2 ; H2.1 122.67,88.56 ; H2.1 120.97,92.6 ; H2.1 124.37,92.6 ; H2.1 124.37,89.2 ; JUSB1.14 7.71,45.8 ; JUSB1.14 7.71,46.66 ; JUSB1.14 4.69,45.8 ; JUSB1.14 6.2,46.66 ; JUSB1.14 4.69,46.66 ; 22.07,2.27 H16.1 ; H16.1 20.65,5.62 ; H16.1 23.49,5.62 ; H16.1 24,4.2 ; H16.1 20.14,4.2 ; H16.1 20.65,2.78 ; H16.1 23.49,2.78 ; H16.1 22.07,6.13 ; JUSBC1.2 189.23,182.33 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 189.23,183.75 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 187.57,183.75 ; JUSBC1.2 187.57,182.33 ; JUSBC1.2 188.4,182.33 ; JUSBC1.2 188.4,185.17
  IN6 w0.15: v2(248.83,105.71) 249.36,105.71 v2(249.42,105.65) 249.72,105.95 ; v2(248.95,95.26) 249.13,95.44 249.29,95.44 249.3,95.45 249.65,95.45 249.66,95.44 249.85,95.44 v2(250.12,95.71) 250.38,95.45 251.2,95.45 v2(251.52,95.13) ; 223.87,87.05 223.64,87.05 223.3,87.05 223.3,87.05 223.07,87.05 v2(222.77,87.35) 222.47,87.05 221.75,87.05 v2(221.54,86.85) ; 223.87,87.05 v2(224.17,87.35) ; 223.87,87.05 223.87,86.75 v2(224.04,86.58) ; 222.53,99.65 222.28,99.9 v2(222.12,99.9) 221.99,99.9 221.74,99.65 ; 222.53,99.65 223.15,99.65 v2(223.32,99.47) ; 222.53,99.65 222.23,99.35 v2(222.17,99.35) 222.04,99.35 221.74,99.65 ; 221.74,99.65 221.64,99.65 221.64,99.65 221.16,99.65 221.01,99.5 v2(220.67,99.5) 220.65,99.52 v2(220.08,99.52) ; 249.72,105.95 UG9.AU47 ; 249.72,105.95 249.72,106 249.49,106.23 v2(249.35,106.23) ; UG9.AU47 v2(251.47,105.65) v2(251.47,106.25) UG9.AU47
  IN6 w0.25: v2(251.52,95.13) 252.01,95.63 v2(252.01,95.64) 252.38,95.64 v2(252.87,95.15) 253.27,95.15 v2(253.42,95.3)
  IN6 w0.3: 250.12,96.57 251.04,96.57 251.47,97 v2(251.47,97.25) ; 250.12,96.57 v2(249.32,97.37) ; 250.12,96.57 v2(250.12,95.71) ; v2(248.74,97.85) 248.77,97.82 v2(248.77,97.15) 249.1,97.15 v2(249.32,97.37) ; v2(249.32,97.37) 249.59,97.37 v2(250.07,97.85)
  GND6 w0.203: JHDMI.22 224.8,173.88 ; JHDMI.22 222.94,171.32 ; JHDMI.22 222.94,173.88 ; JHDMI.22 223.87,171.32 ; JHDMI.22 224.8,171.32 ; JHDMI.22 224.8,172.6 ; JHDMI.22 222.94,172.6 ; JHDMI.22 223.87,173.88 ; JHDMI.11 217.58,174.76 ; JHDMI.11 216.66,173.84 ; JHDMI.11 217.58,173.84 ; JHDMI.11 216.66,174.76 ; JHDMI.11 217.12,174.88 ; JHDMI.11 217.12,173.72 ; H4.1 205.07,50.84 ; H4.1 205.07,46.16 ; H4.1 206.77,50.2 ; H4.1 203.37,50.2 ; H4.1 207.41,48.5 ; H4.1 203.37,46.8 ; H4.1 202.73,48.5 ; H4.1 206.77,46.8 ; H2.1 124.37,89.2 ; H2.1 124.37,92.6 ; H2.1 122.67,88.56 ; H2.1 120.97,92.6 ; H2.1 120.33,90.9 ; H2.1 122.67,93.24 ; H2.1 120.97,89.2 ; H2.1 125.01,90.9 ; 228.8,176.65 JDP.23 ; JDP.23 228.8,175.34 ; JDP.23 230.35,175.34 ; JDP.23 230.35,176.65 ; JDP.23 230.35,177.96 ; JDP.23 228.8,177.96 ; JDP.23 229.57,175.34 ; JDP.23 229.57,177.96 ; JHDMI.5 214.58,173.84 ; JHDMI.5 214.12,173.72 ; JHDMI.5 214.12,174.88 ; JHDMI.5 214.58,174.76 ; JHDMI.5 213.66,174.76 ; JHDMI.5 213.66,173.84 ; 196.45,54.18 H22.1 ; H22.1 197.87,57.53 ; H22.1 196.45,57.02 ; H22.1 199.8,55.6 ; H22.1 199.29,57.02 ; H22.1 195.94,55.6 ; H22.1 199.29,54.18 ; H22.1 197.87,53.67 ; JUSB1.7 15.05,38.66 ; JUSB1.7 15.05,37.14 ; JUSB1.7 14.46,37.31 ; JUSB1.7 14.29,37.9 ; JUSB1.7 15.81,37.9 ; JUSB1.7 15.64,38.49 ; JUSB1.7 14.46,38.49 ; JUSB1.7 15.64,37.31 ; 14.96,43.44 JUSB1.12 ; JUSB1.12 16.71,44.3 ; JUSB1.12 16.71,43.44 ; JUSB1.12 14.96,45.16 ; JUSB1.12 13.21,45.16 ; JUSB1.12 13.21,44.3 ; JUSB1.12 13.21,43.44 ; JUSB1.12 16.71,45.16 ; 181.67,88.06 H3.1 ; H3.1 180.04,91.93 ; H3.1 183.91,90.3 ; H3.1 183.3,88.67 ; H3.1 179.43,90.3 ; H3.1 183.3,91.93 ; H3.1 181.67,92.54 ; H3.1 180.04,88.67 ; 5.63,63.39 JUSBC2.5 ; JUSBC2.5 7.07,65.4 ; JUSBC2.5 5.63,64.3 ; JUSBC2.5 6.35,63.39 ; JUSBC2.5 5.63,65.4 ; JUSBC2.5 7.07,63.39 ; JUSBC2.5 6.35,65.4 ; JHDMI.21 207.47,182.08 ; JHDMI.21 208.4,180.8 ; JHDMI.21 208.4,179.52 ; JHDMI.21 206.54,182.08 ; JHDMI.21 207.47,179.52 ; JHDMI.21 206.54,180.8 ; JHDMI.21 208.4,182.08 ; JHDMI.21 206.54,179.52 ; JDP.22 241.35,171.65 ; JDP.22 241.35,172.96 ; JDP.22 239.8,170.34 ; JDP.22 241.35,170.34 ; JDP.22 239.8,171.65 ; JDP.22 240.57,170.34 ; JDP.22 240.57,172.96 ; 144.22,183.87 JCDRA.49 ; JCDRA.49 145.17,183.87 ; JCDRA.49 145.17,180.75 ; JCDRA.49 144.22,180.75 ; JCDRA.49 146.12,183.87 ; JCDRA.49 144.22,182.31 ; JCDRA.49 146.12,180.75 ; JCDRA.49 146.12,182.31 ; 4.64,50.8 H9.1 ; H9.1 5.15,49.38 ; H9.1 8.5,50.8 ; H9.1 7.99,49.38 ; H9.1 7.99,52.22 ; H9.1 5.15,52.22 ; H9.1 6.57,48.87 ; H9.1 6.57,52.73 ; 176.72,177.71 JCDRA.47 ; JCDRA.47 177.67,179.27 ; JCDRA.47 176.72,176.15 ; JCDRA.47 178.62,177.71 ; JCDRA.47 178.62,176.15 ; JCDRA.47 177.67,176.15 ; JCDRA.47 178.62,179.27 ; JCDRA.47 176.72,179.27 ; 197.33,152 H13.1 ; H13.1 201.81,152 ; H13.1 197.33,149.47 ; H13.1 201.81,154.53 ; H13.1 199.57,149.47 ; H13.1 199.57,154.53 ; H13.1 197.33,154.53 ; H13.1 201.81,149.47 ; H7.1 269.07,152.84 ; H7.1 270.77,148.8 ; H7.1 266.73,150.5 ; H7.1 269.07,148.16 ; H7.1 271.41,150.5 ; H7.1 267.37,152.2 ; H7.1 270.77,152.2 ; H7.1 267.37,148.8 ; 14.96,30.64 JUSB1.11 ; JUSB1.11 16.71,32.36 ; JUSB1.11 14.96,32.36 ; JUSB1.11 13.21,31.5 ; JUSB1.11 16.71,31.5 ; JUSB1.11 13.21,32.36 ; JUSB1.11 16.71,30.64 ; JUSB1.11 13.21,30.64 ; JHDMI.8 216.08,173.21 ; JHDMI.8 215.16,172.29 ; JHDMI.8 215.62,173.33 ; JHDMI.8 215.16,173.21 ; JHDMI.8 216.08,172.29 ; JHDMI.8 215.62,172.17 ; JHDMI.20 209.37,173.88 ; JHDMI.20 209.37,171.32 ; JHDMI.20 210.3,171.32 ; JHDMI.20 208.44,172.6 ; JHDMI.20 210.3,172.6 ; JHDMI.20 208.44,173.88 ; JHDMI.20 210.3,173.88 ; JHDMI.20 208.44,171.32 ; H20.1 299.29,77.67 ; H20.1 295.94,76.25 ; H20.1 299.29,74.83 ; H20.1 297.87,74.32 ; H20.1 297.87,78.18 ; H20.1 296.45,74.83 ; H20.1 296.45,77.67 ; H20.1 299.8,76.25 ; 5.07,67.87 H8.1 ; H8.1 6.49,68.38 ; H8.1 3.65,71.22 ; H8.1 7,69.8 ; H8.1 3.65,68.38 ; H8.1 6.49,71.22 ; H8.1 5.07,71.73 ; H8.1 3.14,69.8 ; JUSBC1.5 188.73,179.92 ; JUSBC1.5 187.62,178.48 ; JUSBC1.5 189.63,178.48 ; JUSBC1.5 189.63,179.92 ; JUSBC1.5 189.63,179.2 ; JUSBC1.5 187.62,179.2 ; JUSBC1.5 187.62,179.92 ; H21.1 263.49,7.92 ; H21.1 260.65,7.92 ; H21.1 262.07,4.57 ; H21.1 260.65,5.08 ; H21.1 264,6.5 ; H21.1 260.14,6.5 ; H21.1 262.07,8.43 ; H21.1 263.49,5.08 ; JDP.7 234.54,172.95 ; JDP.7 234.66,172.49 ; JDP.7 234.07,173.07 ; JDP.7 234.54,172.03 ; JDP.7 233.61,172.03 ; JDP.7 233.61,172.95 ; JDP.7 234.07,171.91 ; H15.1 184.64,181.52 ; H15.1 181.8,181.52 ; H15.1 185.15,180.1 ; H15.1 184.64,178.68 ; H15.1 181.29,180.1 ; H15.1 183.22,182.03 ; H15.1 181.8,178.68 ; H15.1 183.22,178.17 ; 265.49,4.26 H23.1 ; H23.1 270.45,6.5 ; H23.1 267.97,8.74 ; H23.1 270.45,4.26 ; H23.1 265.49,8.74 ; H23.1 267.97,4.26 ; H23.1 270.45,8.74 ; H23.1 265.49,6.5 ; 231.79,173.69 JDP.1 ; JDP.1 232.37,174.27 ; JDP.1 232.84,174.15 ; JDP.1 231.91,173.23 ; JDP.1 231.91,174.15 ; JDP.1 232.84,173.23 ; JDP.1 232.37,173.11 ; JUSB1.14 6.2,46.66 ; JUSB1.14 7.71,45.8 ; JUSB1.14 7.71,46.66 ; JUSB1.14 4.69,45.8 ; JUSB1.14 4.69,46.66 ; 274.37,41.8 H5.1 ; H5.1 276.07,45.84 ; H5.1 278.41,43.5 ; H5.1 276.07,41.16 ; H5.1 277.77,45.2 ; H5.1 274.37,45.2 ; H5.1 277.77,41.8 ; H5.1 273.73,43.5 ; 235.61,172.95 JDP.13 ; JDP.13 236.54,172.03 ; JDP.13 236.07,173.07 ; JDP.13 236.07,171.91 ; JDP.13 235.49,172.49 ; JDP.13 235.61,172.03 ; JDP.13 236.54,172.95 ; 0.38,63.79 JUSBC2.2 ; JUSBC2.2 1.8,65.45 ; JUSBC2.2 3.22,64.62 ; JUSBC2.2 0.38,65.45 ; JUSBC2.2 3.22,63.79 ; JUSBC2.2 3.22,65.45 ; JUSBC2.2 1.8,63.79 ; JUSBC2.2 0.38,64.62 ; 26.65,55.42 H10.1 ; H10.1 28.07,52.07 ; H10.1 26.65,52.58 ; H10.1 30,54 ; H10.1 29.49,55.42 ; H10.1 28.07,55.93 ; H10.1 26.14,54 ; H10.1 29.49,52.58 ; 179.67,4.57 H6.1 ; H6.1 181.6,6.5 ; H6.1 181.09,5.08 ; H6.1 178.25,7.92 ; H6.1 178.25,5.08 ; H6.1 181.09,7.92 ; H6.1 177.74,6.5 ; H6.1 179.67,8.43 ; H19.1 94.29,55.48 ; H19.1 94.29,58.32 ; H19.1 92.87,54.97 ; H19.1 90.94,56.9 ; H19.1 94.8,56.9 ; H19.1 91.45,58.32 ; H19.1 91.45,55.48 ; H19.1 92.87,58.83 ; 274.24,170.6 H12.1 ; H12.1 274.75,172.02 ; H12.1 278.1,170.6 ; H12.1 276.17,168.67 ; H12.1 277.59,169.18 ; H12.1 276.17,172.53 ; H12.1 277.59,172.02 ; H12.1 274.75,169.18 ; 195.81,179.2 JUSBC1.6 ; JUSBC1.6 197.82,178.48 ; JUSBC1.6 195.81,178.48 ; JUSBC1.6 196.72,179.92 ; JUSBC1.6 197.82,179.2 ; JUSBC1.6 197.82,179.92 ; JUSBC1.6 195.81,179.92 ; 5.62,56.76 JUSBC2.3 ; JUSBC2.3 8.08,55.2 ; JUSBC2.3 8.08,56.76 ; JUSBC2.3 6.85,55.2 ; JUSBC2.3 5.62,55.2 ; JUSBC2.3 8.08,55.98 ; JUSBC2.3 5.62,55.98 ; 15.96,34.99 JUSB1.4 ; JUSB1.4 17.31,34.4 ; JUSB1.4 17.14,34.99 ; JUSB1.4 15.96,33.81 ; JUSB1.4 16.55,35.16 ; JUSB1.4 16.55,33.64 ; JUSB1.4 15.79,34.4 ; JUSB1.4 17.14,33.81 ; JLAN.16 243.69,179.94 ; JLAN.16 244.6,178.19 ; JLAN.16 244.6,176.43 ; JLAN.16 242.77,178.19 ; JLAN.16 244.6,179.94 ; JLAN.16 242.77,179.94 ; JLAN.16 242.77,176.43 ; JLAN.16 243.69,176.43 ; JUSBC1.3 197.82,178.7 ; JUSBC1.3 197.04,177.47 ; JUSBC1.3 197.82,177.47 ; JUSBC1.3 197.04,179.93 ; JUSBC1.3 196.27,179.93 ; JUSBC1.3 196.27,177.47 ; JUSBC1.3 197.82,179.93 ; H18.1 103.49,5.08 ; H18.1 102.07,4.57 ; H18.1 100.14,6.5 ; H18.1 104,6.5 ; H18.1 103.49,7.92 ; H18.1 100.65,7.92 ; H18.1 100.65,5.08 ; H18.1 102.07,8.43 ; 187.62,178.7 JUSBC1.1 ; JUSBC1.1 188.4,179.93 ; JUSBC1.1 188.4,177.47 ; JUSBC1.1 189.18,177.47 ; JUSBC1.1 189.18,179.93 ; JUSBC1.1 187.62,177.47 ; JUSBC1.1 187.62,179.93 ; 240.57,175.34 JDP.21 ; JDP.21 239.8,176.65 ; JDP.21 239.8,175.34 ; JDP.21 240.57,177.96 ; JDP.21 241.35,176.65 ; JDP.21 241.35,175.34 ; JDP.21 241.35,177.96 ; JDP.21 239.8,177.96 ; H11.1 24.31,11.5 ; H11.1 22.07,13.74 ; H11.1 20.44,13.13 ; H11.1 20.44,9.87 ; H11.1 23.7,13.13 ; H11.1 19.83,11.5 ; H11.1 23.7,9.87 ; H11.1 22.07,9.26 ; 261.82,178.19 JLAN.14 ; JLAN.14 263.65,176.43 ; JLAN.14 261.82,179.94 ; JLAN.14 262.74,176.43 ; JLAN.14 262.74,179.94 ; JLAN.14 263.65,179.94 ; JLAN.14 261.82,176.43 ; JLAN.14 263.65,178.19 ; 144.57,169.57 H17.1 ; H17.1 142.64,171.5 ; H17.1 143.15,172.92 ; H17.1 145.99,172.92 ; H17.1 144.57,173.43 ; H17.1 146.5,171.5 ; H17.1 143.15,170.08 ; H17.1 145.99,170.08 ; 219.66,173.84 JHDMI.17 ; JHDMI.17 220.58,174.76 ; JHDMI.17 220.12,173.72 ; JHDMI.17 220.58,173.84 ; JHDMI.17 219.66,174.76 ; JHDMI.17 220.12,174.88 ; H16.1 24,4.2 ; H16.1 23.49,5.62 ; H16.1 20.65,5.62 ; H16.1 22.07,6.13 ; H16.1 22.07,2.27 ; H16.1 20.65,2.78 ; H16.1 23.49,2.78 ; H16.1 20.14,4.2 ; JCDRA.48 178.62,183.87 ; JCDRA.48 178.62,182.31 ; JCDRA.48 176.72,182.31 ; JCDRA.48 177.67,183.87 ; JCDRA.48 176.72,180.75 ; JCDRA.48 177.67,180.75 ; JCDRA.48 176.72,183.87 ; JCDRA.48 178.62,180.75 ; JHDMI.2 213.08,172.29 ; JHDMI.2 213.08,173.21 ; JHDMI.2 212.16,172.29 ; JHDMI.2 212.16,173.21 ; JHDMI.2 212.62,172.17 ; JHDMI.2 212.62,173.33 ; JHDMI.2 212.04,172.75 ; JUSBC1.4 197.04,185.17 ; JUSBC1.4 196.21,182.33 ; JUSBC1.4 197.87,185.17 ; JUSBC1.4 197.87,183.75 ; JUSBC1.4 197.04,182.33 ; JUSBC1.4 196.21,183.75 ; JUSBC1.4 196.21,185.17 ; JUSBC1.4 197.87,182.33 ; JUSBC2.4 3.22,55.98 ; JUSBC2.4 0.38,56.81 ; JUSBC2.4 0.38,55.15 ; JUSBC2.4 0.38,55.98 ; JUSBC2.4 1.8,55.15 ; JUSBC2.4 1.8,56.81 ; JUSBC2.4 3.22,56.81 ; JUSBC2.4 3.22,55.15 ; 188.4,182.33 JUSBC1.2 ; JUSBC1.2 188.4,185.17 ; JUSBC1.2 189.23,182.33 ; JUSBC1.2 189.23,185.17 ; JUSBC1.2 187.57,182.33 ; JUSBC1.2 187.57,183.75 ; JUSBC1.2 187.57,185.17 ; JUSBC1.2 189.23,183.75 ; JCDRA.50 146.12,179.27 ; JCDRA.50 146.12,177.71 ; JCDRA.50 146.12,176.15 ; JCDRA.50 145.17,176.15 ; JCDRA.50 145.17,179.27 ; JCDRA.50 144.22,176.15 ; JCDRA.50 144.22,177.71 ; JCDRA.50 144.22,179.27 ; JDP.19 238.24,174.15 ; JDP.19 238.36,173.69 ; JDP.19 237.31,173.23 ; JDP.19 238.24,173.23 ; JDP.19 237.31,174.15 ; JDP.19 237.77,173.11 ; JDP.19 237.77,174.27 ; JUSBC2.6 7.07,55.2 ; JUSBC2.6 5.63,55.2 ; JUSBC2.6 5.63,56.3 ; JUSBC2.6 7.07,57.21 ; JUSBC2.6 6.35,57.21 ; JUSBC2.6 6.35,55.2 ; JUSBC2.6 5.63,57.21 ; 224.84,180.77 JHDMI.23 ; JHDMI.23 225.77,183.33 ; JHDMI.23 226.7,180.77 ; JHDMI.23 225.77,180.77 ; JHDMI.23 226.7,183.33 ; JHDMI.23 224.84,182.05 ; JHDMI.23 224.84,183.33 ; JHDMI.23 226.7,182.05 ; JDP.24 229.57,172.96 ; JDP.24 230.35,171.65 ; JDP.24 229.57,170.34 ; JDP.24 228.8,170.34 ; JDP.24 228.8,172.96 ; JDP.24 230.35,170.34 ; JDP.24 228.8,171.65 ; 119.77,154.08 JPCMC.36 ; JPCMC.36 117.97,158.36 ; JPCMC.36 117.97,154.76 ; JPCMC.36 119.77,159.04 ; JPCMC.36 122.25,156.56 ; JPCMC.36 121.57,154.76 ; 157.83,155.6 H1.1 ; H1.1 161.87,157.3 ; H1.1 158.47,157.3 ; H1.1 160.17,153.26 ; H1.1 161.87,153.9 ; H1.1 160.17,157.94 ; H1.1 162.51,155.6 ; H1.1 158.47,153.9 ; 5.62,63.84 JUSBC2.1 ; JUSBC2.1 8.08,63.84 ; JUSBC2.1 6.85,65.4 ; JUSBC2.1 5.62,65.4 ; JUSBC2.1 8.08,65.4 ; JUSBC2.1 8.08,64.62 ; JUSBC2.1 5.62,64.62 ; 4.69,30 JUSB1.13 ; JUSB1.13 6.2,29.14 ; JUSB1.13 7.71,30 ; JUSB1.13 7.71,29.14 ; JUSB1.13 4.69,29.14 ; H14.1 202.22,182.03 ; H14.1 200.8,181.52 ; H14.1 200.29,180.1 ; H14.1 204.15,180.1 ; H14.1 203.64,178.68 ; H14.1 202.22,178.17 ; H14.1 203.64,181.52 ; H14.1 200.8,178.68
  BOTTOM w0.1: v2(256.27,86.3) 256.49,86.3 v2(257.11,86.92)
  BOTTOM w0.102: UG9.P51 254.17,89.85 254.5,89.52 254.84,89.52 254.96,89.64 255.96,89.64 v2(256.87,90.55) ; 257.09,105.98 257.09,106.58 257.43,106.92 257.43,107.57 257.8,107.94 257.8,109.73 v2(257.68,109.85) ; v2(256.97,108.96) 256.97,108.6 256.6,108.23 256.6,107.24 255.24,105.88 254.04,105.88 UG9.AU51
  BOTTOM w0.127: UG9.W10 v2(225.97,93.35)
  BOTTOM w0.13: v2(250.12,95.71) 250.38,95.45 UG9.AB47
  BOTTOM w0.15: UG9.AP43 v2(247.67,103.85) ; UG9.AW52 v2(254.97,107.65) ; v2(250.13,91.58) 250.46,91.25 UG9.T47 ; v2(224.77,91.45) 225.07,91.45 UG9.T10 v2(225.97,91.25) ; v2(253.52,103.9) 253.42,104 v2(252.98,104) ; v2(250.31,88.94) 249.98,88.94 UG9.N45 v2(250.07,89.45) ; v2(215.41,98.29) 215.41,98.39 216.55,99.53 219.55,99.53 UG9.AH2 ; v2(256.93,104.51) 256.93,104.68 256.66,104.95 256.13,104.95 255.81,104.63 v2(255.81,104.58) ; UG9.D16 229.81,82.51 229.81,82.11 v2(229.57,81.88) ; v2(249.32,97.37) 249.59,97.37 UG9.AE45 ; UG9.BC28 v2(237.87,109.45) ; v2(247.67,101.75) UG9.AL43 v2(248.77,101.35) ; UG9.AV45 v2(249.35,106.23) ; UG9.K37 v2(244.17,87.75) ; v2(251.47,97.85) UG9.AE47 v2(251.47,97.25) ; UG9.AB10 v2(225.97,95.45) ; UG9.AB8 v2(223.53,95.11) ; UG9.AB8 v2(223.57,95.75) ; UG9.AB8 223.97,95.45 v2(224.27,95.75) ; v2(250.2,93.61) 250.03,93.61 UG9.W45 249.48,93.06 v2(249.46,93.06) ; v2(251.99,99.53) 251.87,99.65 UG9.AH47 ; v2(215.07,101.05) 216.01,100.11 218.65,100.11 218.76,100 219.12,100 219.47,100.35 UG9.AJ2 ; v2(251.47,103.55) 251.77,103.85 UG9.AP49 ; v2(217.27,84.84) 217.27,84.6 217.46,84.41 218.06,84.41 218.27,84.62 218.27,84.7 v2(218.47,84.9) ; v2(255.15,105.25) 255.45,105.25 256.18,105.98 257.09,105.98 v2(257.54,105.53) ; v2(239.97,87.75) UG9.K31 239.97,86.35 v2(240.22,86.1) ; v2(258.21,83.89) 258.17,83.85 v2(257.49,83.85) 257.25,84.09 255.48,84.09 v2(255.32,84.25) ; v2(235.47,85.95) UG9.H25 v2(236.07,85.35) ; UG9.N43 v2(247.67,89.15) ; v2(229.47,87.75) UG9.K16 229.67,86.85 v2(229.67,86.5) ; 254.32,83.2 254.33,83.21 255.96,83.21 ; UG9.AP47 250.49,103.85 ; UG9.AH45 248.99,99.65 v2(248.7,99.35) ; v2(250.74,99.5) 250.52,99.5 v2(250.07,99.95) ; UG9.AU47 v2(251.47,106.25) 251.77,105.95 UG9.AU49 ; UG9.AU47 UG9.AU45 ; UG9.AU47 v2(251.47,105.65) ; UG9.K19 v2(231.57,87.75) ; UG9.AH43 v2(247.67,99.65) ; UG9.BC16 v2(229.47,109.45) ; UG9.BC22 v2(233.67,109.45) ; UG9.AP10 v2(225.97,103.85) ; UG9.K34 v2(242.07,87.75) ; 218.74,83.2 218.62,83.08 218.62,83.07 218.38,82.84 218.38,82.84 218.34,82.8 218.08,82.8 v2(217.64,83.25) 217.19,82.8 216.16,82.8 v2(215.71,83.25) ; UG9.BC31 v2(239.97,109.45) ; UG9.AL10 v2(225.97,101.75) ; UG9.BC34 v2(242.07,109.45) ; v2(247.67,91.25) UG9.T43 UG9.T45 ; v2(225.97,97.55) UG9.AE10 ; v2(247.67,95.45) UG9.AB43 ; v2(251.54,93.03) 251.22,93.35 UG9.W47 ; v2(235.77,87.75) UG9.K25 ; UG9.W43 v2(247.67,93.35) ; v2(225.97,89.15) UG9.N10 ; UG9.BC13 v2(227.37,109.45) ; v2(252.87,108.35) v2(253.67,108.35) ; UG9.K28 v2(237.87,87.75) ; v2(227.37,87.75) UG9.K13 ; UG9.BC19 v2(231.57,109.45) ; UG9.AE43 v2(247.67,97.55) ; 219.32,83.2 v2(219.37,83.25) ; UG9.K40 v2(246.27,87.75) ; UG9.BC37 v2(244.17,109.45) ; v2(233.67,87.75) UG9.K22 ; UG9.AU10 v2(225.97,105.95)
  BOTTOM w0.152: UH1.AA20 204.41,29.76 ; UH1.AA20 205.18,30.54 ; UH1.AA20 204.41,30.54 ; UH1.AA20 v2(205.18,29.76) ; 204.41,29.76 UH1.Y20 ; 204.41,29.76 UH1.Y21 ; 204.41,29.76 204.8,29.38 UH1.AA21 ; 206.73,25.89 UH1.AF28 ; 206.73,25.89 UH1.AE28 ; 206.73,25.89 UH1.AF29 207.51,25.89 ; 206.73,25.89 UH1.AE29 v2(205.96,25.89) ; UH1.AF28 207.51,25.89 ; UH1.AF28 207.51,26.66 ; UH1.AF28 206.73,26.66 ; UH1.AC21 v2(205.96,29.76) ; UH1.AC21 v2(205.96,28.99) UH1.AE21 ; UH1.AC21 v2(205.18,28.98) 204.8,29.36 UH1.AA21 ; UH1.AC21 v2(205.18,29.76) ; v2(205.96,29.76) UH1.AE21 ; v2(205.96,29.76) UH1.AE20 ; v2(205.96,29.76) UH1.AC20 ; 207.51,28.99 UH1.AH21 207.51,29.76 ; 207.51,28.99 UH1.AH23 207.51,28.21 ; 207.51,28.99 UH1.AF23 ; 207.51,28.99 UH1.AF21 ; 207.63,31.96 UH1.AH17 ; UH1.AH17 208.16,31.96 ; UH1.AH17 UH1.AJ15 ; UH1.AU45 212.41,17.62 v2(212.08,17.3) ; UH1.AF20 206.73,30.54 ; UH1.AF20 207.51,29.76 ; UH1.AF20 v2(206.73,29.76) ; UH1.AF20 207.51,30.54 ; 206.73,30.54 UH1.AF18 207.51,30.54 ; 206.73,30.54 UH1.AE20 ; 206.73,30.54 UH1.AE18 205.96,30.54 ; v2(208.29,26.65) 208.66,26.28 UH1.AJ28 208.38,25.99 v2(208.29,25.99) ; v2(208.29,26.65) 208.29,26.67 UH1.AJ26 ; v2(208.29,26.65) 207.89,27.05 UH1.AH26 ; v2(214.19,27.59) 214.23,27.55 UH1.BB25 ; 205.18,30.54 UH1.AA18 ; 205.18,30.54 UH1.AC18 ; 205.18,30.54 UH1.AC20 ; UH1.AA21 205.18,29.76 v2(205.18,29.76) ; UH1.AA29 204.53,25.24 ; UH1.AA29 205.06,25.24 ; UH1.AA29 v2(205.18,25.89) UH1.AC29 ; UH1.AA29 v2(204.41,25.89) ; v2(217.24,30.98) 217.13,30.87 UH1.BE18 ; v2(206.73,29.76) UH1.AE21 ; v2(206.73,29.76) UH1.AE20 ; v2(206.73,29.76) UH1.AF21 ; UH1.AE21 v2(206.73,28.99) ; 207.51,29.76 UH1.AH20 207.51,30.54 ; 207.51,29.76 UH1.AF21 ; v2(215.39,31.92) 215.39,31.91 215.08,31.91 UH1.BB16 ; UH1.Y20 203.63,30.54 ; UH1.Y20 v2(203.63,29.76) ; UH1.Y20 204.41,30.54 ; UH1.A32 194.53,24.06 v2(194.33,24.26) ; UH1.T42 v2(202.06,18.86) ; 207.51,27.44 UH1.AH25 ; 207.51,27.44 UH1.AH26 ; 207.51,27.44 UH1.AF26 ; 207.51,27.44 UH1.AF25 ; UH1.AH25 207.51,28.21 ; UH1.AH25 v2(208.28,27.44) ; 202.83,30.56 UH1.U18 202.47,30.93 202.85,31.31 202.86,31.31 202.86,31.31 ; 202.83,30.56 UH1.V18 ; 202.83,30.56 UH1.V20 ; v2(205.96,25.89) UH1.AC29 ; v2(205.96,25.89) UH1.AE28 ; UH1.AC29 205.31,25.24 ; UH1.AC29 205.83,25.24 ; 207.51,25.89 UH1.AH29 208.29,25.9 v2(208.29,25.99) ; 207.51,25.89 UH1.AH28 ; v2(203.63,29.76) UH1.V21 v2(203.63,28.99) ; v2(203.63,29.76) UH1.Y21 ; v2(203.63,29.76) UH1.V20 ; UH1.AC45 205.56,17.67 v2(205.3,17.41) ; UH1.Y17 204.41,31.31 ; 204.41,31.31 UH1.AA17 ; 204.41,31.31 UH1.Y18 ; 204.41,31.31 UH1.AA18 ; v2(207.6,17.37) 207.84,17.6 UH1.AH45 ; v2(217.77,29.26) 217.77,29.25 217.18,28.66 216.45,28.66 UH1.BE23 ; UH1.AM45 209.87,17.55 v2(209.87,17.31) ; v2(196.25,17.11) 196.11,17.25 UH1.D45 ; UH1.AC20 v2(205.18,29.76) ; UH1.AC20 205.96,30.54 ; 207.51,28.21 UH1.AF23 ; 207.51,28.21 UH1.AF25 ; UH1.AL19 v2(209.57,30.89) ; v2(209.57,30.89) UH1.AM17 ; v2(209.57,30.89) UH1.AM19 ; v2(209.57,30.89) UH1.AL17 ; UH1.AA25 v2(205.18,28.21) UH1.AC25 ; CPU1.G28 169.08,113.41 168.77,113.09 168.77,112.39 CPU1.G26 ; UH1.BE32 216.38,23.45 v2(216.38,23.44) ; 193.8,38.26 193.8,37.79 194.43,37.17 194.43,36.97 194.64,36.77 194.72,36.77 194.73,36.76 194.98,36.76 UH1.B6 ; v2(212.67,39.91) 212.67,39.66 UH1.AU1 ; v2(203.63,28.99) UH1.Y21 ; v2(203.63,28.99) UH1.V23 v2(203.63,28.21) UH1.V25 v2(203.63,27.44) UH1.Y26 v2(204.41,26.66) UH1.Y28 v2(204.41,25.89) ; UH1.V29 v2(202.86,25.89) ; v2(202.86,25.89) UH1.U28 ; v2(202.86,25.89) UH1.U29 ; 203.63,30.54 UH1.V18 ; 203.63,30.54 UH1.V20 ; 203.63,30.54 UH1.Y18 ; UH1.V18 203.24,30.92 ; UH1.V18 UH1.U17 ; v2(206.73,27.44) UH1.AE25 v2(206.73,28.21) ; v2(206.73,27.44) UH1.AF26 ; v2(206.73,27.44) UH1.AF25 ; UH1.AH28 207.89,26.31 ; UH1.AH28 208,26.28 v2(208.29,25.99) ; UH1.AH28 207.51,26.66 ; UH1.AH26 207.51,26.66 ; UH1.AH26 v2(208.28,27.44) ; UH1.AH1 207.98,39.55 v2(207.98,39.91) ; UH1.P45 200.76,17.79 v2(200.6,17.63) ; v2(203.02,17.1) 203.29,17.37 UH1.V45 ; v2(208.28,27.44) UH1.AJ26 ; UH1.AJ26 208.63,27.05 ; UG9.H1 218.08,85.65 v2(217.27,84.84) ; 207.51,26.66 UH1.AF26 ; v2(215.34,29.68) 215.2,29.83 UH1.BB21 ; UH1.AA17 205.18,31.31 ; UH1.AA17 205.06,31.96 ; 204.41,30.54 UH1.AA18 ; 204.41,30.54 UH1.Y18 ; UH1.AA18 205.18,31.31 ; UH1.AC18 205.18,31.31 ; UH1.AC18 205.96,30.54 ; v2(214.5,34.19) 214.71,34.19 UH1.BB11 ; 206.73,26.66 UH1.AE28 ; 206.73,26.66 UH1.AF26 ; UH1.AF23 v2(206.73,28.21) ; UH1.AF23 v2(206.73,28.99) ; v2(206.73,28.21) UH1.AF25 ; v2(201.86,39.85) 202.07,39.64 UH1.T1 UH1.T2 ; UH1.AE20 205.96,30.54 ; v2(196.29,24.01) 196.17,23.89 UH1.D33 196.17,23.34 v2(195.85,23.03) 196.05,22.83 UH1.D35 196.24,22.38 UH1.D36 196.15,21.99 UH1.C37 UH1.B37 194.83,21.68 UH1.A37 ; v2(206.73,28.99) UH1.AF21 ; 202.21,25.24 UH1.U29 ; UH1.U29 202.73,25.24 ; UH1.U29 202.21,25.76 ; UH1.AR42 211.34,19.53 v2(211.16,19.71) ; v2(204.41,25.89) UH1.Y29 ; 207.51,30.54 UH1.AH18 ; UH1.A18 194.13,30.88 v2(194.07,30.83) ; v2(216.98,32.97) 216.81,33.14 UH1.BE14 ; v2(209,18.73) 209,18.79 209.07,18.87 UH1.AK42 ; 208.93,30.66 UH1.AJ18 208.9,31.15 ; UH1.AC1 205.58,39.85 v2(205.57,39.86) ; UG9.AH10 v2(225.97,99.65) ; UH1.AJ17 208.93,31.96 ; UH1.AJ17 UH1.AJ15 ; UH1.AJ17 208.93,31.44 ; UH1.AJ14 UH1.AJ15 ; UH1.B25 UH1.A25 194.35,27.37 v2(194.27,27.46)
  BOTTOM w0.178: v2(180,167.71) 180.02,167.71 CT83.2
  BOTTOM w0.2: v2(252.87,90.85) 253.17,91.15 v2(253.47,91.15) ; UG9.BJ34 UG9.BJ35 UG9.BJ36 UG9.BH36 ; v2(251.57,90.95) 252.02,91.4 v2(252.02,91.45) ; UG9.BJ39 UG9.BJ40 ; UG9.BJ39 UG9.BJ38 UG9.BJ37 ; UG9.BJ39 UG9.BH39 ; UG9.BH33 UG9.BJ33 UG9.BJ32 UG9.BJ31 ; v2(261.12,84.43) 260.37,84.43 258.59,82.65 256.52,82.65 255.96,83.21 ; UG9.BJ28 UG9.BJ29 UG9.BJ30 UG9.BH30 ; UG9.BH15 UG9.BJ15 UG9.BJ14 UG9.BJ13 ; UG9.BJ25 UG9.BJ26 UG9.BJ27 UG9.BH27 ; UG9.BJ22 UG9.BJ23 UG9.BJ24 UG9.BH24 ; v2(249.42,105.65) 249.47,105.65 UG9.AU45 ; 250.49,103.85 250.43,103.85 v2(250.24,104.05) 249.97,104.05 UG9.AP45 ; v2(248.83,105.71) v2(249.35,106.23) ; UG9.BH21 UG9.BJ21 UG9.BJ20 UG9.BJ19 ; UG9.BJ16 UG9.BJ17 UG9.BJ18 UG9.BH18 ; 254.32,83.2 v2(254.27,83.25)
  BOTTOM w0.203: CPU1.AU12 145.53,100.75 v2(145.2,101.08) 145.05,101.08 CPU1.AW12 144.72,100.76 144.37,101.11 v2(144.27,101.11) 143.9,100.75 CPU1.AY12 ; CPU1.AU12 145.72,100.75 v2(146.08,101.11) ; CPU1.AU12 CPU1.AU11 ; 134.63,100.46 134.31,100.78 CPU1.BN12 ; 134.63,100.46 134.96,100.78 CPU1.BM12 135.28,101.15 v2(135.28,101.22) 135.28,101.29 CPU1.BL13 135.93,101.93 135.99,101.93 ; 134.63,100.46 134.96,100.13 CPU1.BM11 134.96,99.97 134.63,99.64 ; CPU1.A9 CPU1.B9 172.17,98.53 172.17,98.46 v2(172.01,98.3) ; CPU1.AN12 149.55,101.01 149.95,101.01 CPU1.AM12 150.47,101.01 150.86,101.01 CPU1.AL12 ; CPU1.AN12 148.93,101.11 v2(148.85,101.11) 148.74,101.11 CPU1.AP12 ; CPU1.AN12 149.12,100.75 v2(148.83,100.46) ; v2(141.64,117.93) 141.32,117.61 CPU1.BC34 ; CPU1.BA8 142.94,98.15 v2(143.35,98.55) ; CPU1.BA8 CPU1.BA7 142.64,97.25 142.64,97.22 CPU1.BB6 ; CPU1.BA8 CPU1.BA9 ; UH1.AH20 207.9,30.15 v2(208.28,30.53) ; CPU1.K1 CPU1.K2 CPU1.K3 ; CPU1.L30 CPU1.L29 ; 168.64,95.86 168.97,95.54 CPU1.G4 CPU1.F4 ; 168.64,95.86 168.56,95.86 CPU1.J4 CPU1.K4 ; 168.64,95.86 168.97,96.19 CPU1.G5 ; CPU1.F31 169.7,116.04 169.07,116.04 CPU1.H32 168.73,116.31 v2(168.42,116.63) ; v2(148.83,100.46) 148.74,100.46 CPU1.AP11 ; v2(148.83,100.46) 148.55,100.75 CPU1.AP12 ; v2(148.83,100.46) 148.84,100.46 v2(148.84,99.82) v2(148.83,99.19) ; CPU1.K4 167.4,95.41 167.41,95.4 167.41,95.02 167.4,95.01 CPU1.K3 ; CPU1.K4 167.4,95.66 167.41,95.67 167.41,96.05 167.4,96.06 CPU1.K5 167.07,96.51 v2(166.96,96.51) ; v2(164.44,117.28) 164.45,117.28 ; 164.45,117.28 164.84,117.61 CPU1.N34 ; 164.45,117.28 164.84,116.96 CPU1.N33 ; CPU1.AP12 148.05,101.08 v2(147.92,101.08) 147.78,101.08 CPU1.AR13 ; CPU1.Y10 CPU1.Y11 159.52,100.1 159.62,100 159.63,100 v2(159.81,99.82) 159.44,99.45 CPU1.Y10 ; CPU1.Y10 CPU1.Y9 CPU1.Y8 CPU1.Y7 159.1,97.25 158.69,97.25 158.58,97.14 158.48,97.14 CPU1.AB6 CPU1.AC6 157.34,96.72 157.35,96.7 157.35,96.32 157.34,96.31 CPU1.AC5 157.34,96.06 157.35,96.05 157.35,95.72 157.34,95.71 CPU1.AC4 ; CPU1.J33 168.08,116.96 v2(168.42,116.63) ; UH1.D25 196.24,26.93 UH1.D27 196.15,26.59 v2(196.36,26.38) 196.22,26.23 UH1.C28 ; CPU1.AR2 147.32,94.27 147.32,94.85 CPU1.AR3 147.29,94.9 147.29,95.4 147.28,95.41 CPU1.AR4 147.28,95.67 147.33,95.72 147.33,96 147.28,96.05 CPU1.AR5 ; v2(137.86,98.55) 137.62,98.8 CPU1.BH9 ; v2(137.86,98.55) 137.46,98.15 CPU1.BH8 ; v2(137.86,98.55) 137.89,98.53 137.89,97.8 137.58,97.5 CPU1.BH7 ; CPU1.BA12 143.06,100.75 v2(143.35,100.46) 143.64,100.75 CPU1.AY12 ; CPU1.BA12 143.24,101.09 v2(143.35,101.09) 143.46,101.09 CPU1.AY12 ; CPU1.BA12 142.76,100.75 v2(142.43,101.07) 142.3,101.07 CPU1.BB12 141.71,101.02 v2(141.52,101.02) ; CPU1.BA12 CPU1.BA11 ; v2(131.57,116.54) 131.6,116.51 CPU1.BT32 ; CPU1.BM26 134.96,111.78 v2(135.28,111.45) ; CPU1.N8 165.29,98.6 v2(165.29,99.07) 165.23,99.07 164.95,98.8 CPU1.N9 ; CPU1.N8 CPU1.N7 164.84,97.24 164.88,97.19 CPU1.N6 ; CPU1.N8 CPU1.N9 ; v2(165.3,100.43) 165.61,100.75 CPU1.M12 CPU1.M13 CPU1.M14 ; v2(165.3,100.43) 164.98,100.75 CPU1.N12 ; v2(165.3,100.43) 164.96,100.1 CPU1.N11 ; v2(268.93,162.05) 269.11,162.24 UL1.27 ; v2(138.49,119.23) 138.16,119.56 CPU1.BG37 ; CPU1.AR13 147.79,101.72 v2(147.92,101.72) 147.6,102.05 CPU1.AR14 147.33,102.05 v2(147.01,101.72) ; CPU1.AR13 147.13,101.07 v2(147.02,101.07) ; UG12.11 196.66,109.41 196.69,109.38 196.69,108.68 CG64.2 ; JCDRA.38 167.42,178.75 v2(167.65,178.98) ; CPU1.F27 169.66,112.86 169.42,112.63 v2(169.42,112.45) 169.08,112.11 CPU1.G26 ; v2(160.55,117.27) 160.21,117.61 CPU1.W34 ; v2(139.29,92.62) 139.74,93.07 CPU1.BE1 CPU1.BE2 139.74,94.36 139.75,94.37 139.75,94.75 139.74,94.76 CPU1.BE3 ; v2(168.42,116.63) 168.1,116.31 CPU1.J32 ; UH1.AM22 v2(209.58,29.79) ; CPU1.AL8 CPU1.AL7 151.43,97.19 151.62,97.19 151.72,97.09 152.06,97.09 CPU1.AJ6 CPU1.AH6 CPU1.AG6 154.24,97.09 v2(154.4,97.09) ; CPU1.AL8 151.17,98.15 v2(151.58,98.55) v2(151.58,99.19) ; CPU1.AL8 CPU1.AL9 ; 134.63,99.64 134.31,99.32 CPU1.BN9 ; 134.63,99.64 134.96,99.32 CPU1.BM9 134.71,99 134.71,98.71 CPU1.BM8 134.71,98.21 134.71,97.93 CPU1.BM7 CPU1.BN7 ; CPU1.BT4 132.29,95.54 131.91,95.54 v2(131.78,95.41) ; CPU1.BM23 134.96,109.55 v2(134.63,109.88) 134.63,109.95 CPU1.BN24 ; CPU1.AB33 v2(158.18,117.28) CPU1.AB34 ; CPU1.W33 v2(160.54,116.63) ; CPU1.N6 164.92,96.8 164.92,96.23 CPU1.N5 CPU1.N4 CPU1.N3 ; CPU1.N6 CPU1.M6 ; CPU1.N6 CPU1.P6 ; CPU1.T34 162.57,117.61 v2(162.9,117.28) CPU1.T33 ; v2(131.06,100.97) 132.21,100.97 CPU1.BT12 CPU1.BR12 133.14,100.82 133.16,100.8 133.5,100.8 133.53,100.82 CPU1.BP12 133.71,100.77 133.78,100.77 133.79,100.76 134.17,100.76 134.18,100.77 134.26,100.77 CPU1.BN12 ; CPU1.G14 169.08,102.77 CPU1.F15 169.73,103.49 v2(169.41,103.81) 169.08,104.14 CPU1.G16 ; v2(174,115.79) 173.74,115.79 173.38,115.43 CPU1.A30 ; CPU1.BN7 134.38,97.6 v2(134.38,97.14) 134.75,96.76 CPU1.BM6 ; CPU1.BN7 CPU1.BP7 CPU1.BR7 132.92,97.76 131.59,97.76 131.13,97.3 131,97.3 130.93,97.23 130.72,97.23 130.22,96.73 v2(129.98,96.73) ; CPU1.G22 169.08,108.86 v2(169.41,108.54) 169.73,108.21 CPU1.F21 ; CPU1.D16 171.28,103.95 171.28,103.81 CPU1.C15 172.01,103.09 v2(172.01,103.02) ; UH1.AV24 v2(212.51,27.37) UH1.AV27 ; CPU1.BH10 137.6,99.45 v2(137.86,99.19) ; CPU1.BH10 CPU1.BH11 ; CPU1.BH10 CPU1.BH9 ; CPU1.BA10 143.09,99.45 v2(143.35,99.19) v2(143.35,98.55) ; CPU1.BA10 CPU1.BA11 ; CPU1.BA10 CPU1.BA9 ; CPU1.AD11 CPU1.AD12 156.78,100.75 v2(157.06,100.46) ; CPU1.AD11 156.7,100.1 v2(157.06,100.46) ; CPU1.AD11 CPU1.AD10 ; UH1.BB30 214.89,25.07 v2(214.69,24.87) ; CPU1.BD10 CPU1.BD11 ; CPU1.BD10 CPU1.BD9 ; CPU1.BD10 140.35,99.45 v2(140.61,99.19) ; CPU1.BD11 CPU1.BD12 140.32,100.75 v2(140.61,100.46) 140.89,100.75 CPU1.BC12 CPU1.BC13 140.87,101.4 v2(140.59,101.12) ; CPU1.BD11 140.34,100.1 v2(140.61,99.82) ; CPU1.T10 CPU1.T11 ; CPU1.T10 CPU1.T9 ; CPU1.T10 162.35,99.19 162.48,99.19 ; CPU1.T10 162.18,99.45 v2(162.56,99.82) 162.28,100.1 CPU1.T11 ; CPU1.T11 CPU1.T12 ; CPU1.BH8 CPU1.BH9 ; CPU1.BH8 CPU1.BH7 ; v2(146.36,117.93) 146.04,117.61 CPU1.AU34 ; v2(172.01,106.17) 171.68,106.5 CPU1.C19 171.28,106.96 171.28,107.1 CPU1.D20 ; CPU1.AU7 CPU1.AU8 CPU1.AU9 CPU1.AU10 CPU1.AU11 ; CPU1.AU7 145.63,96.87 CPU1.AU6 145.35,96.59 145.17,96.59 CPU1.AW5 CPU1.AW4 CPU1.AW3 ; CPU1.AU7 145.89,97.25 146.03,97.25 CPU1.AT6 ; CPU1.BB5 142.25,96.06 142.32,96 142.32,95.72 142.25,95.66 CPU1.BB4 142.25,95.41 142.32,95.35 142.32,95.07 142.25,95.01 CPU1.BB3 ; CPU1.BB5 142.17,96.19 141.87,96.48 v2(141.87,96.51) ; CPU1.BB5 142.41,96.35 142.41,96.67 CPU1.BB6 ; CPU1.BB6 CPU1.BA6 ; CPU1.BB6 142.2,96.84 v2(141.87,96.51) ; CPU1.AM38 149.97,120.21 v2(150.3,119.89) 149.98,119.56 CPU1.AM37 ; 140.16,97.09 139.99,97.09 CPU1.BE6 ; 140.16,97.09 140.32,97.09 CPU1.BD6 ; 140.16,97.09 140.15,97.1 CPU1.BD7 ; CPU1.BN12 134.63,101.14 v2(134.63,101.21) 134.96,101.54 CPU1.BM13 ; v2(139.28,94.47) 139.32,94.47 CPU1.BE3 ; CPU1.F5 169.18,96.33 CPU1.G5 ; v2(160.22,176.32) 160.22,176.33 JCDRA.20 ; CPU1.AP33 148.41,116.96 v2(148.73,117.28) 148.4,117.61 CPU1.AP34 ; CPU1.AH33 153.13,116.96 v2(153.45,117.28) 153.12,117.61 CPU1.AH34 ; v2(208.28,30.53) 207.89,30.91 UH1.AH18 207.9,30.92 v2(208.28,31.3) ; v2(208.28,30.53) 208.67,30.92 UH1.AJ18 208.66,30.92 v2(208.28,31.3) ; CPU1.AR38 147.62,120.21 v2(147.94,120.54) ; CPU1.T9 CPU1.T8 CPU1.T7 161.84,97.25 161.84,97.15 CPU1.U6 CPU1.V6 160.44,96.59 160.25,96.59 CPU1.W5 CPU1.W4 CPU1.W3 ; CPU1.T9 162.48,99.19 ; CPU1.BR34 CPU1.BP34 133.98,117.03 v2(133.98,116.97) 134.31,117.29 CPU1.BN34 ; v2(161.92,92.62) 162.37,93.08 162.37,93.49 162.37,93.49 CPU1.T1 CPU1.T2 CPU1.T3 CPU1.T4 CPU1.T5 ; v2(134,107.5) 134.31,107.19 CPU1.BN20 133.98,106.8 v2(133.98,106.73) 134.31,106.4 CPU1.BN19 ; v2(134,107.5) 133.66,107.84 CPU1.BP21 CPU1.BR21 CPU1.BT21 v2(131.58,107.91) ; v2(134,107.5) 134.31,107.8 CPU1.BN21 134.45,107.91 134.51,107.85 134.83,107.85 134.88,107.91 CPU1.BM21 134.96,107.98 v2(135.27,108.3) ; JCDRA.44 169.82,176.65 v2(170.08,176.39) ; UH1.E15 196.17,32.67 UH1.D15 196.25,32.59 UH1.D16 196.25,31.48 UH1.D17 196.3,31.23 196.3,30.52 UH1.D19 196.17,30.3 195.82,29.96 v2(195.82,29.65) UH1.D21 ; CPU1.F4 169.82,95.43 CPU1.F3 ; CPU1.F4 CPU1.E4 ; CPU1.BN30 134.62,115.31 v2(134.62,115.42) 134.62,115.47 CPU1.BN31 133.91,116.18 133.91,116.32 CPU1.BP33 ; v2(157.34,93.04) CPU1.AC1 157.34,94.06 157.33,94.19 157.34,94.19 CPU1.AC2 CPU1.AC3 CPU1.AC4 ; v2(146.1,99.82) 145.92,100 145.9,100 145.81,100.1 CPU1.AU11 ; UG9.B16 229.47,81.78 v2(229.57,81.88) ; CPU1.BB3 142.15,94.89 141.87,94.61 v2(141.87,94.56) ; CPU1.BB3 142.34,94.8 142.34,94.32 CPU1.BB2 142.25,94.1 142.29,94.05 142.29,93.77 142.25,93.72 CPU1.BB1 142.3,93.54 142.3,93.05 v2(141.9,92.65) ; CPU1.E35 170.44,118.2 170.44,117.75 170.38,117.68 CPU1.E34 ; CPU1.G20 169.08,107.29 v2(169.41,106.96) 169.73,106.64 CPU1.F19 ; v2(141.87,96.51) 141.55,96.84 CPU1.BC6 CPU1.BD6 ; CPU1.BA9 143.1,98.8 v2(143.35,98.55) ; v2(151.58,99.19) 151.51,99.19 CPU1.AL9 ; v2(151.58,99.19) v2(151.58,99.82) 151.5,99.82 CPU1.AL10 CPU1.AL9 ; CPU1.W3 159.89,94.85 159.89,94.27 CPU1.W2 159.85,94.11 159.85,93.89 CPU1.W1 159.85,92.87 v2(159.41,92.5) ; CPU1.W3 159.74,94.89 159.41,94.56 v2(159.41,94.59) ; v2(195.42,128.63) 195.52,128.72 UV21.18 ; v2(158.97,176.38) 159.02,176.43 JCDRA.17 ; CPU1.BH5 137.22,96.28 137.26,96.32 137.26,96.7 137.22,96.74 CPU1.BH6 ; CPU1.BH5 CPU1.BH4 CPU1.BH3 CPU1.BH2 136.97,93.98 CPU1.BH1 136.97,93.03 v2(137.18,92.82) ; CPU1.BH5 137.08,96.19 v2(136.8,96.46) ; v2(169.41,110.11) 169.08,110.44 CPU1.G24 ; v2(169.41,110.11) 169.08,109.79 CPU1.G23 ; v2(169.41,110.11) 169.41,110.04 CPU1.F23 ; CPU1.BE6 139.6,96.7 139.6,96.33 CPU1.BE5 ; CPU1.BE6 CPU1.BF6 CPU1.BG6 CPU1.BH6 ; v2(213.3,31.11) UH1.AV17 UH1.AT15 ; CPU1.AC37 v2(157.39,119.23) ; v2(131.36,96.36) 131.39,96.38 132.34,96.38 CPU1.BT5 ; v2(148.83,98.55) 148.59,98.8 CPU1.AP9 ; v2(148.83,98.55) 148.43,98.15 CPU1.AP8 148.82,97.71 148.82,97.36 148.96,97.22 CPU1.AN6 148.91,96.79 CPU1.AN5 149.23,95.86 v2(149.4,95.86) 149.73,96.19 CPU1.AM5 ; v2(148.83,98.55) v2(148.83,99.19) ; v2(143.35,99.82) 143.08,100.1 CPU1.BA11 ; CPU1.AV38 145.25,120.21 v2(145.58,119.89) 145.26,119.56 CPU1.AV37 ; CPU1.BF33 138.96,116.96 v2(139.28,117.28) 138.95,117.61 CPU1.BF34 ; CPU1.N3 164.77,94.89 164.46,94.58 v2(164.41,94.58) ; CPU1.N3 CPU1.N2 CPU1.N1 164.88,93.45 164.89,93.45 164.89,92.87 164.88,92.87 v2(164.88,92.81) ; CPU1.A10 173.52,99.48 v2(173.55,99.44) ; v2(216.94,21.8) 216.88,21.75 UH1.BE37 ; v2(161.33,175.48) 161.33,175.49 161.42,175.58 JCDRA.23 ; CPU1.BH11 137.59,100.1 v2(137.87,99.82) ; CPU1.BH11 CPU1.BH12 ; UH1.AY45 214.03,18.05 213.99,18.09 213.99,18.12 213.98,18.14 213.98,18.39 213.99,18.41 213.99,18.94 v2(214.13,19.08) ; v2(143.21,119.23) 142.89,119.56 CPU1.BA37 142.82,119.63 142.88,119.7 142.88,120.07 142.82,120.14 CPU1.BA38 ; v2(213.29,24.85) 213.29,24.95 213.64,25.3 UH1.AW29 ; v2(169.42,110.91) 169.42,110.98 CPU1.F25 ; CPU1.H25 CPU1.J25 167.44,111.29 167.16,111.57 v2(167.16,111.74) ; v2(148.83,99.19) 148.58,99.45 CPU1.AP10 ; v2(136.09,101.02) 136.26,101.19 CPU1.BK13 136.26,101.67 135.99,101.93 ; CPU1.BJ15 CPU1.BK15 136.23,103.19 135.85,102.81 135.85,102.79 v2(135.87,102.79) 136.26,102.4 CPU1.BK14 136.26,102.19 135.99,101.93 ; UV21.57 203.82,131.38 v2(203.87,131.34) ; v2(136.8,96.46) 136.85,96.46 CPU1.BH6 ; v2(136.8,96.46) 136.71,96.46 136.38,96.79 CPU1.BK6 CPU1.BL6 134.84,96.84 CPU1.BM6 ; CPU1.H11 168.43,100.34 v2(168.76,100.66) ; 162.48,99.19 v2(162.56,99.19) ; CPU1.D24 171.28,110.25 171.28,110.11 CPU1.C23 171.68,109.65 v2(172.01,109.32) ; CPU1.BE5 139.74,96.06 139.75,96.05 139.75,95.67 139.74,95.66 CPU1.BE4 139.74,95.41 139.75,95.4 139.75,95.02 139.74,95.01 CPU1.BE3 ; CPU1.BE5 139.82,96.19 140.13,96.5 v2(140.13,96.51) 140.46,96.84 CPU1.BD6 ; v2(174.2,102.63) CPU1.A14 ; CPU1.Y14 159.45,102.05 v2(159.78,101.72) 159.45,101.4 CPU1.Y13 ; CPU1.D26 171.28,111.83 171.28,111.69 CPU1.C25 171.68,111.22 v2(172.01,110.9) ; v2(173.8,108.93) CPU1.A22 ; CPU1.C37 CPU1.B37 172.43,119.64 CPU1.A37 173.24,119.9 v2(173.24,120.3) ; CPU1.AE6 156,96.5 v2(156.08,96.5) 156.17,96.5 CPU1.AD6 ; CPU1.A4 CPU1.A3 172.41,94.84 CPU1.B3 ; v2(147.3,92.12) 147.3,93.56 147.28,93.57 ; CPU1.BH6 137.22,97.31 CPU1.BH7 ; CPU1.AW3 144.44,94.56 v2(144.32,94.56) ; CPU1.AW3 144.8,94.85 144.8,94.27 CPU1.AW2 144.8,94.2 144.8,93.62 CPU1.AW1 144.62,93.59 144.32,93.88 v2(144.32,93.91) ; UH1.AM27 210.03,26.84 v2(210.28,27.2) ; CPU1.BR38 v2(132.53,120.63) ; v2(172.01,98.3) 172.01,98.23 CPU1.C8 CPU1.D6 ; v2(172.01,98.3) 171.68,98.62 CPU1.C9 171.28,99.09 ; CPU1.E9 170.38,98.62 v2(170.06,98.3) ; CPU1.BJ12 136.58,100.79 v2(136.95,100.42) 137.27,100.75 CPU1.BH12 ; CPU1.Y38 v2(159.75,119.89) CPU1.Y37 ; CPU1.D10 171.28,99.23 171.28,99.09 ; CPU1.BT35 132.24,118.08 v2(131.79,118.53) 132.15,118.9 CPU1.BT36 132.47,118.78 CPU1.BR36 ; CPU1.J7 168.66,97.48 CPU1.G8 CPU1.F8 169.73,97.97 v2(170.06,98.3) ; CPU1.AC4 157.19,95.54 v2(156.88,95.23) ; v2(157.88,176.43) 157.82,176.49 JCDRA.14 ; CPU1.U38 v2(162.11,119.89) CPU1.U37 ; v2(169.41,99.09) 169.73,98.76 CPU1.F9 169.73,98.62 v2(170.06,98.3) ; CPU1.AD9 CPU1.AD10 ; CPU1.AD9 156.39,98.8 v2(156.13,98.53) ; CPU1.AD9 CPU1.AD8 CPU1.AD7 ; CPU1.AD10 156.98,99.82 v2(157.07,99.82) 157.06,99.83 v2(157.06,100.46) ; CPU1.BM29 CPU1.BM28 134.96,113.35 v2(135.28,113.03) 135.28,112.96 CPU1.BM27 ; CPU1.BM29 CPU1.BL29 135.82,114.42 CPU1.BK29 136.66,114.82 CPU1.BJ30 136.52,114.94 v2(136.13,115.33) 136.46,115.66 CPU1.BJ31 ; CPU1.BM29 CPU1.BN29 CPU1.BP29 CPU1.BR29 ; CPU1.T12 CPU1.T13 161.95,101.4 v2(161.65,101.7) 162,102.05 CPU1.T14 ; CPU1.T12 162.26,100.75 v2(162.55,100.46) 162.84,100.75 CPU1.R12 163.27,101.01 163.66,101.01 CPU1.P12 164.18,101.01 164.58,101.01 CPU1.N12 ; CPU1.T12 161.83,101.01 161.58,101.01 161.31,100.75 CPU1.V12 160.92,101.01 160.53,101.01 CPU1.W12 ; v2(172.01,112.51) 171.68,112.83 CPU1.C27 171.28,113.26 171.28,113.4 CPU1.D28 ; CPU1.AA12 158.18,101.01 157.78,101.01 CPU1.AC12 157.35,100.75 v2(157.06,100.46) ; JCDRA.5 v2(154.22,176.45) ; CPU1.N9 CPU1.N10 CPU1.N11 ; 171.28,99.09 CPU1.D9 ; v2(162.95,178.96) 163.56,178.96 163.82,178.7 JCDRA.29 ; v2(149.8,93.04) CPU1.AM1 CPU1.AM2 CPU1.AM3 149.8,95.01 149.82,95.04 149.82,95.38 149.8,95.41 CPU1.AM4 ; CPU1.BH12 137.58,100.75 v2(137.86,100.46) 138.15,100.75 CPU1.BG12 CPU1.BG13 ; UV21.8 199.52,128.61 v2(199.46,128.56) ; CPU1.BD8 140.2,98.15 v2(140.61,98.55) ; CPU1.BD8 CPU1.BD9 ; CPU1.BD8 CPU1.BD7 ; v2(173.62,101.05) CPU1.A12 ; v2(136.13,116.63) 136.45,116.31 CPU1.BJ32 ; CPU1.L33 166.52,116.96 v2(166.84,117.28) 166.51,117.61 CPU1.L34 ; 195.73,34.38 v2(195.73,34.38) 196.17,34.82 UH1.D10 195.84,35.26 UH1.C10 ; CPU1.BN2 134.62,94.24 CPU1.BM2 134.83,94.65 134.83,95.17 CPU1.BM3 134.86,95.43 v2(135.09,95.66) ; PU201.14 92.29,41.77 v2(92.15,41.62) ; CPU1.AU33 146.04,116.96 v2(146.36,116.63) ; PU8200.5 243.93,31.1 v2(243.4,30.58) ; CPU1.K3 167.25,94.89 v2(166.89,94.52) ; CPU1.AY34 143.67,117.61 v2(144,117.28) 143.68,116.96 CPU1.AY33 ; CPU1.J36 168.27,118.66 168.41,118.66 CPU1.H35 168.88,118.26 169.2,118.58 169.26,118.58 CPU1.F36 169.91,119.23 v2(169.99,119.23) 169.96,119.26 169.96,120.08 CPU1.E38 ; JCDRA.11 156.62,175.93 v2(156.51,175.83) ; CPU1.A26 173.41,112.08 v2(173.47,112.02) ; CPU1.P37 v2(164.47,119.89) CPU1.P38 ; v2(141.64,116.63) 141.31,116.96 CPU1.BC33 ; v2(173.73,107.35) CPU1.A20 ; CPU1.N11 CPU1.N12 ; v2(174.06,113.49) 173.9,113.65 CPU1.A28 ; v2(140.61,98.55) 140.36,98.8 CPU1.BD9 ; v2(140.61,98.55) 140.61,97.85 140.25,97.5 CPU1.BD7 ; CPU1.A6 172.98,97.13 172.54,96.69 172.18,96.69 171.82,96.33 CPU1.C5 171.19,95.84 v2(170.85,95.84) ; v2(172.01,113.99) 172.01,114 172,114.12 CPU1.C29 ; CPU1.K38 166.81,120.63 v2(166.77,120.63) ; CPU1.G6 169.04,96.75 169.09,96.69 169.09,96.31 169.04,96.26 CPU1.G5 ; v2(206.8,19.69) UH1.AE42 ; v2(216.87,26.23) 216.78,26.32 UH1.BE28 ; v2(151.88,119.24) 152.2,119.56 CPU1.AJ37 152.27,119.63 152.21,119.7 152.21,120.07 152.27,120.14 CPU1.AJ38 ; CPU1.BG13 138.67,101.05 v2(138.82,101.05) 139.12,100.75 CPU1.BF12 ; CPU1.BG13 CPU1.BG14 ; CPU1.AY14 143.67,102.05 v2(143.35,102.37) ; UH1.AW13 213.56,33.84 v2(213.16,34.24) ; v2(224.87,100.05) UG9.AH10 225.12,99.5 v2(224.82,99.5) ; CPU1.BM5 134.75,96.21 CPU1.BM6 ; CPU1.F13 169.35,101.46 169.35,101.32 CPU1.G12 169.08,100.99 v2(168.76,100.66) ; CPU1.BL35 135.54,118.26 v2(135.3,118.5) 134.96,118.16 CPU1.BM35 ; CPU1.D22 171.28,108.68 171.28,108.54 CPU1.C21 172.01,107.81 v2(172.01,107.69) ; v2(172.01,104.6) 172.01,104.67 CPU1.C17 171.37,105.3 171.37,105.44 CPU1.D18 ; JCDRA.41 v2(168.62,176.37) ; CPU1.AE34 CPU1.AE33 v2(155.81,116.63) ; UH1.B25 195.74,27.37 v2(195.78,27.41) 196.17,27.8 UH1.D24 ; CPU1.AL14 150.99,102.05 v2(150.66,101.72) ; UH1.BE40 216.38,20.22 216.82,20.66 v2(216.82,20.8) ; CPU1.BG38 v2(138.49,120.54) ; CPU1.AG10 154.24,99.82 v2(154.33,99.82) ; UH1.AJ17 208.67,31.7 v2(208.28,31.3) ; CPU1.AG8 CPU1.AG7 ; v2(171.35,115.57) 171.03,115.25 CPU1.D30 ; v2(208.28,31.3) 207.89,31.69 UH1.AH17 ; v2(173.99,110.5) CPU1.A24 ; UH1.AN22 v2(210.33,29.74) ; JCDRA.35 166.22,178.74 v2(165.96,179) 165.41,179 165.02,178.61 JCDRA.32 ; v2(168.76,100.66) 168.43,100.99 CPU1.H12 ; v2(147.94,119.23) 147.61,119.56 CPU1.AR37 ; CPU1.BT26 132.29,111.91 132.04,111.91 131.9,112.05 131.87,112.05 v2(131.76,112.16) ; CPU1.BT9 132.23,99.37 131.52,99.37 131.41,99.26 131.39,99.26 v2(131.28,99.15) ; UH1.BE9 216.85,35.44 v2(216.94,35.52) ; v2(171.78,121.12) 171.5,120.84 171.3,120.84 170.89,120.42 CPU1.D38 ; v2(64.69,14.08) U17.11 ; v2(169.43,94.56) 169.75,94.24 CPU1.F2 ; CPU1.BL38 135.81,120.25 v2(135.47,120.59) 135.1,120.22 CPU1.BM38 ; v2(173.62,104.2) CPU1.A16 ; CPU1.F11 169.41,100.58 v2(169.41,100.65) ; UH1.AL24 v2(209.53,27.41) UH1.AM24 ; v2(167.21,105.78) CPU1.J18 CPU1.H18 168.47,105.69 169,105.69 CPU1.G18 169.08,105.71 v2(169.41,105.39) 169.73,105.06 CPU1.F17 169.41,104.67 v2(169.41,104.59) ; v2(199.61,133.25) 198.92,133.25 198.72,133.46 UV21.41 ; v2(153.41,101.06) 153.1,100.75 CPU1.AH12 ; CPU1.A18 173.45,105.78 v2(173.49,105.82) ; v2(172.01,99.87) 171.68,100.2 CPU1.C11 171.4,100.55 171.4,100.69 CPU1.D12 ; CPU1.AG11 153.97,100.1 v2(154.28,100.42) 154.45,100.42 CPU1.AF12 CPU1.AF13 CPU1.AF14 ; CPU1.AL34 150.63,117.61 v2(150.3,117.28) 150.62,116.96 CPU1.AL33 ; CPU1.AC38 v2(157.39,120.54) ; CPU1.A34 173.08,117.95 v2(173.62,117.95) ; PU8200.10 242.87,33.71 242.67,33.91 242.67,34.31 v2(242.24,34.74) ; JCDRA.8 v2(155.42,176.45) ; CPU1.D14 171.28,102.38 171.28,102.24 CPU1.C13 171.68,101.77 v2(172.01,101.45) ; UV21.33 195.52,133.88 195.24,133.6 v2(195.24,133.25) ; 134.63,105.15 134.31,105.48 CPU1.BN18 CPU1.BP18 CPU1.BR18 CPU1.BT18 v2(131.49,105.55) ; CPU1.BD37 140.53,119.56 v2(140.85,119.89) 140.52,120.21 CPU1.BD38
  BOTTOM w0.229: DT8.2 v2(197.28,174.12) ; DT7.2 v2(194.72,174.12)
  BOTTOM w0.25: UG9.BJ25 235.65,114.47 v2(235.65,114.77) ; UG9.K25 235.77,86.99 ; UG9.AB10 v2(224.97,95.75) ; UG9.BJ27 237.59,114.77 v2(237.75,114.77) ; v2(250.74,99.5) 251.02,99.5 UG9.AH47 ; UG9.AR52 255.78,104.55 v2(255.81,104.58) ; UG9.BL40 246.27,115.4 v2(246.19,115.32) 246.37,115.15 v2(246.37,114.8) 246.27,114.7 UG9.BJ40 UG9.BJ41 ; UG9.BL25 235.77,115.44 v2(235.65,115.32) v2(235.65,114.77) ; v2(240.62,80.3) 240.67,80.35 UG9.A32 ; UG9.AP47 v2(251.47,103.55) ; v2(223.49,113.3) UG9.BG7 UG9.BF6 ; CG277.2 192.4,82.84 192.39,82.83 192.39,82.72 192.23,82.56 v2(192.23,82.1) ; v2(235.65,114.77) 235.49,114.77 UG9.BJ24 ; UG9.AP49 252.72,104 v2(252.98,104) ; UG9.BG19 231.82,112.7 v2(231.82,112.5) ; UG9.BE31 v2(239.67,111.85) ; v2(231.45,114.76) v2(231.45,115.32) 231.57,115.44 UG9.BL19 ; v2(231.45,114.76) 231.44,114.77 231.29,114.77 UG9.BJ18 ; v2(231.45,114.76) 231.45,114.47 UG9.BJ19 ; UG9.BG22 v2(233.97,112.65) ; v2(241.95,114.77) 241.95,114.47 UG9.BJ34 ; v2(241.95,114.77) 241.79,114.77 UG9.BJ33 ; v2(241.95,114.77) 241.95,115.18 242.07,115.3 v2(242.02,115.32) 242.07,115.44 242.07,115.44 UG9.BL34 ; UG9.BE18 v2(231.17,111.25) ; v2(240.27,112.65) UG9.BG31 ; UG9.BE24 v2(235.37,111.25) ; UG9.BJ43 248.07,114.65 v2(247.97,114.65) UG9.BJ42 ; UG9.BL43 248.37,115.3 ; v2(255.12,110.76) 255.31,110.57 255.31,109.88 v2(255.2,109.77) ; UG9.BL37 244.17,115.44 244.16,115.43 v2(244.14,115.31) 244.05,115.21 v2(244.05,114.77) ; v2(237.75,114.77) 237.75,114.47 UG9.BJ28 ; v2(237.75,114.77) 237.75,115.22 237.84,115.31 v2(237.84,115.31) 237.84,115.41 237.87,115.44 UG9.BL28 ; UG9.BG34 v2(242.37,112.65) ; UG9.BF41 v2(246.67,111.95) ; UG9.BE15 v2(229.07,111.25) ; v2(215.07,101.05) 215.07,101.14 214.71,101.5 214.25,101.5 213.93,101.18 v2(213.93,101.04) ; v2(248.95,95.26) 248.56,95.26 UG9.AB43 ; UG9.R52 v2(255.12,90.55) ; UG9.BG42 v2(248.07,113.35) ; UG9.BG40 v2(246.57,112.65) ; v2(250.07,102.05) 249.78,101.75 UG9.AL45 ; UG9.BJ21 233.39,114.77 v2(233.55,114.77) ; v2(248.7,99.35) 248.4,99.65 UG9.AH43 ; UG9.BE37 v2(243.87,111.85) ; UG9.AA8 v2(224.29,95.17) ; UG9.A26 236.47,80.3 v2(236.52,80.25) ; UG9.M52 v2(255.12,88.45) ; UG9.BE22 v2(233.37,111.85) ; UG9.W43 v2(248.67,93.05) 248.68,93.06 v2(249.46,93.06) ; UG9.A29 v2(238.57,80.3) ; UG9.BE16 v2(229.17,111.85) ; UG9.AF1 v2(218.52,98.25) ; UG9.BE34 v2(241.77,111.85) ; UG9.BD29 v2(238.27,110.55) ; v2(233.55,114.77) 233.55,114.47 UG9.BJ22 ; v2(233.55,114.77) v2(233.55,115.32) 233.67,115.44 UG9.BL22 ; v2(244.05,114.77) 244.05,114.47 UG9.BJ37 ; v2(244.05,114.77) 243.89,114.77 UG9.BJ36 ; UG9.BL5 v2(221.47,116.05) ; UG9.BE36 v2(243.77,111.25) ; UG9.V52 v2(255.12,92.65) ; v2(239.85,114.77) 239.85,115.27 v2(239.91,115.33) 239.97,115.39 UG9.BL31 ; v2(239.85,114.77) 239.69,114.77 UG9.BJ30 ; v2(239.85,114.77) 239.85,114.47 UG9.BJ31 ; UG9.BD35 v2(242.47,110.55) ; UG9.BE13 v2(227.07,111.25) ; UG9.AK1 v2(218.52,101.05) ; UG9.BH2 v2(219.37,113.95) ; UG9.BH42 247.92,113.9 v2(248.07,113.93) ; UG9.BE19 v2(231.27,111.85) ; v2(250.07,97.85) 250.07,97.95 UG9.AF45 ; UG9.BE30 v2(239.57,111.25) ; UG9.AP43 248.51,103.71 248.96,103.71 v2(249,103.75) ; UG9.AH49 252.45,99.53 v2(251.99,99.53) ; UG9.AY2 v2(219.08,108.05) ; UG9.BE25 v2(235.46,111.86) ; UG9.BE39 v2(245.87,111.25) ; UG9.BG16 v2(229.77,112.65) ; UG9.BH5 v2(221.47,113.95) ; UG9.BE40 v2(245.97,111.85) ; UG9.BE33 v2(241.67,111.25) ; UG9.BE21 v2(233.27,111.25) ; UG9.BD32 v2(240.37,110.55) ; UG9.BG25 v2(236.07,112.65) ; UG9.BG13 v2(227.67,112.65) ; UG9.BJ16 229.35,114.47 v2(229.35,114.77) 229.47,114.89 UG9.BL16 ; v2(248.74,97.85) 248.67,97.85 UG9.AE43 ; v2(253.47,91.15) 253.57,91.25 UG9.T51 ; UG9.BG37 v2(244.47,112.65) ; UG9.R49 v2(252.87,90.85) ; UG9.BB49 v2(252.27,109.75) ; UG9.BG28 v2(238.17,112.65) ; UG9.BD38 v2(244.57,110.55) ; v2(229.28,83.23) 229.28,83.04 UG9.D16
  BOTTOM w0.254: v2(171.35,115.57) 171.35,115.68 CPU1.C31 ; v2(273.19,20.35) 273.19,21.94 272.87,22.25 JSSD2.9 ; v2(203.64,165.26) 203.64,165.23 203.32,165.23 UT4.L11 ; CPU1.AU8 145.74,98.15 v2(146.13,97.76) ; CH48.2 195.28,43.51 195.66,43.51 196.12,43.97 196.28,44.13 v2(196.28,44.62) v2(196.28,45.5) v2(196.28,46.48) 196.28,47.1 196,47.38 193.98,47.38 v2(193.87,47.48) v2(192.78,47.48) 192.24,47.48 191.88,47.12 v2(191.88,46.65) v2(191.88,45.7) 191.32,45.14 191.32,44.34 192.17,43.49 CH47.2 ; v2(127.07,99.78) 126.99,99.86 126.99,100.36 127.24,100.61 127.42,100.61 127.6,100.43 UZ21.5 ; v2(173.37,119.22) 173.01,118.86 CPU1.A36 ; v2(198.78,15.97) 198.78,15.88 199.03,15.63 RH26.2 ; v2(195.03,42.77) 195.03,41.58 194.64,41.18 v2(194.64,40.23) ; UG9.BC24 235.07,110.03 235.6,109.5 235.72,109.5 ; v2(283.35,87.56) 283.35,87.56 UG1.A1 ; 193.8,38.26 193.8,38.38 193.56,38.62 193.56,38.91 193.53,38.93 193.53,40.57 192.55,41.55 v2(192.55,42.84) ; v2(195.76,31.96) 195.8,31.92 UH1.D16 ; CPU1.AL12 151.23,100.75 v2(151.58,101.1) ; JHDD.6 115.92,9.3 115.6,8.99 114.74,8.99 114.42,9.3 JHDD.3 v2(114.42,11.14) ; JUSBC1.A1 190.1,177.1 v2(190,177.01) ; v2(146.83,93.12) 147.28,93.57 CPU1.AR1 ; CPU1.BJ29 136.58,114.08 CPU1.BK29 ; JSSD2.15 270.78,20.76 v2(270.71,20.68) ; CPU1.BK25 CPU1.BJ25 v2(137.48,111.06) ; CPU1.K9 167.21,99.09 v2(167.08,99.09) 167.44,99.45 CPU1.K10 ; UH1.C1 UH1.D1 ; YL1.2 278.15,164.52 CL11.2 277.75,165.34 v2(277.75,166.02) 277.75,166.58 278.19,167.02 279.76,167.02 v2(279.84,167.1) v2(280.98,167.1) 281.1,167.1 281.2,167 282.18,167 282.49,166.68 v2(282.49,166.12) v2(282.49,163.57) v2(282.49,161.89) 282.49,161.14 v2(282.01,160.66) 281.69,160.34 v2(279.55,160.34) v2(277.8,160.34) 277.15,160.34 276.84,160.04 v2(276.34,160.04) ; v2(213.3,31.11) UH1.AW19 ; v2(186.32,174.5) 186.35,174.53 186.83,174.53 DT4.2 ; v2(167.91,97.76) 167.52,98.15 CPU1.K8 ; v2(167.91,97.76) 167.65,97.5 CPU1.K7 ; v2(167.91,97.76) 168.19,97.48 CPU1.J7 ; v2(151.83,94.58) 151.83,95.13 CPU1.AK4 CPU1.AL4 ; CPU1.G9 169.41,99.02 v2(169.41,99.09) 169.08,99.41 CPU1.G10 ; v2(146.83,95.79) 147.23,96.19 CPU1.AR5 ; CPU1.BP26 CPU1.BR26 CPU1.BT26 ; CPU1.BM21 135.26,107.54 v2(135.26,107.52) ; JSSD2.27 270.78,17.76 270.78,17.75 270.72,17.75 v2(270.71,17.75) ; v2(171.73,94.92) 171.73,94.39 CPU1.C2 ; v2(171.73,94.92) 172.23,94.92 CPU1.B3 ; v2(171.73,94.92) 171.63,94.82 CPU1.D3 ; v2(146.83,94.52) 147.2,94.89 CPU1.AR3 ; CPU1.J10 168.28,99.48 v2(167.97,99.79) 167.81,99.79 CPU1.K11 ; 235.72,109.5 235.72,110.1 UG9.BC25 ; 235.72,109.5 v2(235.77,109.45) ; CPU1.AD6 156.63,96.84 v2(156.96,97.17) ; CPU1.BD12 140.02,100.75 v2(139.69,101.07) 139.37,100.75 CPU1.BF12 ; v2(195.84,24.94) UH1.D31 ; v2(273.02,23.56) 273.02,23.94 272.71,24.25 JSSD2.1 ; v2(270.72,23.45) 271.03,23.76 JSSD2.3 ; CPU1.BE6 139.81,96.84 v2(140.13,96.51) ; v2(270.72,14.7) 270.77,14.76 JSSD2.39 ; v2(270.71,19.18) 270.78,19.25 JSSD2.21 ; v2(170.01,120.74) 170.09,120.66 CPU1.E38 ; v2(154.82,93.04) CPU1.AF1 CPU1.AF2 CPU1.AF3 154.84,94.9 154.84,95.52 CPU1.AF4 155.25,95.97 155.25,96.43 CPU1.AE6 ; v2(156.96,97.17) 156.64,97.5 CPU1.AD7 ; v2(156.96,97.17) 157.3,96.84 CPU1.AC6 ; v2(148.84,99.82) 148.65,99.82 CPU1.AP11 ; U2407.6 187.89,40.24 v2(188.16,39.97) ; CPU1.BM25 v2(135.28,111.45) ; CPU1.L29 166.44,113.83 v2(166.51,113.76) ; UG9.BD24 235.37,110.55 v2(236.17,110.55) UG9.BD26 ; v2(172.9,94.24) 172.98,94.32 CPU1.A3 ; CPU1.BM18 134.63,105.15 ; CPU1.AJ6 CPU1.AJ5 CPU1.AJ4 CPU1.AJ3 CPU1.AJ2 CPU1.AJ1 v2(152.31,93.04) ; v2(116.47,7.53) 117.42,8.48 JHDD.9 ; v2(204.35,18.83) 204.52,19 UH1.AA42 ; CT77.2 183.75,163.1 RT3.2 183.77,163.16 v2(183.25,163.16) ; v2(140.61,99.19) 140.54,99.19 CPU1.BD9 ; CPU1.BK18 CPU1.BJ18 137.34,105.55 v2(137.5,105.39) ; v2(135.09,95.66) 135.09,95.87 CPU1.BM5 134.44,95.69 CPU1.BN4 ; CPU1.AR2 147.25,94.24 v2(146.83,93.82) ; CPU1.BK22 136.36,108.8 136.72,108.8 136.82,108.7 CPU1.BJ22 137.41,108.7 v2(137.47,108.75) ; CPU1.T3 162.07,94.58 v2(161.91,94.58) ; v2(169.41,114.05) 169.73,114.37 CPU1.F29 ; CPU1.AG7 153.86,96.96 CPU1.AG6 ; v2(125.98,157.23) 126.03,157.18 UM8.25 ; CPU1.BN14 CPU1.BP14 133.66,102.47 v2(133.33,102.79) 133.01,102.47 CPU1.BR14 CPU1.BT14 ; v2(197.38,166.26) 197.89,165.75 197.89,165.33 UT4.L1 ; UG9.AV45 v2(249.35,106.23) v2(248.83,105.71) ; v2(131.75,94.69) 131.83,94.77 132.25,94.77 CPU1.BT3 ; CPU1.F3 169.75,94.89 v2(169.43,94.56) ; JHDD.18 v2(121.92,8.92) ; v2(171.38,116.4) 171.03,116.75 CPU1.D33 ; v2(120.64,10.89) 120.42,10.67 JHDD.15 120.42,8.94 120.21,8.73 119.39,8.73 118.92,9.2 JHDD.12 ; CPU1.BG14 138.18,102.05 v2(137.86,101.73) 137.54,102.05 CPU1.BH14 ; v2(143.35,99.82) 143.27,99.82 CPU1.BA10 ; 240.22,85.9 v2(240.22,86.1) ; v2(197.67,159.64) 198.09,160.07 UT4.A1 ; v2(15.51,51.63) UU7.12 ; v2(169.4,109.31) 169.08,109 CPU1.G22 168.98,108.83 168.48,108.83 CPU1.H22 168.23,108.78 167.88,108.78 CPU1.J22 ; v2(149.4,95.86) 149.44,95.86 149.76,95.54 CPU1.AM4 ; CPU1.BA11 143.25,100.46 v2(143.35,100.46) ; JSSD2.57 272.7,10.25 272.96,10 v2(272.96,9.56) ; DT5.2 188.48,174.72 v2(188.48,175.29) ; v2(270.71,16.44) 270.89,16.25 JSSD2.33 ; CPU1.BT24 CPU1.BR24 133.1,110.36 133.53,110.36 133.62,110.27 CPU1.BP24 133.75,110.27 133.8,110.32 134.26,110.32 CPU1.BN24 ; CPU1.BC14 CPU1.BC13 ; v2(189.11,175.84) DT2.2 ; CPU1.E35 170,118.64 169.86,118.64 CPU1.F36 ; DT3.2 v2(191.65,175.84)
  BOTTOM w0.3: UG9.AG44 249.07,98.98 v2(248.7,99.35) ; UG9.AL51 253.63,101.75 v2(253.5,101.88) ; v2(250.12,95.71) 250.03,95.71 UG9.AB45 ; v2(253.42,95.3) 253.57,95.45 UG9.AB51 ; v2(251.57,90.95) 251.47,90.95 UG9.T47 ; v2(231.84,86.66) 231.96,86.66 UG9.J20 ; v2(254.41,109.91) 254.21,109.91 UG9.BC51 ; UG9.AE51 253.57,97.55 v2(253.42,97.4) ; UG9.AH2 219.95,99.65 ; UG9.N51 253.49,89.15 v2(253.46,89.12) ; v2(253.52,103.9) 253.92,103.9 UG9.AP51 ; UG9.AY47 v2(250.87,107.75) ; UG9.B48 v2(252.17,81.15) ; UG9.J17 230.02,86.5 v2(229.67,86.5) ; v2(255.15,105.25) UG9.AT52 UG9.AT51 ; UG9.AD44 v2(248.77,97.15) ; v2(250.13,91.58) 250.1,91.58 UG9.T45 ; v2(219.12,80.2) UG9.A2 ; v2(252.01,95.64) 252.01,95.63 v2(251.52,95.13) 251.2,95.45 UG9.AB47 ; UG9.AE45 v2(250.07,97.85) ; v2(251.57,88.97) 251.35,88.97 UG9.N47 ; v2(255.12,110.76) 255.03,110.85 UG9.BD52 ; UG9.AJ9 v2(224.87,100.05) ; v2(253.46,93.18) 253.63,93.35 UG9.W51 ; UG9.A3 v2(220.37,80.15) ; UG9.AK44 v2(248.77,101.35) ; UG9.J1 v2(218.52,86.35) ; UG9.AU51 253.42,105.95 v2(253.34,105.88) ; UG9.AH45 v2(250.07,99.95) ; UG9.AB6 v2(222.17,95.75) ; UG9.AH51 253.42,99.65 v2(253.34,99.56) ; UG9.AW46 v2(250.17,107.65)
  BOTTOM w0.305: JDIMM2.181 158.69,48.04 v2(158.19,48.54) ; UG7.L5 v2(201.03,97.25) 201.43,96.85 UG7.M5 ; JDIMM2.196 162.44,38.08 162.07,37.7 v2(162.07,37.71) 162.06,37.7 161.9,37.7 161.44,38.16 JDIMM2.192 ; v2(199.94,100.83) 199.83,100.71 199.83,100.05 UG7.K1 ; UG3.C1 250.39,54.11 v2(249.99,53.71) v2(249.39,53.71) ; UG1.M5 274.38,90.13 v2(274.55,89.96) UG1.L5 ; UG2.R4 v2(281.75,114.56) UG2.R3 v2(281.75,115.36) ; JDIMM2.39 121.2,47.2 121.2,48.33 v2(121.04,48.48) 121.03,48.47 120.47,48.47 120.2,48.19 120.2,47.2 JDIMM2.35 ; JDIMM2.180 158.44,38.07 v2(158.8,37.71) ; UG4.E1 v2(272.95,81.96) ; v2(283.35,86.16) v2(283.35,86.76) UG1.A1 282.95,87.16 v2(282.55,87.56) ; UG1.C11 v2(281.75,95.56) UG1.C12 ; UG1.C11 v2(281.75,94.76) UG1.B10 v2(282.55,93.96) ; UG1.C11 v2(280.95,94.76) UG1.D10 ; 115.57,50.54 115.94,50.91 JDIMM1.18 ; 115.57,50.54 v2(115.57,50.52) ; 115.57,50.54 115.37,50.54 114.94,50.97 JDIMM1.14 ; UG1.E12 v2(280.15,96.36) ; v2(314.14,34.77) 314.32,34.59 JWLAN.49 ; v2(283.35,116.96) UG2.U1 ; v2(283.35,116.96) v2(283.35,117.61) 284.06,118.32 CG103.2 ; v2(283.35,116.96) 284.07,116.96 284.23,117.13 CG97.2 ; v2(316.74,34.77) 316.28,34.77 315.82,34.31 JWLAN.55 ; PU6100.23 251.59,149.13 v2(251.53,149.07) ; v2(273.75,115.36) 273.56,115.17 UG2.E3 ; v2(224.6,58.47) 224.63,58.47 UG5.H13 ; UG5.G10 222.04,56.76 v2(222.04,56.51) UG5.F10 v2(222.99,56.11) ; JDIMM1.89 133.69,60.97 134,61.28 v2(134.41,61.28) 134.56,61.28 134.69,61.14 JDIMM1.93 ; JDIMM2.102 136.94,37.87 v2(136.78,37.71) ; UG6.R12 235.99,54.11 v2(235.59,53.71) ; CG122.2 269.62,70.03 v2(270.15,70.56) 270.15,70.56 UG4.A14 ; v2(215.79,64.11) 215.39,63.71 UG5.R1 v2(214.99,64.11) ; v2(270.55,81.16) UG4.A1 v2(269.75,81.96) ; v2(204.23,71.05) 203.83,70.65 UG8.C1 v2(204.23,70.25) ; UG6.N12 v2(235.59,55.31) ; UG1.G5 v2(278.55,90.76) UG1.F5 v2(279.35,89.96) ; v2(125.36,37.69) 125.45,37.77 JDIMM2.56 ; CG315.2 264.77,59.48 RG123.2 CG114.2 262.74,59.83 v2(262.74,60.11) 262.68,60.17 261.76,60.17 261.3,59.71 UG3.K14 260.79,59.71 v2(260.39,60.11) UG3.K13 ; v2(308.47,34.73) 308.32,34.59 JWLAN.25 ; CG98.2 281.75,104.24 v2(281.75,105.11) v2(281.75,105.76) UG2.R14 v2(281.74,106.55) ; v2(280.95,81.16) UG4.R1 ; UG4.R1 v2(281.75,81.96) v2(281.75,82.61) 281.96,82.82 CG118.2 ; UG4.R1 v2(281.75,81.16) ; PU6101.23 237.81,149.06 v2(237.75,149) ; UG3.T10 v2(257.99,64.91) ; UG5.N1 v2(214.99,62.51) ; v2(250.79,64.11) 250.39,63.71 UG3.R1 v2(249.99,64.11) ; CG172.2 233.3,65.7 233.3,65.71 v2(233.79,65.71) 234.19,65.31 UG6.A14 ; v2(112.13,50.35) 111.94,50.53 JDIMM1.2 ; v2(154.32,101.76) 154.61,102.05 CPU1.AF14 ; UG3.U14 v2(261.19,65.71) 262.37,66.9 CG279.2 ; 194.23,92.05 v2(193.83,92.45) 193.43,92.85 UG7.B10 v2(193.03,93.25) ; 194.23,92.05 v2(194.63,92.45) UG7.D10 ; 194.23,92.05 UG7.C11 v2(193.83,91.65) UG7.C12 194.23,91.25 v2(194.63,90.85) ; UG4.R12 v2(280.95,72.36) ; JDIMM1.72 129.44,50.82 129.14,50.51 v2(129.03,50.51) ; UG6.K2 UG6.K1 245.39,58.11 v2(245.44,58.06) ; v2(122.94,48.52) 123.2,48.27 123.2,47.2 JDIMM2.47 ; JDIMM1.243 174.19,58.88 173.78,58.47 v2(173.17,58.47) 173.19,58.5 JDIMM1.239 ; v2(225.39,56.11) UG5.E14 225.79,55.71 v2(225.39,55.31) ; v2(222.97,55.31) 222.59,54.92 UG5.D10 ; v2(327.05,44.61) JSSD1.15 ; CG207.2 205.89,88.71 205.83,88.77 v2(205.83,89.25) UG7.U14 ; v2(193.03,78.25) UG8.T10 ; UG8.T10 193.43,77.85 v2(193.83,78.25) UG8.R11 ; UG8.T10 v2(193.03,77.45) ; UG9.BE28 237.83,111.55 237.51,111.88 v2(237.51,111.89) ; v2(282.55,90.76) UG1.B5 v2(281.75,89.96) UG1.C4 v2(281.75,89.16) UG1.C3 ; UG4.U1 282.95,81.65 v2(283.27,81.96) v2(283.27,82.61) ; v2(271.35,97.16) 271.75,97.56 UG1.R14 v2(271.35,97.96) 271.35,98.44 271.52,98.62 CG83.2 ; v2(301.63,34.72) 301.82,34.53 JWLAN.7 ; v2(196.23,78.25) UG8.M10 v2(197.03,77.45) UG8.L10 ; v2(280.15,88.36) UG1.E3 v2(280.15,89.16) ; v2(269.75,115.36) UG2.A3 270.15,114.96 v2(270.55,115.36) ; JWLAN.61 v2(317.32,34.76) ; v2(121.14,61.58) 121.19,61.53 JDIMM1.39 ; UG7.H13 UG7.H14 198.23,89.05 v2(198.18,89) ; v2(282.55,108.96) UG2.T10 ; UG2.T10 v2(282.55,109.76) ; UG2.T10 v2(281.75,108.96) UG2.R11 ; 223.39,54.11 v2(222.99,54.51) UG5.D10 ; 223.39,54.11 v2(222.99,53.71) UG5.B10 222.59,53.31 v2(222.19,52.91) ; 223.39,54.11 UG5.C11 ; UG3.M5 v2(253.19,60.91) UG3.L5 ; JDIMM2.26 117.94,38.13 v2(117.52,37.71) 117.31,37.71 116.94,38.07 JDIMM2.22 ; v2(132.24,49.27) 132.69,48.81 JDIMM2.85 ; UG4.H13 275.75,71.96 v2(275.35,71.56) 275.75,71.16 UG4.H14 275.75,70.86 v2(275.46,70.57) 275.46,69.55 v2(275.6,69.41) ; v2(283.35,89.16) UG1.A3 v2(282.55,89.16) ; v2(196.23,74.25) UG8.M5 v2(197.03,74.25) UG8.L5 v2(197.03,73.45) ; v2(193.03,98.05) UG7.A3 192.63,98.45 v2(192.23,98.05) ; v2(129.03,49.9) 128.88,49.9 128.44,50.33 JDIMM1.68 ; UG5.A1 215.39,52.51 v2(215.79,52.11) ; UG5.A1 v2(214.99,52.11) ; UG5.A1 215.39,52.51 v2(215.79,52.91) ; UG7.K2 199.63,99.05 v2(199.43,98.85) ; v2(279.35,112.96) 279.11,113.2 279.11,113.21 UG2.M5 ; v2(234.79,62.51) 234.39,62.11 UG6.E14 234.21,62.11 v2(233.81,62.51) ; CG160.2 234.25,51.03 v2(233.97,51.31) ; v2(249.84,58.01) 250.19,58.11 UG3.H1 UG3.H2 ; UG2.A1 269.96,116.75 v2(269.75,116.96) ; v2(129.56,40.8) 129.45,40.69 JDIMM2.72 ; JDIMM2.193 161.69,48.35 v2(161.62,48.43) ; v2(280.95,116.16) UG2.R1 v2(281.75,116.96) v2(281.75,117.61) 282.28,118.14 CG101.2 ; UG2.B5 v2(270.55,113.76) ; JDIMM1.65 127.69,61.16 127.82,61.29 v2(127.94,61.29) ; JDIMM1.202 163.94,50.5 v2(164.07,50.38) 164.07,50.38 164.69,50.38 164.94,50.64 JDIMM1.206 ; v2(195.43,72.65) UG8.N3 v2(195.43,71.85) ; UG1.L10 v2(274.55,94.76) UG1.M10 ; v2(270.55,87.56) UG1.U1 v2(269.75,86.76) ; JDIMM2.78 130.94,38.07 130.69,37.81 v2(130.18,37.81) ; 160.32,37.7 160.32,37.7 159.74,37.7 159.44,38 JDIMM2.184 ; 160.32,37.7 160.44,37.83 JDIMM2.188 ; 160.32,37.7 v2(160.32,37.71) ; CG120.2 280.31,69.47 280.15,69.63 v2(280.15,70.11) v2(280.15,70.76) UG4.N14 v2(279.35,71.56) ; v2(205.03,97.25) 204.86,97.09 204.86,97.09 UG7.T5 ; v2(194.63,79.85) 194.23,79.45 UG8.R12 ; 253.99,56.91 253.99,56.98 253.66,57.31 UG3.G5 ; 253.99,56.91 UG3.F5 v2(253.19,56.11) ; 253.99,56.91 v2(254.01,56.91) ; UG3.N14 v2(261.19,62.51) 261.76,63.09 CG280.2 ; v2(138.44,37.75) 138.18,37.75 137.94,37.99 JDIMM2.106 ; v2(257.99,61.71) UG3.M10 v2(257.99,60.91) UG3.L10 ; v2(283.47,12.35) 283.88,11.94 JEC.8 ; v2(251.59,63.31) UG3.R3 251.99,63.71 v2(252.39,64.11) UG3.R4 ; JDIMM1.48 123.44,52.95 123.51,53.02 123.51,54.24 123.12,54.63 v2(122.95,54.63) 122.57,54.63 122.31,54.36 122.31,53.02 122.44,52.88 JDIMM1.44 ; JSSD1.51 324.76,35.61 324.72,35.65 v2(324.71,35.65) ; v2(234.79,52.91) 234.39,52.51 ; 234.39,52.51 UG6.U14 ; 234.39,52.51 v2(233.99,52.11) 233.74,52.11 232.86,52.99 231.78,52.99 ; UG5.M5 v2(218.19,60.91) UG5.L5 ; UG4.F5 v2(274.55,78.76) UG4.G5 ; JSSD3.57 240.02,12.05 240.36,11.72 241.22,11.72 241.53,12.02 JSSD3.51 241.53,13.85 241.84,14.17 ; JDIMM2.107 138.19,48.19 137.86,48.52 v2(137.42,48.52) 137.19,48.3 JDIMM2.103 ; CG274.2 193.89,69.04 193.83,69.1 v2(193.83,69.6) v2(193.83,70.25) UG8.R1 v2(194.63,71.05) ; v2(277.82,85.06) 277.57,84.8 CG82.2 ; v2(206.43,71.85) v2(205.83,71.85) 205.43,72.25 UG8.A3 v2(205.03,71.85) ; v2(279.35,73.96) 279.16,74.15 UG4.M10 v2(278.55,74.76) UG4.L10 ; JDIMM1.222 168.94,50.93 v2(169.46,50.42) ; UG7.C4 v2(193.83,97.25) 193.43,96.85 UG7.B5 193.43,96.85 v2(193.03,96.45) ; v2(276.15,115.36) 275.94,115.57 UG2.H2 ; v2(205.43,81.65) v2(206.08,81.65) ; v2(205.43,81.65) 205.43,82.67 206.14,83.38 CG208.2 ; v2(205.43,81.65) 205.42,81.64 205.42,81.05 ; v2(243.59,55.31) UG6.N3 243.19,55.71 v2(242.79,55.31) ; UG2.H1 275.78,116.75 v2(275.55,117.21) ; JSSD3.45 243.02,11.11 242.8,10.88 v2(242.8,10.86) ; v2(280.14,94.76) 280.54,94.36 UG1.D10 ; v2(205.03,92.45) 204.63,92.85 UG7.T10 ; PU6201.23 210.51,149 v2(210.51,149) ; JDIMM1.231 171.19,61.04 v2(171.41,61.26) 171.44,61.29 172.05,61.29 172.19,61.15 JDIMM1.235 ; v2(198.63,79.85) UG8.K13 UG8.K14 v2(197.83,81.45) ; UG8.N1 v2(195.43,70.25) v2(195.43,69.6) 195.43,69.1 195.45,69.07 CG285.2 ; v2(280.15,79.56) UG4.N3 v2(280.15,80.36) ; JDIMM1.5 112.69,58.48 v2(112.68,58.46) ; JSSD2.73 272.8,6.26 v2(273.12,6.57) 272.94,6.76 JSSD2.71 ; UG6.N14 234.39,55.71 v2(233.99,55.31) ; UG1.P10 v2(272.15,94.76) 271.75,95.16 UG1.R11 v2(271.35,95.56) 271.75,95.96 UG1.R12 271.75,95.96 v2(272.15,96.36) ; v2(204.23,90.05) 203.83,89.65 UG7.R14 ; v2(199.98,82.8) v2(199.98,81.65) 199.83,81.5 UG8.H14 v2(200.23,80.65) UG8.H13 ; v2(251.59,55.31) UG3.E3 251.99,55.71 v2(252.39,55.31) ; JDIMM1.56 125.44,50.44 124.83,49.82 v2(124.72,49.82) ; JDIMM1.99 136.19,61.51 136.72,62.04 v2(137.99,62.04) ; v2(276.95,96.36) UG1.H13 v2(277.75,97.16) UG1.H14 277.35,98.06 v2(277.55,98.26) 277.75,98.46 CG84.2 ; JDIMM1.60 126.44,50.6 v2(126.6,50.45) 127.08,50.45 127.44,50.81 JDIMM1.64 ; UG6.F5 v2(241.99,60.91) UG6.G5 ; v2(203.43,80.65) UG8.C14 203.83,81.65 v2(203.83,81.65) 203.86,81.68 203.86,82.58 ; v2(280.95,87.56) 281.35,87.16 UG1.C1 v2(281.75,86.76) v2(281.75,86.16) 282.14,85.77 CG80.2 ; 237.43,61.47 237.59,61.31 v2(237.19,60.91) UG6.G10 ; 237.43,61.47 v2(237.19,61.71) ; 237.43,61.47 UG6.F10 ; v2(305.19,42.26) 304.95,42.26 304.57,41.88 JWLAN.18 ; v2(201.83,92.45) UG7.M10 201.43,92.85 v2(201.03,92.45) UG7.L10 ; UG7.E3 195.83,98.45 v2(196.23,98.85) ; UG7.E3 v2(195.43,98.05) ; UG7.E3 v2(195.43,98.85) ; JDIMM2.167 155.2,48.41 155.33,48.55 v2(155.65,48.55) 155.89,48.55 156.2,48.24 JDIMM2.171 ; CG224.2 283.66,69.25 283.35,69.56 v2(283.35,70.11) v2(283.35,70.76) UG4.U14 ; JDIMM1.40 121.44,53.96 120.77,54.63 v2(120.59,54.63) ; v2(195.03,93.4) 195.03,93.4 UG7.D10 ; UG5.K1 214.99,59.71 v2(214.84,59.86) ; v2(237.99,52.91) 237.59,53.31 UG6.T10 ; JDIMM2.247 175.19,48.33 v2(175.39,48.52) ; v2(276.95,107.36) UG2.K13 v2(277.75,106.56) UG2.K14 277.6,105.91 v2(277.6,105.51) 277.6,104.53 277.45,104.39 CG79.2 ; v2(217.39,52.11) 216.99,52.51 UG5.A3 ; UG7.E12 v2(195.43,91.65) ; v2(277.81,119.48) CG86.2 ; UG5.H2 UG5.H1 215.17,58.11 v2(214.84,58.01) ; QG2.3 283.39,100.14 283.39,98.81 v2(282.55,97.96) UG1.A14 v2(282.55,97.16) ; JDIMM2.10 113.94,39.89 113.88,39.96 v2(113.88,40.74) ; UG4.R4 v2(281.75,79.56) UG4.R3 v2(281.75,80.36) ; JDIMM2.82 131.94,38.14 132.34,37.75 v2(132.66,37.75) 132.68,37.75 132.94,38.02 JDIMM2.86 ; UG8.B10 v2(205.03,78.25) ; JDIMM1.223 169.19,61.17 169.32,61.3 v2(169.86,61.3) 170.19,60.97 JDIMM1.227 ; UG7.K13 v2(200.23,90.05) 199.83,89.65 UG7.K14 199.83,89.2 v2(200.03,89) ; JDIMM1.176 157.44,50.77 v2(157.19,50.51) 156.79,50.51 156.44,50.85 JDIMM1.172 ; JDIMM1.90 133.94,50.56 v2(134.12,50.39) 134.6,50.39 134.94,50.74 JDIMM1.94 ; UG4.N12 v2(280.15,72.36) ; v2(202.63,80.65) UG8.E14 v2(202.23,81.65) ; JDIMM2.234 171.94,38.05 171.6,37.71 v2(171.38,37.71) 171.21,37.71 170.94,37.98 JDIMM2.230 ; v2(216.59,53.71) UG5.C3 v2(216.59,54.51) ; v2(135.26,40.93) 135.39,40.93 135.94,40.37 JDIMM2.98 ; UG1.G10 278.15,94.21 v2(278.55,93.81) 278.95,94.21 UG1.F10 v2(279.35,94.76) ; JDIMM1.77 130.69,61.59 130.3,61.99 v2(130.07,61.99) 129.65,61.99 129.49,61.82 129.49,61.12 129.69,60.92 JDIMM1.73 ; JDIMM1.107 138.19,61.15 v2(137.99,61.35) 137.56,61.35 137.19,60.99 JDIMM1.103 ; UG5.C12 224.19,54.11 v2(223.79,53.71) ; JDIMM1.9 113.69,60.85 v2(114.11,61.27) ; JDIMM1.98 135.94,50.71 136.02,50.64 v2(136.02,50.48) ; CG104.2 280.31,85.4 280.15,85.56 v2(280.15,86.16) v2(280.15,86.76) UG1.E1 v2(279.35,87.56) ; JDIMM2.57 125.69,48.18 125.39,48.49 v2(124.79,48.49) 124.43,48.49 124.2,48.25 124.2,47.2 JDIMM2.51 ; JDIMM2.238 172.94,38.02 v2(173.25,37.72) ; v2(167.39,62.33) 166.69,61.63 ; 166.69,61.63 166.32,61.26 165.91,61.26 165.69,61.04 JDIMM1.209 ; 166.69,61.63 JDIMM1.213 ; v2(132.64,62.03) 132.16,62.03 131.69,61.56 JDIMM1.81 ; 227.15,63.93 226.37,63.93 v2(226.19,64.11) UG5.R14 225.79,63.71 v2(225.39,64.11) ; v2(273.12,5.76) JSSD2.75 ; CG203.2 195.26,82.81 195.43,82.64 v2(195.43,82.1) v2(195.43,81.45) UG8.N14 ; v2(192.23,82.1) v2(192.23,81.45) UG8.U14 ; v2(206.43,98.85) v2(205.83,98.85) 205.56,98.59 UG7.U3 ; UG8.G10 v2(201.03,78.25) 201.43,77.85 UG8.F10 ; v2(167.53,48.4) 167.69,48.24 JDIMM2.217 ; v2(257.99,56.11) UG3.F10 257.44,56.51 v2(257.04,56.91) 257.44,57.31 UG3.G10 ; v2(275.6,82.11) 275.78,81.75 UG4.H1 ; v2(300.32,34.72) JWLAN.1 ; v2(270.55,108.96) 270.77,109.19 270.77,109.19 UG2.B10 ; JDIMM2.218 167.94,37.76 v2(167.9,37.72) ; JSSD1.3 326.89,47.61 v2(327.16,47.88) 326.94,48.11 JSSD1.1 ; UG4.N1 v2(280.15,81.96) v2(280.15,82.61) 280.15,83.12 280.18,83.15 CG119.2 ; JDIMM2.89 133.69,48.31 134,48.61 v2(134.09,48.61) 134.5,48.61 134.69,48.42 JDIMM2.93 ; UG1.T10 v2(270.55,94.76) ; UG2.A14 270.15,106.16 v2(270.15,105.56) v2(270.15,104.91) 269.93,104.7 CG102.2 ; JDIMM1.181 158.69,61.9 v2(158.84,62.05) 159.12,62.05 159.69,61.48 JDIMM1.185 ; UG6.N1 v2(245.19,55.31) ; UG6.B10 v2(237.19,64.91) ; JDIMM2.14 114.94,38.14 115.37,37.72 v2(115.58,37.72) 115.94,38.09 JDIMM2.18 ; CG209.2 203.2,88.68 v2(202.63,89.25) UG7.N14 ; UG9.BE27 v2(237.47,111.25) ; CG87.2 269.74,98.45 269.75,98.44 v2(269.75,97.96) UG1.U14 ; UG6.C4 v2(242.79,63.31) UG6.C3 v2(243.59,63.31) ; UG7.E1 v2(195.43,99.65) ; UG3.P10 v2(257.99,63.31) UG3.R11 v2(258.79,64.11) 259.19,63.71 UG3.R12 v2(259.59,63.31) ; JSSD1.57 324.78,34.11 v2(324.71,34.17) ; UG5.G5 218.71,57.31 v2(219.11,56.91) 218.99,56.91 UG5.F5 v2(218.19,56.11) ; JDIMM2.251 176.19,48.67 175.71,49.16 v2(175.39,49.16) ; JDIMM2.61 126.69,48.39 v2(126.58,48.5) 127.41,48.5 127.69,48.22 JDIMM2.65 ; UG8.D10 v2(203.43,78.25) UG8.C11 ; UG1.N1 273.17,86.98 v2(272.95,86.76) ; UG2.U14 v2(283.35,105.76) v2(283.35,105.11) ; v2(223.19,51.31) 223.33,51.18 CG286.2 ; v2(244.39,54.51) UG6.R1 v2(245.19,53.71) ; v2(173.26,49.74) 173.26,49.75 174.44,50.93 JDIMM1.244 ; UG3.N1 v2(249.99,62.51) ; JDIMM1.57 125.69,61.42 126.18,61.91 v2(126.69,61.91) ; v2(193.03,79.85) 192.63,79.45 UG8.U12 v2(192.23,79.85) ; v2(280.15,105.11) v2(280.15,105.76) UG2.N14 280.15,106.56 v2(280.15,106.56) ; UG7.R12 203.83,91.25 v2(203.43,90.85) ; UG3.E1 v2(249.99,55.31) v2(249.39,55.31) 248.77,55.31 248.61,55.47 CG134.2 ; JDIMM2.222 168.95,39 168.95,38.14 169.23,37.86 v2(169.23,37.71) ; v2(245.44,59.91) 245.25,59.91 245.12,59.78 245.12,59.78 245.04,59.71 UG6.H1 ; UG5.T5 v2(218.19,64.91) ; JDIMM1.52 124.44,53.26 v2(124.79,53.61) ; v2(205.03,90.85) 205.43,91.25 UG7.U12 205.43,91.25 v2(205.83,90.85) v2(206.43,90.85) ; JDIMM2.248 175.44,37.99 v2(175.73,37.7) 176.06,37.7 176.44,38.08 JDIMM2.252 ; UG1.R3 v2(271.35,89.16) 271.75,89.56 UG1.R4 ; JDIMM1.247 175.19,61.66 175.61,62.07 v2(176.03,62.07) ; UG6.H2 v2(243.59,59.31) ; UG6.T10 v2(237.19,52.91) ; UG6.T10 237.19,53.71 v2(237.19,53.71) 236.79,54.11 UG6.R11 ; 248.37,115.3 248.37,115.05 v2(247.97,114.65) ; v2(275.35,97.96) UG1.K14 v2(275.35,97.16) UG1.K13 ; v2(241.19,56.11) 241.59,56.51 UG6.M5 v2(241.99,56.91) UG6.L5 241.51,57.31 v2(241.11,56.91) ; JDIMM1.43 122.19,61.04 122.95,61.79 v2(123.38,61.79) ; UG2.G10 v2(274.55,108.96) UG2.F10 v2(273.75,108.96) ; v2(193.03,99.65) UG7.A1 ; UG7.A1 v2(192.23,100.45) ; UG7.A1 192.63,100.05 v2(192.23,99.65) ; UG1.D10 v2(280.55,93.81) ; UG3.K1 249.99,59.71 v2(249.84,59.86) ; v2(193.83,80.65) 194.23,81.05 UG8.R14 v2(193.83,81.45) v2(193.83,82.1) ; UG4.H2 v2(276.15,80.36) ; UG3.A1 v2(249.99,52.11) v2(249.39,52.11) 248.88,52.11 248.77,52.22 CG136.2 ; v2(234.79,54.51) UG6.R14 234.39,54.11 v2(233.99,53.71) ; UG2.A12 269.97,107.58 v2(269.75,107.36) ; JDIMM1.26 117.94,50.91 117.87,50.84 117.54,50.51 117.52,50.51 v2(117.52,50.51) 117.32,50.51 116.94,50.88 JDIMM1.22 ; UG5.K13 v2(225.39,60.11) 225.79,59.71 UG5.K14 226.37,59.71 226.77,60.11 v2(227.74,60.11) ; JDIMM1.248 175.44,50.46 v2(175.42,50.44) 176.08,50.44 176.44,50.8 JDIMM1.252 ; UG5.U3 v2(216.59,65.71) v2(216.59,66.31) ; JSSD2.51 272.84,11.76 273.06,11.97 273.06,12.86 272.66,13.25 JSSD2.45 v2(270.71,13.25) ; JDIMM1.189 160.69,61.12 160.91,61.33 161.68,61.33 161.69,61.32 v2(161.74,61.32) 161.69,61.27 JDIMM1.193 ; v2(327.89,38.36) 327.61,38.64 326.91,38.64 326.87,38.61 JSSD1.39 ; JDIMM2.31 119.19,43.57 v2(119.04,43.42) ; UG7.D10 195.04,92.85 v2(195.44,92.45) ; UG4.T10 v2(282.55,74.76) ; UG4.T10 v2(282.55,73.96) ; UG4.T10 v2(281.75,73.96) UG4.R11 ; v2(278.55,77.96) UG4.L5 v2(278.55,78.76) UG4.M5 v2(279.35,77.96) ; JTP.6 194.32,10.19 v2(194.06,9.94) 193.82,10.18 JTP.7 ; UG7.E14 195.63,89.46 v2(195.43,89.25) ; UG6.C12 235.99,63.71 v2(236.39,64.11) UG6.C11 UG6.D10 ; JDIMM1.30 118.94,50.79 119.24,50.5 v2(119.64,50.5) 119.98,50.5 120.44,50.96 JDIMM1.36 ; JDIMM1.238 172.94,50.82 v2(173.28,50.49) ; v2(214.39,53.71) v2(214.99,53.71) UG5.C1 215.39,54.11 v2(215.79,53.71) ; v2(216.59,62.51) UG5.N3 ; UG5.U14 v2(226.19,65.71) ; UG8.A14 205.42,81.05 ; 205.42,81.05 v2(205.04,80.67) ; UG7.N12 202.23,91.25 v2(201.83,90.85) ; UG7.A14 v2(192.23,89.25) ; JDIMM2.52 124.45,40.85 v2(124.66,41.06) ; UG5.D10 v2(222.04,54.91) ; v2(276.95,72.36) 277.35,71.96 UG4.K13 UG4.K14 277.35,70.76 v2(277.6,70.51) 277.6,70.03 277.26,69.69 CG113.2 ; JDIMM2.2 111.94,38.06 112.34,37.67 112.65,37.67 112.94,37.96 JDIMM2.6 112.94,41.44 112.17,42.22 v2(112.06,42.22) ; v2(223.79,52.11) 224.19,52.51 UG5.A12 ; v2(253.53,14.51) JSSD3.3 ; v2(224.59,55.31) UG5.E12 ; v2(269.15,96.36) v2(269.75,96.36) 269.94,96.17 269.94,96.17 UG1.U12 ; v2(249.99,56.11) v2(249.39,56.11) 248.88,56.11 248.84,56.15 248.83,56.15 248.64,56.34 CG126.2 ; UG5.T10 v2(222.99,64.91) ; v2(198.18,70) 198.23,70.05 UG8.K1 UG8.K2 ; v2(280.95,107.36) 281.19,107.6 UG2.R12 ; v2(161.63,49.01) 162.24,49.01 162.69,48.56 JDIMM2.197 ; v2(259.59,52.91) 259.19,52.51 UG3.A12 259.19,52.51 v2(258.79,52.11) ; JDIMM2.201 163.69,48.09 v2(164.05,48.44) 164.39,48.44 164.69,48.13 JDIMM2.205 ; JDIMM2.60 126.45,38 126.63,37.81 v2(126.63,37.71) 127.11,37.71 127.45,38.04 JDIMM2.64 ; JDIMM2.69 128.69,48.29 129.03,48.62 v2(129.03,48.86) ; JDIMM2.231 171.19,48.24 171.44,48.49 v2(171.71,48.49) 171.93,48.49 172.19,48.23 JDIMM2.235 ; JDIMM2.175 157.2,48.61 156.64,49.17 v2(155.65,49.17) ; JDIMM2.19 116.2,47.2 116.2,48.41 v2(116.13,48.47) 115.53,48.47 115.19,48.14 JDIMM2.15 ; v2(277.4,117.21) 277.35,117.16 UG2.K1 UG2.K2 ; v2(327.16,30.45) 327,30.61 JSSD1.71 ; UG7.C3 v2(193.83,98.85) ; JDIMM1.168 155.44,53.48 155,53.93 153.55,53.93 v2(153.48,53.99) ; JDIMM2.185 159.69,48.22 160.21,48.73 v2(160.34,48.73) 160.45,48.73 160.69,48.48 JDIMM2.189 ; UG6.L10 237.59,57.31 v2(237.99,56.91) UG6.M10 v2(237.19,56.11) ; UG2.L5 278.55,112.96 v2(278.55,112.86) ; JDIMM2.210 165.95,39 165.95,38.08 v2(166.3,37.72) 166.55,37.72 166.95,38.11 166.95,39 JDIMM2.214 ; JDIMM2.168 155.44,36.98 v2(155.34,36.88) ; UG5.E3 216.99,55.71 v2(217.39,55.31) ; v2(224.59,66.31) v2(224.59,65.71) 224.37,65.49 UG5.U12 ; UG3.U1 v2(249.99,65.71) ; CG149.2 232.55,59.73 232.55,60.02 v2(232.64,60.11) 233.54,60.11 v2(233.79,59.86) 233.94,59.71 UG6.H14 234.39,59.71 v2(234.79,60.11) UG6.H13 ; CG100.2 280.5,117.96 v2(280.15,117.61) v2(280.15,116.96) UG2.N1 v2(279.35,116.16) ; v2(280.15,107.36) 279.98,107.53 279.98,107.53 UG2.N12 ; v2(114.07,54.82) 114.07,54.06 113.94,53.93 JDIMM1.10 ; JDIMM2.48 123.45,40.58 123.58,40.71 123.58,41.38 123.12,41.83 v2(122.95,41.83) 122.57,41.83 122.31,41.56 122.31,40.4 122.45,40.26 JDIMM2.44 ; CG85.2 281.07,99.32 280.95,99.2 v2(280.95,98.56) v2(280.95,97.96) UG1.C14 v2(280.95,97.16) ; v2(272.15,81.16) 271.75,81.56 UG4.C1 v2(271.35,81.96) ; JSSD1.73 326.79,30.11 v2(327.16,29.73) 327.04,29.61 JSSD1.75 ; UG3.T5 v2(253.19,64.91) ; JDIMM1.51 124.19,60.91 123.9,61.21 v2(123.37,61.21) 123.19,61.03 JDIMM1.47 ; JDIMM1.78 130.94,50.92 130.53,50.51 v2(130.25,50.51) ; JDIMM2.94 134.94,39.85 134.57,40.23 v2(134.12,40.23) 134.07,40.23 133.94,40.1 JDIMM2.90 ; UG5.R4 v2(217.39,64.11) 216.99,63.71 UG5.R3 v2(216.59,63.31) ; CG121.2 271.4,70.21 v2(271.75,70.56) 271.75,71.16 v2(271.35,71.56) ; UG4.D10 v2(272.15,73.96) 271.75,73.56 UG4.C11 271.75,73.56 v2(271.35,73.16) UG4.C12 ; v2(249.69,14.51) 249.69,14.45 249.02,13.78 JSSD3.21 ; UG2.H13 v2(275.35,106.56) 275.35,106.56 UG2.H14 275.75,105.71 v2(275.6,105.56) ; UG8.C4 203.83,73.05 v2(203.43,72.65) UG8.C3 203.83,72.25 v2(203.43,71.85) ; JSSD3.15 v2(250.53,14.52) ; UG1.H2 UG1.H1 277.35,86.71 v2(277.45,86.61) ; JDIMM1.171 156.19,61.15 v2(156.34,61.3) 155.33,61.3 155.19,61.16 JDIMM1.167 ; v2(324.74,41.75) 324.88,41.61 JSSD1.27 ; JDIMM1.197 162.69,61.36 162.11,61.94 v2(161.74,61.94) ; JDIMM2.36 120.45,38.09 120.05,37.7 v2(119.41,37.7) 118.94,38.17 JDIMM2.30 ; JDIMM1.251 176.19,61.28 v2(176.06,61.42) ; JDIMM1.188 160.44,50.63 v2(160.32,50.51) 160.32,50.5 159.74,50.5 159.44,50.8 JDIMM1.184 ; JDIMM2.206 164.95,39 164.95,38.06 164.59,37.71 164.52,37.71 v2(164.51,37.71) 164.38,37.71 163.95,38.14 163.95,39 JDIMM2.202 ; v2(273.75,73.96) UG4.F10 v2(274.55,73.96) UG4.G10 ; v2(196.23,97.25) UG7.F5 196.63,96.85 v2(197.03,96.45) UG7.G5 ; UG6.B5 v2(241.99,64.91) ; UG8.A12 v2(205.83,79.85) ; v2(271.35,106.56) UG2.C14 271.75,105.56 v2(271.75,105.56) v2(271.75,104.91) 271.75,104.43 271.71,104.39 CG88.2 ; v2(191.97,107.07) 192.03,107.01 UG14.5 ; UG4.E3 v2(273.75,80.36) ; v2(243.59,53.71) UG6.R3 243.19,54.11 v2(242.79,53.71) UG6.R4 UG6.T5 241.59,53.31 v2(241.19,52.91) ; JDIMM2.99 136.19,48.23 v2(135.98,48.44) ; v2(156.34,61.94) 156.66,61.94 157.19,61.41 JDIMM1.175 ; v2(193.03,74.25) UG8.T5 v2(193.83,73.45) UG8.R4 v2(193.83,72.65) 194.23,72.25 UG8.R3 v2(193.83,71.85) ; v2(272.95,116.96) 273.21,116.7 UG2.E1 ; UG4.R14 v2(281.75,70.76) v2(281.75,70.11) ; v2(257.19,52.91) 257.59,53.31 UG3.B10 v2(257.99,53.71) 258.39,54.11 UG3.C11 ; UG5.L10 v2(222.99,60.91) UG5.M10 v2(222.99,61.71) ; v2(113.42,50.52) 113.35,50.52 112.94,50.92 JDIMM1.6 ; UG8.H2 199.83,71.45 v2(199.43,71.85) ; UG2.C3 271.75,114.96 ; 271.75,114.96 v2(272.15,115.36) ; 271.75,114.96 v2(272.15,114.56) 271.75,114.16 UG2.C4 ; CG123.2 262.18,57.7 261.97,57.91 v2(261.49,57.91) 261.29,58.11 UG3.H14 UG3.H13 v2(259.59,58.51) ; v2(226.79,52.91) v2(226.19,52.91) 225.79,52.51 UG5.A14 v2(225.39,52.91) ; v2(259.59,66.31) v2(259.59,65.71) 259.36,65.49 UG3.U12 ; v2(272.95,97.16) UG1.N14 v2(272.95,97.96) ; UG3.U3 251.8,65.49 251.8,65.49 v2(251.59,65.71) v2(251.59,66.31) ; v2(259.59,55.31) UG3.E12 v2(259.59,56.11) ; v2(226.49,57.91) 226.29,58.11 UG5.H14 ; UG5.N14 v2(226.19,62.51) ; UG8.B5 v2(205.03,73.45) ; UG6.U12 v2(235.59,52.11) ; JDIMM1.230 170.94,50.74 171.17,50.51 v2(171.57,50.51) 171.94,50.88 JDIMM1.234 ; v2(119.19,56.22) 119.19,56.22 JDIMM1.31 ; v2(282.55,95.56) UG1.A12 283.24,95.96 v2(283.48,96.2) ; JDIMM2.243 174.19,46.08 173.79,45.67 v2(173.11,45.67) 173.11,46.09 173.19,46.17 JDIMM2.239 ; v2(272.95,71.56) 273.35,71.16 UG4.E14 v2(273.35,70.56) ; v2(224.59,52.11) 224.59,52.11 UG5.A12 ; v2(271.35,116.96) UG2.C1 271.74,116.56 v2(271.34,116.16) ; v2(156.23,37.75) 156.44,37.97 JDIMM2.172 ; UG3.C11 v2(257.99,54.51) UG3.D10 v2(256.99,54.91) ; UG3.C11 v2(258.79,53.71) 259.19,54.11 UG3.C12 v2(259.59,54.51) ; UG6.U3 v2(243.59,52.11) ; v2(174.1,37.71) 174.44,38.06 JDIMM2.244 ; v2(253.99,52.91) 253.59,53.31 UG3.B5 253.19,53.71 v2(253.19,53.71) 253.19,53.71 UG3.C4 ; v2(260.39,53.71) 260.79,54.11 UG3.C14 v2(261.19,54.51) v2(261.79,54.51) 262.4,54.51 263.09,53.82 CG268.2 ; UG1.N12 v2(273.75,96.36) ; UG2.D10 272.35,109.16 272.35,109.16 v2(272.15,108.96) 271.75,108.56 UG2.C11 271.75,108.56 v2(271.35,108.16) UG2.C12 ; JDIMM2.176 157.44,38.11 157.62,37.94 v2(157.62,37.75) ; v2(275.6,86.61) 275.78,86.97 UG1.K1 ; JWLAN.37 v2(311.32,34.76) ; JDIMM1.102 136.94,50.72 137.16,50.51 v2(137.41,50.51) 137.49,50.51 137.94,50.96 JDIMM1.106 ; v2(193.83,101.1) v2(193.83,100.45) UG7.C1 v2(194.63,99.65) ; JDIMM2.223 169.19,48.34 v2(169.48,48.62) 169.97,48.62 170.19,48.39 JDIMM2.227 ; v2(251.59,62.51) UG3.N3 ; v2(200.03,70) 199.91,70.12 199.91,70.57 UG8.H1 ; JDIMM1.1 111.69,59.06 v2(111.41,58.77) ; UG4.A3 v2(269.75,80.36) v2(269.1,80.36) ; v2(201.83,71.85) 202.23,72.25 UG8.E3 ; JDIMM1.15 115.19,60.84 115.37,61.01 115.37,61.04 115.54,61.21 v2(115.94,61.21) 116.19,60.95 JDIMM1.19 ; UG8.U3 192.63,72.25 v2(192.23,71.85) ; v2(224.59,62.51) UG5.N12 v2(224.59,61.71) ; UG6.C14 234.19,63.71 v2(233.79,64.11) 233.3,64.11 233.12,63.93 CG155.2 ; v2(309.77,31.45) 309.82,31.51 JWLAN.31 ; v2(254.32,14.51) 254.32,14.47 254.02,14.18 JSSD3.1 ; UG5.A12 224.19,52.51 v2(223.79,52.91) ; v2(215.79,55.31) 215.39,55.71 UG5.E1 v2(214.99,55.31) v2(214.39,55.31) ; v2(280.15,115.36) UG2.N3 279.93,114.79 v2(280.15,114.56) ; v2(128.45,40.44) JDIMM2.68 ; JDIMM2.226 169.95,39 169.95,41.17 170.67,41.89 v2(170.8,41.89) ; JDIMM1.69 128.69,61.43 128.23,61.9 v2(127.94,61.9) ; UG7.P10 v2(203.43,92.45) UG7.R11 ; v2(224.16,148.81) 224.35,149 PU6200.23 ; UG2.U3 v2(283.35,115.36) ; JDIMM1.85 132.69,61.21 v2(132.64,61.26) ; v2(260.39,64.11) 260.79,63.71 UG3.R14 v2(261.19,64.11) ; v2(235.59,58.51) 235.19,58.11 UG6.K13 UG6.K14 ; JDIMM2.9 113.69,48.64 v2(113.71,48.65) ; v2(272.95,72.36) UG4.E12 ; v2(271.35,80.36) UG4.C3 v2(272.15,79.56) ; UG1.T5 v2(270.55,89.96) ; UG8.E1 v2(202.63,70.25) ; UG4.B10 v2(270.55,73.96) ; v2(273.35,105.56) 273.35,106.16 ; v2(158.12,50.55) 158.21,50.55 158.44,50.78 JDIMM1.180 ; v2(126.69,61.27) JDIMM1.61 ; UG4.A12 270.15,72.76 v2(269.75,72.36) ; v2(167.55,50.52) 167.94,50.91 JDIMM1.218 ; v2(195.43,77.45) 195.03,77.85 UG8.P10 ; JDIMM1.214 166.94,50.86 166.6,50.52 v2(166.3,50.52) 165.94,50.88 JDIMM1.210 ; v2(327.16,45.56) 327.16,45.8 326.86,46.11 JSSD1.9 ; UG4.U3 v2(283.31,80.32) ; v2(196.23,92.45) UG7.F10 196.63,93 v2(197.03,93.4) 197.43,93 UG7.G10 ; UG3.A3 251.99,52.51 v2(252.39,52.11) ; v2(193.83,90.05) 194.23,89.65 UG7.C14 v2(193.83,89.25) ; v2(272.15,78.82) 272.09,78.82 UG4.C4 ; UG8.C12 v2(204.23,79.85) ; UG4.K2 UG4.K1 277.35,82.16 v2(277.4,82.21) ; UG7.R4 v2(204.23,98.05) 203.83,98.45 UG7.R3 203.83,98.45 v2(203.43,98.85) ; v2(283.35,107.36) UG2.U12 v2(282.55,107.36) ; UG3.C3 v2(251.59,53.71) ; v2(272.95,88.36) 273.35,88.76 UG1.N3 ; v2(206.08,100.65) v2(205.43,100.65) UG7.U1 ; v2(237.99,55.31) UG6.P10 ; v2(167.39,61.44) 167.69,61.13 JDIMM1.217 ; v2(121.24,62.16) 120.97,62.16 120.19,61.39 JDIMM1.35 ; JDIMM2.43 122.2,47.2 122.2,48.66 122.76,49.22 v2(122.94,49.22) ; UG5.P10 v2(222.99,63.31) UG5.R11 v2(223.79,64.11) 224.19,63.71 UG5.R12 v2(224.59,63.31) ; UG8.F5 201.43,73.85 v2(201.03,73.45) UG8.G5 ; v2(272.15,87.56) UG1.R1 v2(271.35,86.76) ; v2(140.47,145.26) 140.47,145.51 140.9,145.94 PU507.23 ; UG2.P10 v2(280.15,109.76) ; v2(283.35,72.36) 282.95,72.76 UG4.U12 v2(282.55,72.36) ; JDIMM2.77 130.69,48.05 130.85,48.21 130.85,48.64 v2(130.31,49.19) 129.9,49.19 129.69,48.98 JDIMM2.73 ; JDIMM2.1 111.69,48.65 v2(112.13,49.08) 112.69,48.51 JDIMM2.5 ; v2(244.53,14.19) JSSD3.39 ; UG1.K2 275.91,88.12 275.91,88.12 v2(276.15,88.36) ; UG3.A14 260.79,52.51 v2(261.19,52.91) v2(261.79,52.91) 261.95,52.75 261.95,51.66 262.2,51.4 CG226.2 ; JDIMM1.82 131.94,50.73 v2(132.17,50.51) 132.66,50.51 132.94,50.79 JDIMM1.86 ; JWLAN.43 v2(312.82,34.76) ; JTP.14 v2(190.32,9.89) ; UG2.F5 v2(274.55,113.76) UG2.G5 ; v2(214.99,65.71) UG5.U1 ; UG1.U3 270.15,88.76 v2(269.75,88.36) v2(269.15,88.36) ; UG5.C4 217.79,54.11 v2(218.19,53.71) UG5.B5 218.59,53.31 v2(218.99,52.91) ; JDIMM2.213 166.69,48.21 166.48,48.42 v2(166.31,48.42) 165.9,48.42 165.69,48.21 JDIMM2.209 ; UG8.U1 192.28,70.3 v2(192.28,70.25) v2(192.28,69.6) ; v2(216.59,59.31) 216.19,59.71 UG5.K2 ; UG1.E14 v2(280.15,97.16) ; v2(170.8,54.69) 170.65,54.69 169.94,53.99 JDIMM1.226 ; UG6.A3 v2(243.59,64.91) ; JSSD3.33 246.02,13.66 246.88,14.51 v2(247.09,14.51) 247.53,14.07 JSSD3.27 ; v2(197.98,100.7) 198.23,100.45 UG7.H1 UG7.H2 ; UG3.K2 251.19,59.71 v2(251.59,59.31) ; v2(327.36,36.81) 327.31,36.86 327.3,36.86 327.06,37.11 JSSD1.45 ; JDIMM1.201 163.69,61 164,61.31 v2(164.54,61.31) 164.54,61.13 164.69,60.97 JDIMM1.205 ; v2(244.39,64.11) 244.79,63.71 UG6.C1 v2(245.19,64.11) ; JDIMM2.81 131.69,48.11 v2(132.19,48.6) ; v2(225.39,54.51) UG5.C14 v2(226.19,54.51) v2(226.79,54.51) 227.53,54.51 228.16,53.88 CG266.2 ; v2(327.29,40.11) JSSD1.33 ; UG4.B5 v2(270.55,78.76) ; JDIMM1.196 162.44,50.86 162.14,50.56 v2(161.51,50.56) 161.44,50.62 JDIMM1.192 ; v2(204.23,99.65) 203.83,100.05 UG7.R1 203.83,100.65 v2(203.83,100.65) ; v2(245.19,62.51) UG6.E1 ; UG6.E12 v2(235.59,62.51) ; UG7.A12 v2(193.03,91.65) ; JDIMM1.27 118.19,61.04 117.95,61.28 v2(117.74,61.28) 117.5,61.28 117.19,60.97 JDIMM1.23 ; UG6.A1 v2(245.19,65.71) ; v2(282.55,112.96) UG2.T5 v2(281.75,113.76) ; UG4.T5 v2(282.55,77.96) ; JDIMM2.27 118.2,47.2 118.2,48.32 117.95,48.56 v2(117.48,48.56) 117.2,48.28 117.2,47.2 JDIMM2.23 ; UG6.A12 v2(235.59,65.71) ; UG6.E3 v2(243.59,61.71) ; JWLAN.67 v2(318.82,34.76) ; JSSD1.21 326.61,43.11 326.84,43.34 v2(327.09,43.34) ; v2(252.02,14.52) JSSD3.9 ; v2(280.15,74.76) UG4.P10 ; UG8.N12 v2(195.43,79.85) ; UG7.N1 v2(202.23,100.65) ; v2(279.35,108.96) UG2.M10 v2(278.55,109.76) UG2.L10 ; v2(202.63,98.85) 202.56,98.79 UG7.N3 ; UG6.U1 v2(245.19,52.11) ; JDIMM2.40 121.45,41.16 120.77,41.83 v2(120.59,41.83) ; UG8.A1 v2(205.83,70.25) ; UG8.E12 v2(202.63,79.85) ; UG3.E14 v2(260.39,56.11)
  BOTTOM w0.356: RE485.2 233.05,23.49 233.43,23.11 v2(233.49,23.11) ; RH28.2 197.4,14.68 v2(197.62,14.89) ; RG26.2 230.98,120.28 v2(231.4,119.85) ; v2(232.82,29.8) 232.84,29.82 232.84,30.13 RE401.2 ; RE465.2 227.15,26.66 v2(227.52,26.29) ; RT22.2 201.56,157.54 v2(201.59,157.51) ; RM87.2 123.95,158.12 v2(123.71,157.88) ; RE472.2 227.15,29.81 227.44,29.52 v2(227.44,29.51) ; RV17.2 227.82,157.17 v2(227.76,157.11) ; v2(236.48,32.93) 236.74,32.67 RE397.2 ; RH22.2 197.34,13.11 197.34,12.67 v2(197.37,12.64) ; v2(227.97,19.7) 227.15,20.53 RE453.2 ; v2(204.8,168.24) 205.15,167.89 RT65.2 ; v2(188.92,152.81) 188.67,153.07 CT45.2 ; v2(179.97,151.36) 179.97,151.54 RT78.2 ; RV669.2 191.86,132.56 v2(192.41,133.11) ; RV670.2 192.29,130.84 v2(192.36,130.91) ; RE479.2 v2(233.05,26.27) ; RG22.2 225.71,23.5 v2(225.94,23.27) ; v2(223.22,170.75) 223.21,170.75 223.21,170.72 223.19,170.69 CV1069.2 ; RG518.2 v2(232.37,120.28) ; v2(180.65,164.46) 180.77,164.57 181.24,164.57 CT59.2 ; v2(210.51,124.7) 210.54,124.67 210.6,124.67 211.15,124.12 RG519.2 ; RA52.2 36.12,11.88 ; v2(203.15,168.62) 203.84,167.93 RT64.2 ; CT57.2 175.45,151.55 v2(175.65,151.35) ; RE491.2 233.05,20.58 233.41,20.23 v2(233.75,20.23) ; v2(200.13,123.31) 200.33,123.12 RG3.1 ; v2(236.17,164.94) 236.1,165.01 RV15.1 ; v2(168.03,163.52) 167.63,163.93 RV600.1
  BOTTOM w0.381: v2(231.28,32.67) 231.24,32.63 231.21,32.63 230.83,32.25 RE473.2 230.54,32.2 230.26,31.92 QE42.4 ; v2(176.35,151.36) 176.83,151.36 RT24.2 ; RS3.2 235.44,15.5 235.43,15.49 ; v2(186.76,166.25) 186.61,166.4 RT43.2 ; CG241.2 v2(212.43,110.38) ; v2(195.53,168.18) 196.1,168.18 CT102.2 ; QE45.1 233.56,20.91 233.36,20.71 233.13,20.71 RE491.2 ; v2(148.64,165.52) 148.65,165.51 148.73,165.51 149.12,165.12 QM2.4 ; PQ8202.4 237.8,32.76 237.59,32.98 237.59,34.03 v2(238.06,34.5) ; RM64.2 139.35,157.36 v2(139.58,157.13) ; CT85.2 184.46,165.67 v2(184.55,165.76) ; v2(205.99,41.5) 205.42,42.07 CH177.2 ; CG87.2 269.74,100.76 CG220.2 ; CG287.2 CG284.2 ; CG117.2 274.05,101.1 RG112.2 CG78.2 275.94,100.06 v2(276.49,99.51) ; QE43.1 233.56,27.39 233.29,27.11 RE479.2 ; v2(213.83,158.67) 213.82,158.66 212.63,158.66 UX2.3 ; v2(237.05,29.75) 237.05,29.28 RE478.2 236.44,28.96 236.17,28.69 QE43.4 ; v2(180.76,151.36) 180.76,152.64 RT79.2 ; QE40.4 230.26,25.45 230.54,25.72 RE462.2 v2(230.83,26.51) ; RE401.2 233.46,30.35 233.74,30.62 QE29.1 ; PQ8202.1 239.72,30.73 240.51,31.52 240.51,32.07 240.09,32.49 v2(239.87,32.49) ; v2(227.58,22.92) 227.54,22.92 227.15,23.31 RE458.2 227.43,23.68 227.9,24.15 QE40.1 ; v2(94.37,46.39) 94.37,46.83 94.1,47.1 PR207.2 93.93,47.15 93.02,48.05 PC210.2 ; v2(236.44,23.34) 236.74,23.05 RE490.2 236.58,22.49 236.51,22.41 236.43,22.41 236.24,22.22 236.24,22.21 QE45.4 ; v2(170.19,6.26) 170.19,6.7 169.82,7.07 JKBBL.1 ; JLAN.17 v2(243.51,181.69) ; v2(175.36,159.29) 175.35,159.29 175.35,159.95 174.99,160.31 CM17.2 ; CT58.2 CT57.2 ; CT86.2 182.4,166.91 181.95,166.46 v2(181.95,166.41) ; CG219.2 227.77,63.93 227.15,63.93 ; UV3.8 228.79,163.72 228.27,163.2 228.27,163.13 227.95,162.81 227.87,162.81 v2(227.85,162.78) ; v2(180.98,170.38) 180.98,170.37 CT66.2 CT64.2 ; CT82.2 182.65,170.5 v2(182.62,170.54) ; v2(131.15,101.57) 130.69,101.57 130.36,101.24 C11.2 ; RG134.2 CG148.2 227.78,59.73 227.78,60.06 v2(227.74,60.11) ; v2(233.86,169.3) 234.18,169.62 JDP.8 ; v2(181.3,161.86) 181.39,161.94 CT60.2 ; v2(139.71,160.5) 139.33,160.12 RM23.1 RM82.1 ; v2(167.52,158.66) 167.94,159.07 UM4.15 ; v2(133.03,161.32) 133.07,161.36 134.06,161.36 CM9.2 ; v2(198.63,90.85) 198.23,90.45 UG7.H13 ; RT39.2 177.78,159.92 177.78,158.05 176.84,157.12 176.84,156.67 v2(176.79,156.62) ; v2(178.05,166.41) 178.11,166.47 CT47.2 ; CT69.2 181.56,170.5 v2(181.59,170.53) ; RE453.2 227.49,20.69 227.7,20.91 QE39.1 ; v2(253.19,51.31) 252.93,51.05 CG282.2 ; RT69.2 199.08,168.4 v2(199.29,168.61) 199.72,168.19 RT68.2 ; DT10.3 192.81,172.85 v2(192.88,172.79) ; QG507.1 v2(289.53,85.53) ; v2(249.99,51.31) 249.69,51.01 CG132.2 ; CT61.2 179.38,163.84 v2(179.35,163.81) ; RT71.2 198.45,168.5 v2(198.23,168.71) 197.81,168.29 RT72.2 ; CG243.2 203.86,83.23 203.86,82.58 ; v2(230.83,29.75) RE468.2 230.54,28.96 230.26,28.69 QE41.4 ; QM2.1 152.31,166.42 v2(152.31,166.42) ; v2(169.62,155.67) 168.92,155.67 167.94,154.69 UM4.6 ; v2(170.7,158.59) 170.54,158.75 UM4.19 ; CG283.2 205.89,86.53 CG207.2 ; v2(281.75,71.56) 281.75,71.56 UG4.R14 ; CG1.2 197.8,104.65 197.92,104.77 198.46,104.77 v2(198.67,104.55) ; CT80.2 CT54.2 180.65,164.46 v2(180.65,164.46) ; v2(184.55,161.22) 184.79,161.46 RT19.2 ; v2(197.62,14.89) 197.89,14.89 198.07,15.07 RH30.2 ; CV35.2 238.1,167.32 CV34.2 v2(237.82,166.4) ; CU20.2 v2(11.69,61.35) ; v2(169.22,6.76) 169.32,6.66 JKBBL.2 ; v2(178.05,161.86) 178.41,161.86 178.51,161.96 CT46.2 CT78.2 ; RT44.2 185.36,167.07 v2(184.56,167.07) 184.46,166.97 CT84.2 ; CT90.2 202.21,158.08 RT22.2 ; CT59.2 CT79.2 ; v2(124.86,159.65) 124.9,159.61 RM72.2 ; CT71.2 184.51,165.06 v2(184.56,165.1) ; QG500.1 210.51,121.95 210.94,121.52 v2(210.94,120.9) ; CT81.2 183.54,170.33 v2(183.74,170.53) ; RE397.2 236.44,32.2 236.17,31.92 QE29.4 ; CU21.2 v2(10.35,56.92) ; RT80.2 176.73,166.44 v2(176.77,166.4) ; RE465.2 227.38,27.17 227.6,27.39 QE41.1 ; CT55.2 185.15,163.21 v2(185.2,163.17) ; 235.97,170.7 235.97,169.32 v2(235.66,169.01) ; QE44.4 236.17,25.45 236.44,25.72 RE484.2 237.02,26 v2(237.02,26.45) ; RA75.2 34.12,1.47 34.47,1.47 v2(34.49,1.45) ; v2(139.95,153.21) 139.87,153.13 RM75.1 ; CH46.2 219.66,35.06 220.13,34.6 220.15,34.6 220.17,34.58 v2(221.12,34.58) ; RG501.2 v2(216.06,109.25) ; QG508.4 289.09,80.79 v2(289.02,80.85) ; CG81.2 v2(284.27,110.59) ; RE485.2 233.49,23.87 233.76,24.15 QE44.1 ; QG507.4 v2(290.83,85.05) ; UV3.15 v2(236.69,159.82) ; v2(206.74,162.4) RT63.2 ; RT45.2 RT42.2 178.96,172.35 178.96,172.96 v2(179.21,173.2) ; QE42.1 227.64,30.62 227.43,30.41 RE472.2 ; v2(178.05,165.11) 178.01,165.15 CT62.2 ; JLAN.15 v2(262.86,181.69) ; v2(230.83,23.27) RE456.2 230.54,22.49 230.26,22.21 QE39.4 ; CT48.2 182.53,163.79 CT72.2 181.98,164.43 v2(181.95,164.46) ; CG271.2 v2(248.61,51.09)
  BOTTOM w0.4: QG4.3 227.19,52.51 v2(226.79,52.91) ; UG2.E14 273.35,106.16 UG2.E14 ; UG2.E14 v2(272.95,106.56) ; v2(259.59,62.51) UG3.N12 v2(259.59,61.71) ; UG4.C14 271.75,71.16 ; UG2.E12 v2(272.95,107.36) ; UG7.E14 195.62,89.86 195.62,89.86 v2(195.43,90.05)
  BOTTOM w0.406: UM3.3 159.82,172.03 v2(159.48,171.69) ; JEC.10 286.45,12.94 286.14,12.63 v2(286.14,12.35) ; UM7.3 150.91,174.63 151.32,175.04 v2(151.58,175.04) ; v2(201.35,121.05) 201.41,121.1 UG10.3 201.41,121.89 201.9,122.38 203.44,122.38 204.15,123.1 RG562.2
  BOTTOM w0.432: v2(208.83,123.05) 208.97,123.19 QG500.4 ; v2(286.06,7.44) JEC.9
  BOTTOM w0.457: CG322.2 196.57,104.96 CG323.2 CG385.2 v2(197.46,105.21) ; v2(36.8,32.01) 36.84,31.97 36.99,31.97 CA12.2 ; CT91.2 202.31,156.93 v2(201.6,156.93) ; RM42.2 152.04,173.76 151.58,174.21 v2(151.58,174.34) ; C258.2 65.9,17.84 v2(66.11,17.62) ; v2(243.75,120.68) 243.71,120.72 RG36.2 ; UG11.3 191.51,119.53 v2(191.55,119.56) ; v2(193.98,111) 193.51,111.47 193.51,111.59 193.05,112.05 CG292.2
  BOTTOM w0.508: PR5034.1 125.79,115.5 125.91,115.5 126.53,114.88 RH166.1 126.73,114.43 126.69,114.4 126.69,114.37 v2(126.56,114.24) ; v2(283.4,73.96) 283.98,73.96 284.19,73.76 CG115.2 ; JKB3.10 v2(66.86,7.93) ; CG227.2 255.91,51.15 v2(256.17,51.4) ; CV1056.2 212.73,155.32 PC6214.2 212.24,154.4 211.66,154.98 211.45,154.98 v2(211.44,155) ; RH149.1 RH150.1 167.88,89.85 v2(167.59,90.14) ; v2(14.07,56.23) 14.5,55.79 CU32.2 ; v2(196.54,107.39) 196.16,107.77 CG64.2 ; PC806.2 235.35,43.29 v2(234.86,42.79) ; v2(234.07,167.74) 234.07,166.91 233.84,166.68 RV18.1 CX1.2 ; CL7.2 266.4,159.59 266.4,158.66 v2(266.71,158.35) ; DU21.1 v2(13.09,67.79) ; v2(128.33,149.94) RM70.1 ; PR6062.1 v2(283.96,134.26) ; v2(182.4,48.18) 182.85,47.73 C2498.2 ; PC6227.2 211.62,142.15 v2(211.98,142.51) ; v2(191.46,129.24) CV436.2 ; v2(159.55,162.54) 158.83,162.54 QV2.3 ; v2(199.86,12.59) 199.86,13.33 RH585.1 ; v2(319.92,36.1) JWLAN.69 ; v2(179.27,125.98) 179.27,125.6 PC1006.2 PC1003.2 ; YH2.4 191.89,44.75 v2(191.88,44.74) ; v2(31.28,36.79) CA7.2 32.07,36.68 RA22.2 ; CE85.2 32.01,48.8 31.5,49.31 v2(31.5,49.82) ; v2(172.16,89) 172.79,89.63 RH148.1 ; JACK1.7 10.82,3.51 11.44,2.89 16.14,2.89 v2(17.24,1.8) ; PC111.2 v2(55.13,41.5) ; v2(123.07,149.01) 122.59,148.52 PC537.2 122.59,146.99 PR547.1 ; PC6000.1 v2(267.92,143.3) ; PC6008.2 v2(271.28,134.94) ; v2(193.83,101.1) 194.02,101.29 194.02,101.36 194.37,101.71 194.44,101.71 194.59,101.86 CG284.2 ; PC807.2 v2(123.53,114.08) ; CM18.2 168.8,162.29 168.9,162.39 RM25.1 170.18,162.39 v2(170.51,162.72) ; v2(39.14,33.94) 38.81,33.61 CA37.2 ; PC8200.2 249.37,34.98 249.56,35.17 v2(249.56,35.97) ; PR8206.1 249.37,32.16 v2(249.82,31.71) ; CU33.2 v2(22.63,55.64) ; RH469.2 171.95,122.87 v2(171.9,122.87) ; DA6.1 v2(21.94,33.08) ; v2(191.72,137.24) 190.93,136.45 RV20.2 ; v2(199.06,83.34) 199.28,83.57 CG388.2 ; PR811.2 223.47,43.29 PC813.2 PC812.2 224.86,42.45 PC821.2 224.74,42.17 224.41,41.84 224.41,41.36 v2(224.04,40.99) ; PC6443.2 277.66,65.56 v2(277.4,65.82) ; PC3.2 v2(75.57,30.93) ; RM38.2 165.45,163.19 v2(165.73,163.19) ; JTRONR.6 278.77,29.78 v2(279.11,29.43) 279.57,29.88 JTRONR.7 ; RV624.2 197.87,138.03 197.06,138.84 v2(196.87,138.84) ; v2(125.51,103.86) PC599.2 126.18,103.35 127.12,102.41 C3.2 ; v2(126.69,7.84) 127.07,7.46 JHDD.34 ; v2(229.95,15.14) 229.96,15.14 CH49.2 ; v2(101.98,28.95) 101.76,28.73 UE9.2 ; PC598.2 v2(126.18,105.99) ; v2(217.37,50.53) 217.58,50.32 CG161.2 ; v2(328.65,48.72) 328.17,49.21 JSSD1.76 ; v2(273.04,30.32) 273.47,29.89 JTRONR.13 ; v2(125.5,119.35) 125.49,119.34 PR5008.2 125.5,118.59 PC590.2 ; v2(105.38,27.21) CE65.2 CE64.2 ; C263.2 v2(69.6,18.27) ; v2(277.4,67.09) 277.72,66.77 PC6442.2 ; CG256.2 v2(194,84.23) ; RV23.1 CV438.2 201.29,137.56 v2(201.43,137.7) ; JHDD.33 122.4,7.78 v2(123.07,7.78) ; v2(71.45,9.11) 72.2,9.11 73,9.91 C261.2 73,11.61 C260.2 ; RV665.2 223.97,158.66 223.47,158.15 v2(223.47,156.81) ; CH178.2 202.03,40.88 201.81,40.67 v2(201.81,40.46) ; v2(205.49,125.3) 205.49,125.81 CV437.2 ; CG116.2 285.25,70.58 v2(285.99,70.58) ; DU20.1 15.88,64.55 v2(15.88,65.25) ; PC214.2 PC213.2 96.97,44.55 v2(97.48,44.04) ; CG382.2 232.46,56.29 232.82,55.93 v2(232.82,55.18) ; PC6009.2 v2(272.42,143.29) ; v2(24.77,50.39) 23.95,50.39 CU42.2 ; JSPK.6 45.93,15.29 v2(45.58,15.63) ; v2(19.95,49.89) 20.1,49.74 CU35.2 ; v2(39.7,33.24) 39.98,32.97 CA36.2 ; PC801.2 236.86,39.85 236.6,40.11 v2(236.55,40.11) ; v2(161.25,163.07) 161.48,163.3 CV372.2 ; v2(225.32,47.95) 225.32,47.63 PC820.2 PC824.2 ; CG65.2 197.37,107.72 v2(197.63,107.45) ; v2(164.22,172.7) RM6.1 ; v2(208.99,6.55) JKB.32 ; v2(140.57,148.13) PH500.1 ; CA1.2 34.77,23.98 34.5,23.71 v2(34.5,23.27) ; v2(178.05,162.51) 178.04,162.52 RT5.2 ; CU44.2 v2(21.41,55.59) ; v2(254.32,14.51) 255.12,13.71 JSSD3.76 ; CE84.2 45.3,47.81 v2(45.55,48.06) ; CM19.2 163.52,159.1 162.55,160.07 v2(162.26,160.07) ; v2(282.58,65.69) 282.95,65.33 QG3.3 ; PR6060.1 v2(278.44,134.27) ; DV14.1 158.2,167.67 v2(158.38,167.84) ; v2(202.83,140.89) 204.03,140.89 204.29,140.63 CV439.2 ; v2(274.39,4.66) JSSD2.77 ; v2(31.71,35.08) 31.72,35.09 CA4.2 ; v2(124.06,131.93) PC501.2 ; CL9.1 278.65,162.47 v2(278.91,162.73) 278.94,162.76 v2(278.94,163.57) YL1.2 ; PC8216.2 243.21,37.89 v2(243.25,37.93) ; v2(209.98,146.05) 209.62,146.4 PC6216.2 ; JELC.7 164.69,25.09 v2(164.28,25.5) ; v2(42.3,7.14) 42.12,7.14 RA73.2 ; v2(41.66,10) 42.43,9.24 JSPK.8 ; v2(194.64,136.94) 194.62,136.92 RV24.2 ; CG292.2 192.79,112.06 CG288.2 ; JDIMM2.261 v2(113.48,31.1) ; CV19.2 v2(165.4,171.9) ; v2(236.55,41.62) PR805.2 ; PC108.2 31.29,41.08 v2(30.18,42.18) ; v2(258.79,51.31) 258.45,50.98 CG133.2 ; PH504.1 163.06,147.37 v2(162.76,147.67) ; JDIMM2.262 176.52,31.1 v2(175.97,31.66) ; v2(123.71,156.5) 124.11,156.09 CM33.2 CM30.2 ; JELC.6 v2(170.6,25.65) ; JACK2.7 10.82,16.08 11.31,15.59 15.25,15.59 19,11.84 ; RH581.2 207.13,43.56 RH109.2 205.91,43.56 205.24,42.89 205.24,42.64 205.14,42.54 CH177.2 205.13,42.07 204.62,41.56 204.62,40.59 v2(204.55,40.52) ; PR5018.1 123.31,122.54 v2(123.47,122.7) ; PC309.2 v2(259.15,17.3) ; JSPK.7 v2(55.03,6.95) ; v2(100.12,52.32) PC1301.2 PR1302.2 ; CU37.2 11.89,55.96 v2(11.57,56.28) ; v2(190.83,74.64) 190.57,74.9 CG276.2 ; v2(99.82,15.44) UE2.4 ; v2(238.51,50.51) 238.01,50.51 237.75,50.26 ; v2(124.38,149.93) RM84.1 ; v2(105.52,25.79) 105.14,25.41 CE19.2 ; QX1.3 222.5,162.45 v2(221.78,161.73) ; v2(48.15,45.49) 48.15,46.14 48.51,46.5 PR107.2 ; v2(129.6,149.94) CM35.2 ; CG221.2 284.53,108.17 v2(284.11,108.59) ; v2(213.37,105.57) CG66.2 ; JKBBL.22 v2(158.67,8.35) ; CX2.2 207.95,160.57 v2(207.49,161.03) ; PC1004.2 175.46,125.6 v2(175.46,125.98) ; PC591.2 118.44,106.78 v2(119.04,107.38) ; C2507.2 65.2,10.71 v2(65.67,10.24) 66.07,10.65 C2524.2 ; CG219.2 228.61,63.85 CG368.2 ; CM34.2 v2(140.03,155.54) ; PC597.2 PC596.2 v2(121.23,103.06) ; v2(200.92,107.28) 201.32,106.89 RG89.1 ; v2(203.27,108.91) 203.04,108.91 202.51,109.44 RG87.1 ; UG15.4 v2(208.94,110.33) ; v2(279.52,134.32) 279.66,134.18 PR6056.1 ; CA5.2 v2(28.27,41.94) ; RM29.2 v2(165.74,161.68) ; v2(268.11,137.45) 268.3,137.64 PR6005.1 268.89,137.64 PC6001.2 ; v2(246.08,50.96) CG273.2 ; CA2.2 v2(34.77,25.61) ; CE86.2 285.45,30.43 v2(285.22,30.19) 284.87,29.84 JTRONR.14 ; C2523.2 63.39,10.66 v2(63.85,10.2) 64.28,10.64 C2506.2 ; v2(223.91,170.72) 223.91,170.02 223.66,169.77 CV1068.2 ; PR104.2 51.83,49.64 v2(51.83,50.08) ; CA12.2 CA13.2 ; JELC.4 169,25.98 v2(169.36,25.62) 169.8,26.06 JELC.5 ; v2(269.1,168.44) UL2.2 ; v2(196,118.86) 195.92,118.78 RG65.1 ; RG92.1 v2(214.07,116.43) ; QG508.1 290.62,78.24 v2(290.94,78.57) ; v2(283.07,103.89) 282.84,103.66 CG98.2 ; PC1303.2 99.7,38.44 100.21,37.93 v2(100.31,37.93) ; PC207.1 v2(93.61,40.1) ; CE22.2 v2(103.4,28.77) ; PR802.2 236.64,38.96 v2(236.55,39.05) ; CG387.2 199.25,87.59 v2(199.13,87.7) ; CT98.2 194.57,161.77 194.69,161.88 CT103.2 193.3,162.34 v2(192.92,161.96) ; CG76.1 213,115.65 v2(213.18,115.48) 214,114.65 RG98.2 ; CG225.2 285.12,82.48 v2(285.35,82.71) ; UT2.4 193.99,159.1 194.5,158.59 v2(194.7,158.59) ; v2(294.54,36.23) 295.24,35.52 JRTC1.3 ; PC5003.2 v2(125.93,112.73) ; v2(120.46,133.68) 120.07,133.68 119.56,134.18 PC5010.1 119.54,134.36 PR513.1 119.55,135.25 PC507.2 ; CG392.2 206.14,85.74 CG283.2 ; v2(193.85,120.34) 193.85,120.76 193.21,121.39 CG61.2 ; v2(207.02,125.36) 207.02,124.53 RV630.2 ; JDIMM1.262 176.12,67.9 v2(175.09,68.93) ; JKB3.7 v2(61.43,6.7) ; PC101.2 54.03,50.03 v2(54.75,50.03) 55.19,49.6 PR103.1 ; PR5015.2 v2(119.68,121.05) ; PC115.2 31.29,47.35 v2(30.95,47.69) ; JKBBL.21 v2(171.47,8.6) ; CV20.2 223.59,160.95 224.67,162.03 v2(224.67,162.4) RX1.2 ; v2(243.33,50.96) CG159.2 ; UG13.4 209.56,104.3 208.86,105 v2(208.86,105.16) ; v2(209.44,131.53) 208.8,132.18 RV22.2 RV628.2 ; v2(215.53,157.77) 215.49,157.73 RX8.2 ; PR6019.2 v2(271.28,142.97) ; v2(23.57,52.17) 23.57,51.91 23.83,51.64 CU34.2 ; v2(232.64,60.11) 232,60.75 CG383.2 ; v2(39.06,8.8) 39.01,8.74 CA71.1 38.38,8.73 RA62.1 ; v2(114.94,7.46) 114.94,6.72 JHDD.32 ; v2(190.19,106.12) 190.94,105.38 CG240.2 ; PC811.2 PR808.2 225.17,39.59 PR815.1 224.72,40.35 v2(224.51,40.56) ; PR6000.2 v2(267.92,142.41) ; v2(197.68,9.94) 198.17,9.45 198.17,9.35 198.97,8.55 JTP.17 ; v2(35.03,1.78) 35.11,1.86 35.11,2.58 34.92,2.78 CA255.2 ; RV622.2 RV626.2 209.19,130.7 209.27,130.63 v2(209.5,130.63) ; v2(37.28,16.99) 37.43,16.84 CA65.2 ; PC1.2 v2(84.1,39.42) ; v2(101.09,27.15) CE20.2 ; v2(258.4,14.69) 258.45,14.64 C633.2 ; CL40.2 268.27,171.38 v2(268.99,170.66) ; PR6058.1 v2(283.96,137.95) ; v2(132.27,146.67) 132.27,145.75 PC522.2 ; PC802.2 249.21,45.31 v2(249.46,45.56) ; v2(131.14,9.87) 130.32,9.06 JHDD.35 ; v2(197.32,83.34) RG154.2 CG265.2 ; v2(291.66,35.72) 291.44,35.94 JRTC1.2 ; CH175.2 215.28,44.4 v2(215.73,44.4) ; v2(35.19,16.99) 34.74,16.54 RA67.2 CA74.2 ; CG228.2 262.82,50.2 263.01,50.38 v2(263.03,50.38) ; CM70.2 149.61,169.71 v2(150.12,169.2) ; CL8.1 v2(277.8,160.34) ; PC8211.2 243.2,30.37 v2(243.4,30.58) ; CG391.2 192.76,86.9 QG8.3 192.38,85.69 v2(192.37,85.68) ; v2(271.73,172.56) 271.29,172.13 CL41.2 ; v2(194.08,163.77) 194.18,163.67 CT88.2 ; v2(199.59,43.59) 199.53,43.53 199.53,42.91 CH179.2 ; PC8205.2 241.68,34.74 v2(242.24,34.74) ; RV664.2 227.73,158.66 227.73,160.08 v2(227.76,160.1) ; R185.1 188.92,40.87 v2(188.92,40.1) ; PC523.2 121.59,145.4 v2(122.02,144.96) ; CLRP1.2 v2(174.67,34.55) ; CH48.2 195.03,43.26 v2(195.03,42.77) ; v2(130.69,134.53) 130.28,134.93 PR519.2 PR516.2 ; CU19.2 12.86,57.88 12.77,57.97 v2(12.77,58.77) 11.86,59.68 DU11.1 ; v2(137.6,149.61) RM62.1 ; CM21.2 CM20.2 v2(168.34,150.78) ; CU18.2 11.06,64.29 12.07,65.31 v2(12.07,65.69) ; JKB.31 225.73,6.55 v2(226.51,7.33) ; v2(171.26,150.83) RM21.1 ; CG386.2 197.66,114.61 v2(198.13,115.08) ; v2(37.43,14.26) CA64.2 ; QV95.3 v2(207.41,138.83) ; v2(43.53,51.67) 44.05,51.15 JTRONL.13 ; PC6222.2 v2(216.35,155.61) ; JWLAN.68 299.22,34.64 v2(300.3,35.72) ; CG208.2 CG390.2 ; RH9.2 CH45.2 219.39,37.99 v2(219.02,37.62) ; C262.2 v2(69.71,17.21) ; v2(60.74,17.08) 61.26,17.6 C2525.2 ; v2(324.89,28.51) JSSD1.77 ; v2(131.36,149.7) 131.12,149.94 CM32.2 ; DA5.1 v2(22.45,17.11) ; PR6427.1 v2(247.34,119.09) ; RH472.2 152.84,121.99 v2(153.16,121.67) 153.73,122.24 RH466.2 ; JHDD.31 v2(109.95,8) ; PR517.2 128.5,134.95 v2(128.08,134.53) 127.62,135 PR518.2 ; v2(58.54,48.49) 58.45,48.57 57.14,48.57 PR105.1 ; PR106.1 49.97,47.73 50.81,46.88 v2(50.81,46.82) ; CA35.2 37.68,35.92 38.05,36.29 v2(38.05,36.42) 38.05,36.68 CA34.2 ; YG1.2 v2(210.79,115.09) ; CT92.2 CT93.2 206.6,161.36 206.79,161.17 v2(206.79,161.17) ; YH2.2 v2(194.08,46.45) ; v2(239.79,29.81) 239.78,29.81 239.72,29.75 PC8222.2 ; C265.2 58.53,16.96 C264.2 v2(58.53,15.22) ; v2(130.09,161.26) 130.69,161.26 CM36.2 ; JTRONL.14 v2(33.37,52.36) ; CA41.2 38.99,29.68 v2(39.01,29.66) ; PR6059.1 v2(283.96,136.1) ; CA6.2 v2(29.41,39.59) ; C2.2 194.06,14.51 194.38,14.83 v2(195.02,14.83) ; v2(114.25,67.47) 113.81,67.9 JDIMM1.261 ; JKB3.8 v2(60.65,4.93) ; CL42.2 v2(266.15,169.37) ; PC529.2 v2(130.89,148.5) ; PC5011.1 120.5,147.32 v2(121.8,148.62) ; v2(19.12,36.99) DU1.1 ; PC817.2 240.34,44.49 v2(239.86,44.49) ; PC2.2 v2(85.2,39.4) ; v2(227.95,43.6) 228.15,43.4 PC822.2 ; C2515.2 267.43,19.59 v2(267.66,19.36) 267.66,19.01 267.7,18.97 267.7,18.8 C2516.2 ; v2(289.38,32.34) 288.89,32.84 JRTC1.4 ; YL1.4 v2(282.49,166.12) ; PC6203.2 v2(223.47,145.38) ; CG281.2 284.81,76.61 v2(284.81,76.3) ; YG1.4 209.09,118.51 v2(208.34,119.26) ; PR6038.1 v2(283.35,139.12) ; JELC.8 v2(171.9,26.32) ; PC6012.1 v2(274.2,145.64) ; v2(161.48,173.77) 162.06,173.77 CM23.2 RM17.1 ; v2(187.02,10.26) 187.17,10.1 JTP.18 ; CM17.2 CM16.2 ; DT15.1 v2(207.53,168.69) ; PC212.2 v2(94.94,40.1) ; v2(274.41,25.36) JSSD2.76 ; v2(195.08,158.02) CT99.2 ; CA18.2 38.06,24.19 37.55,23.68 v2(36.22,23.68) ; v2(240.04,50.51) 240.55,50.51 CG223.2 ; v2(212.86,118.73) CG75.1 ; v2(192.55,42.84) CH47.2 ; PC4.2 v2(74.68,30.94) ; CE61.2 v2(220.8,164.85) ; PR6057.1 v2(280.87,134.27) ; CE87.2 v2(276.35,33.26) ; CT104.2 v2(203.15,168.62)
  vias: v2(2.96,69.8) v2(3.69,30.64) v2(4.02,71.63) v2(4.02,67.97) v2(4.46,50.8) v2(5.52,52.63) v2(5.52,48.97) v2(6.12,71.63) v2(6.12,67.97) v2(7.18,69.8) v2(7.62,52.63) v2(7.62,48.97) v2(7.77,72.67) v2(8.68,50.8) v2(8.7,45.13) v2(11.25,30.66) v2(12.33,47.66) v2(12.96,47.66) v2(13.28,39.05) v2(13.66,47.66) v2(14.36,47.66) v2(14.94,70.1) v2(16.04,61.39) v2(16.39,56.95) v2(17.14,62.81) v2(17.3,53.44) v2(17.3,52.38) v2(17.3,51.31) v2(18.44,53.44) v2(18.44,52.38) v2(18.44,51.31) v2(19.66,11.5) v2(19.96,4.2) v2(20.86,13.59) v2(20.86,9.41) v2(21.02,6.03) v2(21.02,2.37) v2(21.59,0.43) v2(22.15,57.07) v2(22.33,44.58) v2(23.12,6.03) v2(23.12,2.37) v2(23.28,13.59) v2(23.28,9.41) v2(23.69,43.28) v2(23.69,42.64) v2(24.2,4.2) v2(24.33,43.28) v2(24.33,42.64) v2(24.51,11.51) v2(24.77,37.18) v2(25.96,54) v2(26.36,46.7) v2(26.42,39.28) v2(27.02,55.83) v2(27.02,52.17) v2(29.12,55.83) v2(29.12,52.17) v2(29.21,0.43) v2(29.73,56.57) v2(30.15,32.58) v2(30.15,30.51) v2(30.15,28.44) v2(30.18,54) v2(31.98,11.88) v2(31.98,10.51) v2(31.98,9.12) v2(31.98,7.74) v2(32.22,32.58) v2(32.22,30.51) v2(32.22,28.44) v2(33.36,11.88) v2(33.36,10.51) v2(33.36,9.12) v2(33.36,7.74) v2(34.29,32.58) v2(34.29,30.51) v2(34.29,28.44) v2(34.74,11.88) v2(34.74,10.51) v2(34.74,9.12) v2(34.74,7.74) v2(36.12,11.88) v2(36.12,10.51) v2(36.12,9.12) v2(36.12,7.74) v2(36.76,53.57) v2(36.83,0.43) v2(37.6,19.78) v2(37.6,19.15) v2(38.24,19.78) v2(38.24,19.15) v2(38.68,50.58) v2(38.87,19.78) v2(38.87,19.15) v2(39.38,50.58) v2(42.53,27.9) v2(42.53,27.26) v2(42.53,26.63) v2(42.98,4.93) v2(43.16,27.9) v2(43.16,27.26) v2(43.16,26.63) v2(43.63,40.72) v2(44.34,52.94) v2(44.3,40.76) v2(47.57,32.48) v2(47.98,32.91) v2(48.27,34.65) v2(48.23,34.07) v2(48.23,33.48) v2(48.37,32.46) v2(48.8,34.89) v2(48.8,34.26) v2(48.82,33.63) v2(48.8,32.93) v2(49.31,35.85) v2(49.31,35.21) v2(49.31,34.58) v2(49.31,33.94) v2(49.31,33.24) v2(49.31,32.61) v2(49.86,36.23) v2(49.86,35.59) v2(49.86,34.96) v2(49.86,34.32) v2(49.86,33.62) v2(49.86,32.99) v2(50.6,4.93) v2(51.87,51.06) v2(53.24,45.68) v2(53.86,46.3) v2(53.86,45.05) v2(54.49,45.68) v2(56.22,10.15) v2(56.22,9.57) v2(56.37,23.3) v2(56.37,21.16) v2(57.44,22.23) v2(58.07,3.43) v2(58.51,23.3) v2(58.51,21.16) v2(59.16,20.57) v2(59.49,51.06) v2(59.75,20.57) v2(61.48,25.62) v2(61.48,24.99) v2(62.11,25.62) v2(62.11,24.99) v2(62.11,24.35) v2(62.75,25.62) v2(62.75,24.99) v2(62.75,24.35) v2(65.69,3.43) v2(66.87,5.37) v2(66.87,4.6) v2(67.08,51.57) v2(67.82,48.23) v2(67.95,50.45) v2(67.95,49.82) v2(68.59,50.45) v2(68.59,49.82) v2(69.22,50.45) v2(69.22,49.82) v2(69.86,50.45) v2(69.86,49.82) v2(70.49,50.45) v2(70.49,49.82) v2(71.19,50.45) v2(71.19,49.82) v2(71.83,50.45) v2(71.83,49.82) v2(72.46,50.45) v2(72.46,49.82) v2(73.04,5.43) v2(73.1,50.45) v2(73.1,49.82) v2(73.73,50.45) v2(73.73,49.82) v2(74.37,50.45) v2(74.37,49.82) v2(74.7,51.57) v2(75,50.45) v2(75,49.82) v2(75.64,50.45) v2(75.64,49.82) v2(75.82,48.22) v2(76.44,18.5) v2(76.7,19.07) v2(76.82,17.93) v2(77.08,18.5) v2(77.33,19.07) v2(77.46,17.93) v2(77.71,18.5) v2(77.97,19.07) v2(78.1,17.93) v2(78.35,18.5) v2(78.6,19.07) v2(78.73,17.93) v2(78.98,18.5) v2(79.24,19.07) v2(79.37,17.93) v2(79.62,18.5) v2(80.66,5.43) v2(80.78,19.87) v2(81.42,19.87) v2(82.32,51.57) v2(84.02,33.75) v2(84.46,33.31) v2(84.53,34.13) v2(84.91,33.69) v2(84.91,32.86) v2(85.35,33.24) v2(85.35,32.42) v2(85.8,32.8) v2(88.27,49.82) v2(88.28,5.43) v2(88.91,49.82) v2(89.8,53.04) v2(90.76,56.9) v2(90.88,27.02) v2(90.88,26.32) v2(91.58,27.02) v2(91.58,26.32) v2(91.82,58.73) v2(91.82,55.07) v2(92.07,44) v2(92.27,27.02) v2(92.27,26.32) v2(92.53,60.15) v2(92.69,44.62) v2(92.69,43.38) v2(92.97,27.02) v2(92.97,26.32) v2(93.32,44) v2(93.92,58.73) v2(93.92,55.07) v2(93.99,32.73) v2(93.99,32.1) v2(93.99,31.46) v2(94.31,34.51) v2(94.31,33.88) v2(94.31,33.24) v2(94.62,32.73) v2(94.62,32.1) v2(94.62,31.46) v2(94.94,34.51) v2(94.94,33.88) v2(94.94,33.24) v2(94.98,56.9) v2(95.26,32.73) v2(95.26,32.1) v2(95.26,31.46) v2(95.9,5.37) v2(98.69,41.24) v2(98.69,40.55) v2(99.05,64.09) v2(99.67,71.69) v2(99.96,6.5) v2(100.88,46.42) v2(101.02,8.33) v2(101.02,4.67) v2(103.12,8.33) v2(103.13,4.67) v2(103.27,3.43) v2(104.18,6.5) v2(104.48,77.6) v2(105.8,13.37) v2(110.89,3.43) v2(110.99,91.32) v2(112.06,44.76) v2(112.06,43.49) v2(112.51,98.79) v2(112.68,57.17) v2(112.68,55.9) v2(112.68,54.63) v2(112.85,159.74) v2(112.85,152.12) v2(112.85,144.5) v2(112.85,136.88) v2(112.85,129.26) v2(112.85,121.64) v2(112.85,114.02) v2(112.85,106.4) v2(114.01,44.69) v2(114.01,42.79) v2(114.07,57.49) v2(114.07,55.59) v2(115.34,57.17) v2(115.34,55.9) v2(115.34,54.63) v2(115.34,44.37) v2(115.34,43.1) v2(115.34,41.83) v2(117.38,57.17) v2(117.38,55.9) v2(117.38,54.63) v2(117.63,44.37) v2(117.63,43.1) v2(117.63,41.83) v2(118,115.55) v2(118.51,3.43) v2(118.59,115.55) v2(119.04,41.52) v2(119.19,54.32) v2(119.38,163.67) v2(120.25,100.73) v2(120.59,57.17) v2(120.59,55.9) v2(120.59,44.37) v2(120.59,43.1) v2(120.91,120.37) v2(120.91,119.78) v2(120.91,119.2) v2(121.15,118.66) v2(121.61,116.3) v2(121.74,118.68) v2(121.68,113.94) v2(122.95,57.17) v2(122.95,55.9) v2(122.95,44.37) v2(122.95,43.1) v2(124.51,143.05) v2(124.51,141.08) v2(124.51,139.12) v2(124.63,44.69) v2(124.63,42.79) v2(124.69,57.49) v2(124.69,55.59) v2(125.23,134.53) v2(126.13,3.43) v2(126.18,98.88) v2(126.43,134.53) v2(126.47,143.05) v2(126.47,141.08) v2(126.47,139.12) v2(126.51,57.17) v2(126.51,55.9) v2(126.51,54.63) v2(126.63,99.33) v2(126.63,44.37) v2(126.63,43.1) v2(126.63,41.83) v2(126.89,162.37) v2(127.9,105.51) v2(128.34,154.66) v2(128.28,105.98) v2(128.44,143.05) v2(128.44,141.08) v2(128.44,139.12) v2(128.99,107.96) v2(129.02,57.17) v2(129.02,55.9) v2(129.02,54.63) v2(129.02,44.37) v2(129.02,43.1) v2(129.02,41.83) v2(130.1,156.18) v2(130.1,154.66) v2(130.29,56.22) v2(130.29,54.32) v2(130.51,93.31) v2(130.57,94.2) v2(130.8,43.42) v2(130.8,41.52) v2(130.88,98.16) v2(131.26,138.27) v2(131.86,157.7) v2(131.86,156.18) v2(131.86,154.66) v2(131.86,90.14) v2(132.09,160.67) v2(132.17,57.17) v2(132.17,55.9) v2(132.17,54.63) v2(132.17,44.37) v2(132.17,43.1) v2(132.17,41.83) v2(132.99,91.5) v2(133.62,157.7) v2(133.62,156.18) v2(133.62,154.66) v2(133.75,3.43) v2(133.79,146.92) v2(134.38,92.62) v2(134.51,162.37) v2(135.11,149.07) v2(135.1,89.9) v2(135.08,88.1) v2(135.25,41.89) v2(135.38,157.7) v2(135.38,156.18) v2(135.38,154.66) v2(136.07,91.51) v2(136.18,161.73) v2(136.66,44.36) v2(136.66,43.04) v2(136.66,41.77) v2(136.99,160.89) v2(137.09,89.81) v2(137.5,159.37) v2(137.62,57.45) v2(137.61,56.16) v2(137.61,54.7) v2(137.61,53.36) v2(138.13,44.32) v2(138.12,43.03) v2(138.4,91.09) v2(138.57,104) v2(139.08,113.31) v2(139.3,115.33) v2(139.34,109.82) v2(139.72,113.31) v2(139.72,44.25) v2(139.72,42.95) v2(139.72,41.58) v2(139.85,57.05) v2(139.85,55.75) v2(140.06,115.34) v2(140.03,90.96) v2(139.98,89.13) v2(140.16,106.58) v2(140.16,105.31) v2(140.41,104) v2(141.05,104) v2(141.37,3.43) v2(141.55,180.52) v2(141.55,172.65) v2(141.55,165.28) v2(141.56,113.31) v2(141.64,115.34) v2(141.62,109.82) v2(141.59,44.39) v2(141.59,43.01) v2(141.61,41.79) v2(141.72,57.19) v2(141.69,55.81) v2(142.19,113.31) v2(142.29,144.86) v2(142.29,144.16) v2(142.46,171.5) v2(142.4,115.35) v2(142.45,106.65) v2(142.45,105.38) v2(142.77,146.87) v2(142.83,104) v2(143.06,123.69) v2(143.06,123.05) v2(143.07,88.42) v2(143.07,87.15) v2(143.14,145.73) v2(143.46,104) v2(143.52,173.33) v2(143.52,169.67) v2(143.54,148.99) v2(143.7,123.69) v2(143.7,123.05) v2(143.79,145.73) v2(143.97,115.34) v2(144.03,113.31) v2(143.97,109.82) v2(144.04,57.23) v2(144.04,55.96) v2(144.04,54.72) v2(144.04,53.45) v2(143.98,44.43) v2(143.98,43.16) v2(143.98,41.92) v2(144.44,145.73) v2(144.4,123.69) v2(144.4,123.05) v2(144.45,91.96) v2(144.43,89.36) v2(144.67,113.31) v2(144.67,106.65) v2(144.67,105.38) v2(144.79,115.34) v2(145.03,123.69) v2(145.03,123.05) v2(145.09,145.73) v2(145.42,158.46) v2(145.43,104) v2(145.62,173.33) v2(145.62,169.67) v2(145.62,56.22) v2(145.62,54.95) v2(145.62,53.04) v2(145.62,45.07) v2(145.62,43.16) v2(145.62,41.89) v2(145.73,145.73) v2(146.07,104) v2(146.1,132.8) v2(146.16,87.49) v2(146.16,85.58) v2(146.31,158.46) v2(146.4,115.34) v2(146.45,113.31) v2(146.38,109.82) v2(146.56,149.13) v2(146.57,143.35) v2(146.57,142.76) v2(146.57,142.18) v2(146.57,141.59) v2(146.57,141.01) v2(146.57,140.43) v2(146.68,171.5) v2(146.69,132.8) v2(147.02,106.65) v2(147.02,105.38) v2(147.17,145.19) v2(147.17,144.6) v2(147.17,144.02) v2(147.16,143.35) v2(147.16,142.76) v2(147.16,142.18) v2(147.16,141.59) v2(147.16,141.01) v2(147.16,140.43) v2(147.13,115.35) v2(147.15,113.34) v2(147.2,158.46) v2(147.3,90.22) v2(147.3,88.25) v2(147.46,11.84) v2(147.46,11.21) v2(147.75,145.19) v2(147.75,144.6) v2(147.75,144.02) v2(147.74,143.35) v2(147.74,142.76) v2(147.74,142.18) v2(147.74,141.59) v2(147.74,141.01) v2(147.74,140.43) v2(147.84,104.04) v2(148.19,184.16) v2(148.22,158.46) v2(148.22,11.84) v2(148.22,11.21) v2(148.39,144.59) v2(148.38,144) v2(148.37,143.33) v2(148.37,142.75) v2(148.37,142.17) v2(148.37,141.58) v2(148.37,141) v2(148.44,104.04) v2(148.47,44.94) v2(148.47,43.41) v2(148.47,41.89) v2(148.73,115.34) v2(148.86,109.82) v2(148.86,57.74) v2(148.86,56.21) v2(148.86,54.69) v2(148.86,53.16) v2(148.99,113.38) v2(148.99,3.43) v2(149.23,158.46) v2(149.37,106.65) v2(149.37,105.38) v2(149.37,79.47) v2(149.37,78.23) v2(149.37,76.96) v2(149.5,115.33) v2(149.58,113.38) v2(149.62,111.73) v2(150.12,158.46) v2(150.26,104.04) v2(150.62,144.88) v2(150.62,144.19) v2(150.81,79.38) v2(150.81,78.79) v2(150.81,78.21) v2(150.81,77.63) v2(150.81,75.12) v2(150.81,74.54) v2(150.81,73.96) v2(150.81,73.37) v2(150.89,104.04) v2(150.91,55.96) v2(150.91,54.43) v2(151.06,92.42) v2(151.04,90.53) v2(150.99,44.94) v2(150.99,43.41) v2(150.99,41.89) v2(151.1,146.9) v2(151.1,115.34) v2(151.2,87.72) v2(151.21,85.92) v2(151.34,113.38) v2(151.4,111.73) v2(151.47,145.75) v2(151.59,106.58) v2(151.59,105.31) v2(151.85,115.34) v2(151.87,149.02) v2(152.04,113.38) v2(152.12,145.75) v2(152.29,91.69) v2(152.3,89.86) v2(152.4,87.97) v2(152.77,145.75) v2(152.85,56.21) v2(152.85,54.69) v2(152.85,44.94) v2(152.85,43.41) v2(152.85,41.89) v2(152.99,169.55) v2(153.42,145.75) v2(153.44,115.3) v2(153.61,41.25) v2(154.07,145.75) v2(154.13,113.76) v2(154.25,115.34) v2(154.38,108.49) v2(154.45,103.66) v2(154.65,143.31) v2(154.65,142.72) v2(154.65,142.14) v2(154.68,170.9) v2(154.77,110.39) v2(154.78,141.04) v2(154.78,140.45) v2(154.84,91.84) v2(154.82,90.53) v2(154.84,89.22) v2(154.84,87.99) v2(154.95,149.26) v2(154.89,132.68) v2(155.06,141.56) v2(155.23,143.31) v2(155.23,142.72) v2(155.23,142.14) v2(155.36,141.04) v2(155.36,140.45) v2(155.49,144.43) v2(155.49,143.84) v2(155.52,132.68) v2(155.58,149.26) v2(155.64,141.56) v2(155.82,183.77) v2(155.82,143.31) v2(155.82,142.72) v2(155.82,142.14) v2(155.94,141.04) v2(155.94,140.45) v2(155.97,113.76) v2(156.07,144.43) v2(156.07,143.84) v2(156.23,108.49) v2(156.23,103.66) v2(156.35,145.19) v2(156.34,57.22) v2(156.34,55.95) v2(156.34,54.68) v2(156.38,170.43) v2(156.46,44.42) v2(156.46,43.15) v2(156.46,41.88) v2(156.47,142.78) v2(156.61,115.35) v2(156.61,113.76) v2(156.61,3.43) v2(156.73,144.62) v2(156.86,108.49) v2(156.86,103.66) v2(156.88,127.44) v2(156.88,126.86) v2(156.99,110.39) v2(157.3,91.3) v2(157.43,171.44) v2(157.46,127.44) v2(157.46,126.86) v2(157.74,172.63) v2(157.84,44.73) v2(157.84,42.83) v2(158.05,127.44) v2(158.05,126.86) v2(158.09,57.6) v2(158.09,55.63) v2(158.18,115.34) v2(158.26,89.56) v2(158.31,141.62) v2(158.31,140.93) v2(158.39,113.76) v2(158.63,127.44) v2(158.63,126.86) v2(158.58,110.39) v2(158.64,108.49) v2(158.64,103.66) v2(158.79,143.63) v2(158.96,115.34) v2(159.02,113.76) v2(159.16,142.49) v2(159.14,88.07) v2(159.27,108.49) v2(159.27,103.66) v2(159.38,146.03) v2(159.63,44.43) v2(159.63,43.16) v2(159.63,41.89) v2(159.7,57.23) v2(159.7,55.96) v2(159.7,54.69) v2(159.8,142.49) v2(159.86,90.94) v2(160.45,142.49) v2(160.52,115.34) v2(160.73,110.39) v2(160.81,167.45) v2(160.82,166.86) v2(160.8,113.76) v2(161.05,108.49) v2(161.05,103.66) v2(161.1,142.49) v2(161.21,89.59) v2(161.33,115.35) v2(161.43,113.76) v2(161.65,103.66) v2(161.66,57.3) v2(161.66,56.03) v2(161.66,54.76) v2(161.66,44.5) v2(161.66,43.23) v2(161.66,41.96) v2(161.75,142.49) v2(161.69,108.49) v2(162,170.6) v2(162.07,110.39) v2(162.26,140.1) v2(162.26,139.51) v2(162.26,138.93) v2(162.26,138.34) v2(162.26,137.76) v2(162.51,88.29) v2(162.63,146.02) v2(162.84,140.1) v2(162.84,139.51) v2(162.84,138.93) v2(162.84,138.34) v2(162.84,137.76) v2(162.93,115.35) v2(163.26,146.02) v2(163.21,113.76) v2(163.27,91.28) v2(163.44,183.77) v2(163.42,140.1) v2(163.42,139.51) v2(163.42,138.93) v2(163.42,138.34) v2(163.42,137.76) v2(163.47,108.49) v2(163.44,103.66) v2(163.51,56.34) v2(163.51,54.44) v2(163.51,43.54) v2(163.51,41.64) v2(163.66,115.36) v2(163.85,113.25) v2(163.85,112.67) v2(164.06,140.08) v2(164.06,139.5) v2(164.06,138.91) v2(164.06,138.33) v2(164.06,137.75) v2(164.04,103.66) v2(164.23,105.88) v2(164.23,3.43) v2(164.5,175.67) v2(164.55,90.03) v2(164.66,167.37) v2(164.64,140.08) v2(164.64,139.5) v2(164.64,138.91) v2(164.64,138.33) v2(164.64,137.75) v2(164.72,141.84) v2(164.72,141.25) v2(164.72,140.67) v2(165.12,105.88) v2(165.25,167.35) v2(165.36,170.78) v2(165.34,57.23) v2(165.34,55.96) v2(165.34,54.69) v2(165.34,44.43) v2(165.34,43.16) v2(165.34,41.89) v2(165.88,103.66) v2(166,88.61) v2(166.23,91.46) v2(166.45,111.47) v2(166.45,110.89) v2(166.64,141.57) v2(166.64,140.88) v2(167.12,143.58) v2(167.25,57.3) v2(167.25,56.03) v2(167.25,54.76) v2(167.18,44.5) v2(167.18,43.23) v2(167.18,41.96) v2(167.49,142.44) v2(167.65,168.87) v2(167.89,145.7) v2(168.14,142.44) v2(168.28,91.93) v2(168.78,142.44) v2(169.02,57.61) v2(169.02,55.71) v2(169.02,44.81) v2(169.02,42.91) v2(169.43,142.44) v2(169.87,127.35) v2(170.08,142.44) v2(170.46,127.35) v2(170.8,57.23) v2(170.8,55.96) v2(170.8,44.43) v2(170.8,43.16) v2(170.92,140.06) v2(170.92,139.47) v2(170.92,138.89) v2(170.92,138.31) v2(170.92,137.72) v2(170.96,79.34) v2(170.96,78.76) v2(170.96,77.79) v2(170.96,77.21) v2(170.97,75.53) v2(170.97,74.95) v2(170.97,74.36) v2(170.97,73.78) v2(171.06,183.77) v2(171.04,127.35) v2(171.18,145.97) v2(171.51,141.9) v2(171.51,141.31) v2(171.51,140.73) v2(171.5,140.06) v2(171.5,139.47) v2(171.5,138.89) v2(171.5,138.31) v2(171.5,137.72) v2(171.62,127.35) v2(171.81,145.97) v2(171.85,3.43) v2(172.1,141.9) v2(172.1,141.31) v2(172.1,140.73) v2(172.09,140.06) v2(172.09,139.47) v2(172.09,138.89) v2(172.09,138.31) v2(172.09,137.72) v2(172.55,175.29) v2(172.72,141.9) v2(172.71,141.31) v2(172.73,140.73) v2(172.72,140.04) v2(172.72,139.46) v2(172.72,138.88) v2(172.72,138.29) v2(172.72,137.71) v2(173.14,175.29) v2(173.15,57.23) v2(173.15,55.96) v2(173.15,54.69) v2(173.15,44.43) v2(173.15,43.16) v2(173.15,41.89) v2(173.6,151.34) v2(173.72,175.29) v2(174.43,175.62) v2(174.43,175.04) v2(174.43,173.96) v2(174.74,56.28) v2(174.74,54.38) v2(174.74,43.48) v2(174.74,41.57) v2(174.98,141.59) v2(174.98,140.9) v2(175.26,105.92) v2(175.46,143.61) v2(175.46,128.37) v2(175.46,127.73) v2(175.47,104.09) v2(175.78,171.55) v2(175.83,142.46) v2(175.85,96.93) v2(175.78,94.96) v2(175.96,128.69) v2(175.96,128.05) v2(176.04,102.58) v2(176.01,101.1) v2(176.23,145.73) v2(176.44,99.15) v2(176.48,142.46) v2(176.71,57.23) v2(176.71,55.96) v2(176.77,163.16) v2(176.83,44.43) v2(176.83,43.16) v2(176.83,41.89) v2(177.13,142.46) v2(177.56,6.5) v2(177.75,102.58) v2(177.73,101.11) v2(177.78,142.46) v2(177.87,36.48) v2(178.38,173.2) v2(178.42,142.46) v2(178.44,43.7) v2(178.52,185.32) v2(178.62,8.33) v2(178.62,4.67) v2(178.76,173.64) v2(179.01,140.08) v2(179.01,139.5) v2(179.01,138.91) v2(179.16,138.33) v2(179.16,137.75) v2(179.27,145.89) v2(179.27,39.02) v2(179.27,37.69) v2(179.33,171.16) v2(179.41,137.16) v2(179.47,3.43) v2(179.59,140.08) v2(179.59,139.5) v2(179.59,138.91) v2(179.74,138.33) v2(179.74,137.75) v2(179.86,141.28) v2(179.86,140.69) v2(179.97,171.16) v2(180,168.36) v2(180,137.16) v2(180.2,173.77) v2(180.18,140.08) v2(180.18,139.5) v2(180.18,138.91) v2(180.33,138.33) v2(180.33,137.75) v2(180.44,141.28) v2(180.44,140.69) v2(180.63,137.13) v2(180.72,8.33) v2(180.74,4.64) v2(180.81,140.07) v2(180.81,139.49) v2(180.81,138.9) v2(180.96,138.32) v2(180.96,137.73) v2(181.07,140.67) v2(181.11,180.1) v2(181.3,166.41) v2(181.3,165.76) v2(181.78,6.5) v2(181.95,168.34) v2(181.95,165.76) v2(182,173.77) v2(182.05,139.96) v2(182.17,181.93) v2(182.17,178.27) v2(182.6,162.51) v2(183.02,142.07) v2(183.08,144.75) v2(183.25,161.85) v2(183.26,141.01) v2(183.9,161.19) v2(184.05,141.01) v2(184.27,181.93) v2(184.27,178.27) v2(184.85,141.01) v2(184.85,139.96) v2(184.86,126.33) v2(185.33,180.1) v2(185.3,126.78) v2(185.53,172.51) v2(185.72,127.19) v2(186.19,127.6) v2(186.36,21.44) v2(186.36,18.45) v2(187.14,184.93) v2(187.09,3.43) v2(187.32,172.5) v2(187.85,19.94) v2(189.24,172.78) v2(189.24,171.03) v2(189.35,21.44) v2(189.49,165.51) v2(189.62,158.34) v2(189.62,157.7) v2(189.95,27.03) v2(190.13,30) v2(190.38,166.72) v2(190.54,29.5) v2(190.55,27.03) v2(190.87,30.07) v2(191.23,22.66) v2(191.63,163.54) v2(191.65,162.58) v2(191.78,164.62) v2(192.41,139.48) v2(192.54,164.69) v2(192.54,143.67) v2(192.54,142.27) v2(194.41,111.47) v2(194.65,39.65) v2(194.71,3.43) v2(194.96,17.22) v2(194.96,16.63) v2(195.24,131.98) v2(195.24,130.71) v2(195.4,125.56) v2(195.76,55.6) v2(195.75,37.26) v2(196.1,165.64) v2(196.28,160.41) v2(196.3,38.9) v2(196.6,124.29) v2(196.66,111.79) v2(196.82,57.43) v2(196.82,53.77) v2(196.88,24.1) v2(196.99,181.58) v2(197.42,133.25) v2(197.42,131.98) v2(197.42,130.71) v2(197.76,18.83) v2(198.02,36.26) v2(197.98,32.06) v2(198.02,31.15) v2(198.51,27.41) v2(198.51,26.37) v2(198.47,25.13) v2(198.95,125.64) v2(198.92,57.43) v2(198.92,53.77) v2(198.97,37.68) v2(199.03,35.84) v2(199.02,34.8) v2(199.2,161.17) v2(199.61,131.98) v2(199.61,130.71) v2(199.83,164.03) v2(199.86,38.36) v2(199.79,23.08) v2(199.98,55.6) v2(200.03,37) v2(200.03,34.84) v2(200.11,180.1) v2(200.19,33.2) v2(200.86,169.39) v2(200.81,27.52) v2(201.07,34.85) v2(201,23.3) v2(200.99,22.49) v2(201.17,181.93) v2(201.17,178.27) v2(201.3,125.64) v2(201.56,161.04) v2(201.79,133.25) v2(201.79,131.98) v2(201.79,130.71) v2(201.91,38.4) v2(202.03,164.05) v2(202.04,33.24) v2(202.05,32.55) v2(202,20.92) v2(202.12,162.84) v2(202.14,162.26) v2(202.14,161.67) v2(202.14,161.09) v2(202.15,35.72) v2(202.13,34.91) v2(202.07,24.53) v2(202.33,3.43) v2(202.56,48.5) v2(202.76,139.67) v2(202.76,128.81) v2(202.83,138.34) v2(203.17,135.21) v2(203.27,181.93) v2(203.27,178.27) v2(203.39,21.51) v2(203.81,50.68) v2(203.81,46.32) v2(204.34,180.09) v2(204.36,38.46) v2(204.36,34.91) v2(204.36,20.98) v2(204.38,37.18) v2(204.38,36.48) v2(204.38,35.54) v2(205.18,103.92) v2(205.68,23.22) v2(205.81,103.92) v2(206.33,50.68) v2(206.33,46.32) v2(206.73,33.22) v2(206.76,23.83) v2(207.58,48.5) v2(207.86,34.08) v2(207.87,24.53) v2(207.84,23.79) v2(207.8,21.54) v2(208.44,181.94) v2(208.57,169.45) v2(209.01,38.4) v2(209.22,22.3) v2(209.46,164.77) v2(209.66,129.23) v2(209.69,174.42) v2(209.95,3.43) v2(210.05,34.69) v2(210.13,20.74) v2(210.27,23.9) v2(210.33,23.08) v2(212.08,167.96) v2(212.23,170.28) v2(212.17,23.05) v2(212.18,22.49) v2(212.29,147.92) v2(212.29,147.23) v2(212.77,149.93) v2(212.94,98.25) v2(213.14,148.79) v2(213.19,140.94) v2(213.19,140.3) v2(213.62,152.11) v2(213.79,148.79) v2(213.78,140.94) v2(213.78,140.3) v2(213.93,121.97) v2(213.91,36.13) v2(214.07,170.28) v2(214.17,98.24) v2(214.34,168.04) v2(214.36,140.94) v2(214.36,140.3) v2(214.44,148.79) v2(214.39,56.11) v2(214.94,140.94) v2(214.94,140.3) v2(215.09,148.79) v2(215.25,39.95) v2(215.53,140.94) v2(215.53,140.3) v2(215.73,148.79) v2(215.86,39.97) v2(216.24,86.37) v2(216.57,98.3) v2(216.63,81.82) v2(216.82,101.05) v2(217,17.91) v2(217.4,86.38) v2(217.5,153.26) v2(217.5,152.62) v2(217.57,3.43) v2(217.69,145.96) v2(218.13,153.26) v2(218.13,152.62) v2(218.27,145.96) v2(218.52,115.12) v2(218.52,80.85) v2(218.63,81.85) v2(218.77,153.26) v2(218.77,152.62) v2(218.86,145.96) v2(218.96,144.69) v2(218.96,143.42) v2(218.96,117.06) v2(219.1,142.21) v2(219.1,141.57) v2(219.1,140.94) v2(219.1,140.3) v2(219.1,139.67) v2(219.1,139.03) v2(219.22,116.2) v2(219.29,81.08) v2(219.4,153.26) v2(219.4,152.62) v2(219.44,145.96) v2(219.44,118.78) v2(219.54,144.69) v2(219.54,143.42) v2(219.68,142.21) v2(219.68,141.57) v2(219.68,140.94) v2(219.68,140.3) v2(219.68,139.67) v2(219.68,139.03) v2(219.89,116.93) v2(220.04,153.26) v2(220.04,152.62) v2(220.02,145.96) v2(220.03,118.78) v2(220.13,144.69) v2(220.13,143.42) v2(220.09,105.83) v2(220.09,103.76) v2(220.1,101.63) v2(220.08,95.55) v2(220.12,91.4) v2(220.12,89.25) v2(220.26,142.21) v2(220.26,141.57) v2(220.26,140.94) v2(220.26,140.3) v2(220.26,139.67) v2(220.26,139.03) v2(220.23,134.78) v2(220.23,134.14) v2(220.19,97.71) v2(220.27,93.35) v2(220.24,85.16) v2(220.43,112.14) v2(220.53,155.58) v2(220.61,145.96) v2(220.61,118.78) v2(220.65,105.83) v2(220.65,103.73) v2(220.65,97.4) v2(220.63,84.73) v2(220.67,153.26) v2(220.67,152.62) v2(220.71,144.69) v2(220.71,143.42) v2(220.75,83.22) v2(220.85,142.21) v2(220.85,141.57) v2(220.85,140.94) v2(220.85,140.3) v2(220.85,139.67) v2(220.85,139.03) v2(220.86,134.78) v2(220.86,134.14) v2(220.77,95.15) v2(220.77,93.05) v2(220.78,78.73) v2(221.12,155.58) v2(221.18,170.47) v2(221.19,145.96) v2(221.31,153.26) v2(221.31,152.62) v2(221.29,144.69) v2(221.29,143.42) v2(221.43,142.21) v2(221.43,141.57) v2(221.43,140.94) v2(221.43,140.3) v2(221.43,139.67) v2(221.43,139.03) v2(221.42,107.65) v2(221.4,83.87) v2(221.37,82.55) v2(221.5,134.78) v2(221.5,134.14) v2(221.48,97.84) v2(221.47,88.95) v2(221.47,81.85) v2(221.47,81.15) v2(221.7,155.58) v2(221.94,153.26) v2(221.94,152.62) v2(221.88,144.69) v2(221.88,143.42) v2(221.94,128.82) v2(221.94,128.24) v2(222.02,142.21) v2(222.04,141.57) v2(222.04,140.94) v2(222.04,140.3) v2(222.04,139.67) v2(222.04,139.03) v2(222.03,101.53) v2(222.02,89.35) v2(222.02,85.2) v2(222.13,134.78) v2(222.13,134.14) v2(222.12,110.45) v2(222.07,109.85) v2(222.07,93.65) v2(222.11,91.58) v2(222.46,144.69) v2(222.46,143.42) v2(222.64,142.21) v2(222.63,141.57) v2(222.63,140.94) v2(222.63,140.3) v2(222.63,139.67) v2(222.63,139.03) v2(222.77,106.25) v2(222.77,104.15) v2(222.85,102.04) v2(222.82,97.21) v2(222.77,88.8) v2(222.86,85.25) v2(222.87,84.55) v2(223.08,144.69) v2(223.08,143.42) v2(223.22,142.21) v2(223.21,141.57) v2(223.21,140.94) v2(223.21,140.3) v2(223.21,139.67) v2(223.21,139.03) v2(223.3,91.49) v2(223.32,89) v2(223.67,144.69) v2(223.67,143.42) v2(223.57,107.75) v2(223.57,103.55) v2(223.57,93.05) v2(223.86,140.3) v2(223.85,139.67) v2(223.85,139.03) v2(224.17,107.65) v2(224.27,105.65) v2(224.17,101.45) v2(224.2,97.87) v2(224.23,88.86) v2(224.44,140.3) v2(224.43,139.67) v2(224.43,139.03) v2(224.47,128.8) v2(224.48,128.22) v2(224.67,79.4) v2(224.8,183.72) v2(224.8,176.1) v2(224.77,93.55) v2(224.87,106.35) v2(224.92,104.13) v2(224.92,102.09) v2(224.97,83.95) v2(224.97,81.15) v2(225.03,140.3) v2(225.01,139.67) v2(225.01,139.03) v2(225.19,3.43) v2(225.37,82.2) v2(225.61,140.3) v2(225.6,139.67) v2(225.6,139.03) v2(225.57,112.65) v2(225.57,85.35) v2(225.94,147.92) v2(225.94,147.23) v2(226.2,140.3) v2(226.18,139.67) v2(226.18,139.03) v2(226.43,149.93) v2(226.6,117.13) v2(226.77,139.67) v2(226.77,139.03) v2(226.79,148.79) v2(226.78,140.3) v2(226.97,82.55) v2(227.05,83.91) v2(227.08,128.87) v2(227.08,128.24) v2(227.13,114.78) v2(227.08,86.68) v2(227.25,115.32) v2(227.2,82.01) v2(227.35,139.67) v2(227.35,139.03) v2(227.34,136.18) v2(227.34,135.54) v2(227.38,152.13) v2(227.44,148.79) v2(227.4,140.3) v2(227.52,83.26) v2(227.64,169.01) v2(227.67,86.75) v2(227.65,85.98) v2(227.68,85.27) v2(227.99,140.3) v2(227.97,139.67) v2(227.97,139.03) v2(227.97,136.18) v2(227.97,135.54) v2(228.04,118.9) v2(228.09,148.79) v2(228.42,107.05) v2(228.42,90.15) v2(228.48,181.86) v2(228.61,136.18) v2(228.61,135.54) v2(228.57,35.64) v2(228.74,148.79) v2(229.12,107.05) v2(229.12,90.15) v2(229.15,35.64) v2(229.26,158.6) v2(229.39,148.79) v2(229.56,128.87) v2(229.56,128.24) v2(229.72,85.25) v2(229.87,83.95) v2(229.96,7.19) v2(229.96,6.56) v2(230.26,153.51) v2(230.26,152.88) v2(230.52,107.05) v2(230.52,99.25) v2(230.52,90.15) v2(230.89,153.51) v2(230.89,152.88) v2(231.34,146.02) v2(231.34,145.38) v2(231.32,83.86) v2(231.42,82) v2(231.53,153.51) v2(231.53,152.88) v2(231.8,175) v2(231.92,107.05) v2(231.92,105.65) v2(231.87,85.35) v2(231.97,146.02) v2(231.97,145.38) v2(232.16,153.51) v2(232.16,152.88) v2(232.16,128.87) v2(232.16,128.24) v2(232.81,153.3) v2(232.81,3.43) v2(233.05,153.83) v2(233.1,142.91) v2(233.1,141.95) v2(233.14,140.77) v2(233.12,140.05) v2(233.12,139.03) v2(233.32,107.05) v2(233.32,105.65) v2(233.32,90.15) v2(233.45,153.3) v2(233.37,141.37) v2(233.42,83.8) v2(233.52,84.76) v2(233.52,82) v2(233.69,153.83) v2(233.72,140.77) v2(233.7,140.05) v2(233.7,139.03) v2(233.96,141.37) v2(233.97,86.75) v2(233.97,85.95) v2(234.08,153.3) v2(234.32,153.83) v2(234.31,140.77) v2(234.32,140.05) v2(234.32,139.03) v2(234.51,128.81) v2(234.51,128.18) v2(234.58,141.37) v2(234.72,153.3) v2(234.72,107.05) v2(234.72,90.15) v2(234.77,98.65) v2(234.96,164.37) v2(234.96,153.83) v2(234.9,142.91) v2(234.9,141.95) v2(234.93,140.77) v2(234.91,140.05) v2(234.91,139.03) v2(235.16,141.37) v2(235.25,14.07) v2(235.35,153.3) v2(235.42,107.05) v2(235.42,90.15) v2(235.48,142.91) v2(235.48,141.95) v2(235.51,140.77) v2(235.54,140.05) v2(235.57,139.1) v2(235.7,146.02) v2(235.7,144.81) v2(235.72,143.8) v2(235.83,14.07) v2(235.97,153.51) v2(235.97,152.88) v2(236.1,142.91) v2(236.1,141.95) v2(236.14,140.77) v2(236.15,139.1) v2(236.18,140.05) v2(236.28,146.02) v2(236.28,144.81) v2(236.43,143.8) v2(236.42,14.07) v2(236.48,136.24) v2(236.48,135.6) v2(236.52,78.35) v2(236.52,77.1) v2(236.61,153.46) v2(236.61,152.88) v2(236.69,142.91) v2(236.69,141.95) v2(236.72,140.77) v2(236.74,139.1) v2(236.86,146.02) v2(236.86,144.81) v2(236.81,140.05) v2(236.82,107.05) v2(236.77,98.65) v2(236.82,90.15) v2(237.07,143.8) v2(237.12,136.24) v2(237.12,135.6) v2(237.12,128.81) v2(237.12,128.18) v2(237.26,168.05) v2(237.32,142.91) v2(237.32,141.95) v2(237.36,140.77) v2(237.45,146.02) v2(237.45,144.81) v2(237.44,140.05) v2(237.37,139.1) v2(237.69,143.8) v2(237.75,136.24) v2(237.75,135.6) v2(237.93,140.88) v2(238.02,140.05) v2(238.06,139.16) v2(238.22,107.05) v2(238.22,105.65) v2(238.22,104.25) v2(238.22,97.15) v2(238.22,94.35) v2(238.22,90.15) v2(238.31,47.29) v2(238.45,9.18) v2(238.51,140.88) v2(238.52,79.05) v2(238.64,140.05) v2(238.64,139.16) v2(238.57,77.3) v2(238.92,107.05) v2(238.92,105.65) v2(238.92,104.25) v2(238.92,94.35) v2(238.92,90.15) v2(238.9,47.29) v2(239.1,140.88) v2(239.23,140.05) v2(239.25,139.16) v2(239.42,174.87) v2(239.48,47.29) v2(239.66,147.98) v2(239.66,147.29) v2(239.72,140.88) v2(239.72,128.81) v2(239.72,128.18) v2(239.86,140.05) v2(239.84,139.16) v2(240.06,47.29) v2(240.14,150) v2(240.23,166.28) v2(240.23,164.75) v2(240.32,107.05) v2(240.32,94.35) v2(240.32,90.15) v2(240.43,3.43) v2(240.51,148.85) v2(240.62,78.65) v2(240.62,76.85) v2(240.62,75.69) v2(240.65,47.29) v2(240.96,74.77) v2(241.16,148.85) v2(241.41,79.69) v2(241.41,78.89) v2(241.47,76.76) v2(241.51,77.85) v2(241.72,107.05) v2(241.72,101.45) v2(241.72,94.35) v2(241.72,90.15) v2(241.81,148.85) v2(241.82,41.05) v2(241.85,38.5) v2(241.85,37.92) v2(241.92,82) v2(242.46,148.85) v2(242.46,38.65) v2(242.46,38.07) v2(242.53,14.14) v2(242.64,165.64) v2(243.1,148.85) v2(243.12,107.05) v2(243.12,101.45) v2(243.12,97.95) v2(243.12,94.35) v2(243.12,90.15) v2(243.73,153.58) v2(243.73,152.94) v2(243.75,120.05) v2(243.85,83.92) v2(244.01,86.15) v2(244.01,81.94) v2(244.04,38.7) v2(244.1,32.91) v2(244.15,18.96) v2(244.37,153.58) v2(244.37,152.94) v2(244.38,120.68) v2(244.38,120.05) v2(244.46,85.34) v2(244.47,82.55) v2(244.48,180.32) v2(244.52,90.15) v2(244.47,86.75) v2(244.48,84.58) v2(244.73,33.53) v2(244.73,32.29) v2(244.75,17.99) v2(245,153.58) v2(245,152.94) v2(244.99,146.08) v2(244.99,145.45) v2(245.22,107.05) v2(245.22,105.65) v2(245.22,90.15) v2(245.35,32.91) v2(245.34,18.96) v2(245.64,153.58) v2(245.64,152.94) v2(245.63,146.08) v2(245.63,145.45) v2(245.97,85.32) v2(246.12,82) v2(246.24,153.91) v2(246.24,153.27) v2(246.2,38.7) v2(246.42,86.45) v2(246.57,85.35) v2(246.87,153.91) v2(246.87,153.27) v2(246.88,143.1) v2(246.88,142.46) v2(246.88,141.83) v2(246.88,141.19) v2(246.9,140.56) v2(246.9,139.92) v2(247.47,141.19) v2(247.51,153.91) v2(247.51,153.27) v2(247.48,140.56) v2(247.48,139.92) v2(248.05,141.19) v2(248.05,3.43) v2(248.14,153.91) v2(248.14,153.27) v2(248.1,140.56) v2(248.12,139.94) v2(248.22,82) v2(248.67,143.1) v2(248.67,142.46) v2(248.67,141.83) v2(248.67,141.19) v2(248.69,140.56) v2(248.7,139.94) v2(248.78,153.91) v2(248.78,153.27) v2(248.77,88.99) v2(248.92,87.57) v2(249.26,143.1) v2(249.26,142.46) v2(249.26,141.83) v2(249.26,141.19) v2(249.32,140.56) v2(249.34,139.94) v2(249.51,153.87) v2(249.51,153.23) v2(249.87,143.73) v2(249.88,143.1) v2(249.88,142.46) v2(249.88,141.83) v2(249.88,141.19) v2(249.96,140.56) v2(249.97,139.94) v2(250.08,152.94) v2(250.25,86.87) v2(250.32,82) v2(250.45,143.73) v2(250.47,143.1) v2(250.47,142.46) v2(250.47,141.83) v2(250.47,141.19) v2(250.59,140.56) v2(250.61,139.94) v2(250.62,26.39) v2(250.71,128.94) v2(250.71,124.85) v2(250.77,45.56) v2(250.87,101.35) v2(250.87,87.35) v2(250.87,86.75) v2(251.04,143.73) v2(251.1,143.1) v2(251.1,142.46) v2(251.1,141.83) v2(251.1,141.19) v2(251.21,140.56) v2(251.23,139.94) v2(251.2,26.39) v2(251.34,128.94) v2(251.34,124.85) v2(251.41,45.56) v2(251.53,101.42) v2(251.63,86.8) v2(251.57,83.85) v2(251.98,128.94) v2(251.98,124.85) v2(252.02,101.93) v2(252.07,87.25) v2(252.11,93.51) v2(252.1,45.56) v2(252.17,83.85) v2(252.27,82.55) v2(252.74,45.56) v2(252.78,25.81) v2(252.92,107.73) v2(252.91,93) v2(252.92,86.78) v2(252.87,82.55) v2(252.97,85.24) v2(253.27,80.3) v2(253.44,148.05) v2(253.44,147.35) v2(253.41,25.81) v2(253.5,87.21) v2(253.52,84.75) v2(253.67,82.47) v2(253.69,23.15) v2(253.92,150.06) v2(254.05,25.81) v2(254.29,148.92) v2(254.34,81.78) v2(254.32,80.4) v2(254.33,23.15) v2(254.42,81) v2(254.54,122.71) v2(254.54,122.08) v2(254.54,120.94) v2(254.54,120.3) v2(254.58,5.05) v2(254.68,25.81) v2(254.79,108.2) v2(254.94,148.92) v2(254.96,23.15) v2(254.96,22.51) v2(254.99,81.13) v2(255.11,82.47) v2(255.22,5.05) v2(255.27,86.3) v2(255.32,25.81) v2(255.42,81.94) v2(255.59,148.92) v2(255.63,99.03) v2(255.6,23.15) v2(255.6,22.51) v2(255.67,3.43) v2(255.85,5.05) v2(255.95,25.81) v2(256.07,92.65) v2(256.23,148.92) v2(256.32,88.45) v2(256.65,15.29) v2(256.63,14.69) v2(256.72,111.74) v2(256.88,148.92) v2(257.23,15.29) v2(257.21,14.69) v2(257.33,84.72) v2(257.5,153.64) v2(257.5,153) v2(257.53,110.75) v2(257.64,112.39) v2(257.81,15.29) v2(257.79,14.69) v2(258.02,90.55) v2(258.14,153.64) v2(258.14,153) v2(258.17,92.65) v2(258.23,86.63) v2(258.34,113.32) v2(258.42,15.3) v2(258.77,153.64) v2(258.77,153) v2(258.83,145.51) v2(259.41,153.64) v2(259.41,153) v2(259.47,145.51) v2(259.77,90.4) v2(259.96,6.5) v2(260.07,153.97) v2(260.07,153.33) v2(260.04,123.98) v2(260.04,123.4) v2(260.04,122.78) v2(260.04,122.19) v2(259.97,93.07) v2(260.7,153.97) v2(260.7,153.33) v2(260.93,141.07) v2(260.93,140.43) v2(261.02,8.33) v2(261.02,4.67) v2(261.25,25.97) v2(261.34,153.97) v2(261.34,153.33) v2(261.51,141.07) v2(261.51,140.43) v2(261.82,159.67) v2(261.88,25.97) v2(261.97,153.97) v2(261.97,153.33) v2(262.14,141.07) v2(262.14,140.43) v2(262.44,159.67) v2(262.52,25.97) v2(262.61,153.97) v2(262.61,153.33) v2(262.72,141.07) v2(262.72,140.43) v2(263.03,159.67) v2(263.12,8.33) v2(263.12,4.67) v2(263.22,153.65) v2(263.36,141.07) v2(263.36,140.43) v2(263.29,3.43) v2(263.43,14.57) v2(263.49,183.17) v2(263.66,159.67) v2(263.66,144.88) v2(263.66,144.24) v2(263.57,17.57) v2(263.57,16.97) v2(263.86,153.64) v2(263.85,153.02) v2(263.79,124.05) v2(263.79,123.41) v2(263.79,122.78) v2(263.79,122.14) v2(264.03,14.57) v2(264.18,6.5) v2(264.42,126.59) v2(264.42,125.95) v2(264.42,125.32) v2(264.42,124.68) v2(264.42,124.05) v2(264.42,123.41) v2(264.42,122.78) v2(264.42,122.14) v2(265.06,126.59) v2(265.06,125.95) v2(265.06,125.32) v2(265.06,124.68) v2(265.19,31.79) v2(265.57,32.36) v2(265.83,31.79) v2(265.99,175.97) v2(266.2,35.02) v2(266.2,34.39) v2(266.2,32.35) v2(266.23,16.91) v2(266.25,16.29) v2(266.56,150.5) v2(266.72,8.77) v2(266.76,4.29) v2(266.84,35.02) v2(266.84,34.39) v2(266.84,32.35) v2(267.16,31.79) v2(267.81,152.68) v2(267.81,148.32) v2(267.79,31.78) v2(268.42,31.78) v2(269.21,8.76) v2(269.18,4.29) v2(269.57,57.75) v2(269.57,57.12) v2(269.75,73.96) v2(270.2,57.75) v2(270.2,57.12) v2(270.33,152.68) v2(270.33,148.32) v2(270.66,6.47) v2(270.91,3.43) v2(270.98,163.06) v2(270.98,161.64) v2(270.98,160.22) v2(271.58,150.5) v2(272.02,155.2) v2(272.4,163.06) v2(272.4,161.64) v2(272.4,160.22) v2(273.25,173.67) v2(273.44,43.59) v2(273.52,44.41) v2(273.52,42.86) v2(273.82,163.06) v2(273.82,161.64) v2(273.82,160.22) v2(273.8,42.09) v2(273.88,139.8) v2(273.88,138.27) v2(273.88,136.75) v2(273.92,45.12) v2(274.06,170.6) v2(274.06,155.21) v2(274.52,41.18) v2(274.65,45.82) v2(275.12,172.43) v2(275.12,168.77) v2(275.24,40.8) v2(275.41,139.8) v2(275.41,138.27) v2(275.41,136.75) v2(275.47,46.16) v2(276.16,40.7) v2(276.39,46.23) v2(276.93,139.8) v2(276.93,138.27) v2(276.93,136.75) v2(277.22,172.43) v2(277.22,168.77) v2(277.31,41.12) v2(277.38,45.88) v2(278.04,41.69) v2(278.11,45.27) v2(278.28,170.6) v2(278.55,114.56) v2(278.53,3.43) v2(278.6,44.43) v2(278.6,42.55) v2(278.84,43.53) v2(280.03,46.3) v2(280.03,45.71) v2(280.62,46.3) v2(280.62,45.71) v2(280.62,45.13) v2(280.62,44.55) v2(280.62,43.96) v2(280.62,43.38) v2(280.62,42.79) v2(280.87,173.67) v2(282.52,64.55) v2(282.52,63.92) v2(282.52,63.33) v2(283.1,64.55) v2(283.85,44.36) v2(283.85,43.72) v2(284.36,38.64) v2(284.39,168.17) v2(285,37.24) v2(285,36.66) v2(286.15,3.43) v2(286.99,161.5) v2(286.99,153.88) v2(286.99,146.26) v2(286.99,138.64) v2(286.99,131.02) v2(286.99,123.4) v2(286.99,115.78) v2(287,108.17) v2(287.98,100.6) v2(290.12,93.29) v2(290.33,59.53) v2(290.33,58.9) v2(290.33,58.26) v2(290.33,57.63) v2(290.33,56.99) v2(290.33,56.36) v2(290.33,55.72) v2(290.52,38.26) v2(290.52,37.62) v2(290.97,59.53) v2(290.97,58.9) v2(290.97,58.26) v2(290.97,57.63) v2(290.97,56.99) v2(290.97,56.36) v2(290.97,55.72) v2(291.66,70.45) v2(291.66,69.82) v2(291.6,59.53) v2(291.6,58.9) v2(291.6,58.26) v2(291.6,57.63) v2(291.6,56.99) v2(291.6,56.36) v2(291.6,55.72) v2(292.24,44.55) v2(292.24,43.91) v2(292.3,59.53) v2(292.3,58.9) v2(292.3,58.26) v2(292.3,57.63) v2(292.3,56.99) v2(292.3,56.36) v2(292.3,55.72) v2(292.93,60.8) v2(292.93,60.17) v2(292.93,59.53) v2(292.93,58.9) v2(292.93,58.26) v2(292.93,57.63) v2(292.93,56.99) v2(292.93,56.36) v2(292.93,55.72) v2(292.93,55.09) v2(292.93,54.45) v2(292.93,53.82) v2(292.93,53.18) v2(292.93,52.55) v2(292.93,51.91) v2(293.4,86.41) v2(293.57,60.8) v2(293.57,60.17) v2(293.57,59.53) v2(293.57,58.9) v2(293.57,58.26) v2(293.57,57.63) v2(293.57,56.99) v2(293.57,56.36) v2(293.57,55.72) v2(293.57,55.09) v2(293.57,54.45) v2(293.57,53.82) v2(293.57,53.18) v2(293.57,52.55) v2(293.57,51.91) v2(293.77,3.43) v2(294.2,60.8) v2(294.2,60.17) v2(294.2,59.53) v2(294.2,58.9) v2(294.2,58.26) v2(294.2,57.63) v2(294.2,56.99) v2(294.2,56.36) v2(294.2,55.72) v2(294.2,55.09) v2(294.2,54.45) v2(294.2,53.82) v2(294.2,53.18) v2(294.2,52.55) v2(294.2,51.91) v2(294.28,63.47) v2(294.28,62.88) v2(294.28,62.25) v2(294.28,61.67) v2(294.84,60.8) v2(294.9,60.17) v2(294.9,59.53) v2(294.9,58.9) v2(294.9,58.26) v2(294.9,57.63) v2(294.9,56.99) v2(294.9,56.36) v2(294.9,55.72) v2(294.9,55.09) v2(294.9,54.45) v2(294.9,53.82) v2(294.9,53.18) v2(294.9,52.55) v2(294.9,51.91) v2(295.66,67.58) v2(295.66,66.99) v2(295.66,66.37) v2(295.66,65.79) v2(295.66,48.1) v2(295.66,47.47) v2(295.66,46.83) v2(295.66,46.2) v2(295.76,76.25) v2(296.36,48.1) v2(296.36,47.47) v2(296.36,46.83) v2(296.36,46.2) v2(296.82,78.08) v2(296.82,74.42) v2(297,48.74) v2(297,48.1) v2(297,47.47) v2(297,46.83) v2(297,46.2) v2(297.73,80.14) v2(297.7,48.1) v2(297.7,47.47) v2(297.7,46.83) v2(298.42,78.34) v2(298.92,74.42) v2(299.98,76.25) v2(300.91,73.23) v2(300.94,65.63) v2(301.39,3.43) v2(302.87,53.65) v2(303.44,54.22) v2(303.44,53.08) v2(304.02,53.65) v2(305.47,37.73) v2(305.47,34.73) v2(306.97,36.23) v2(307.55,61.82) v2(308.47,37.73) v2(309.01,3.43) v2(311.86,36.91) v2(312.43,43.28) v2(313.06,43.28) v2(315.17,61.82) v2(315.88,37.1) v2(316.52,58.68) v2(316.52,56.7) v2(316.63,3.43) v2(317.51,57.69) v2(318.5,58.68) v2(318.5,56.7) v2(321.98,58.43) v2(322.36,24.26) v2(322.36,23.68) v2(322.37,23.1) v2(322.97,21.24) v2(324.25,3.43) v2(324.89,51.37) v2(329.13,37.1) v2(329.76,39.28) v2(330.3,43.69) v2(330.3,41.71) v2(331.29,42.7) v2(331.87,3.43) v2(332.28,41.71) v2(332.51,51.37) v2(335.28,31.71) v2(335.28,29.93) v2(337.99,46.08) v2(337.99,38.46) v2(337.99,30.84) v2(337.99,23.22) v2(337.99,15.6) v2(337.99,7.98) v4(13.88,29.06) v4(14.54,29.37) v4(23.07,43.07) v4(31.61,9.85) v4(55.63,20.99) v4(80.65,19.27) v4(86.27,31.19) v4(88.11,48.2) v4(94.65,30.56) v4(148.18,145.69) v4(148.41,139.85) v4(150.86,143.14) v4(164.26,136.56) v4(181.49,136.06) v4(190.27,158.24) v4(214.03,144.28) v4(216.23,102.25) v4(216.37,84.55) v4(220.72,43.59) v4(237.14,147.26) v4(242.46,117.93) v4(254.16,140.57) v4(254.92,28.11) v4(256.46,149.77) v4(259.41,118.59) v4(261.15,152.44) v4(265.77,122.04) v4(266.11,128.31) v4(267.47,29.46) v4(279.66,47.68) v4(292.05,41.13) v4(292.13,70.15) v4(293.11,49.93) v4(296.08,68.56) v4(297.3,42.86) v4(297.75,59.29)
