# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N19618056: length 38.4
  TOP w0.102: v2(198.27,107.45) 198.27,107.17 198.07,106.97 197.28,106.97 v1(197.2,107.04) 196.91,107.04 196.81,106.94 RG101.1
  IN6 w0.102: v2(198.27,107.45) 198.79,107.45 200.48,109.14 200.48,110.71 201.3,111.54 201.3,112.37 204.03,115.09 209.7,115.09 210.14,114.65 211.59,114.65 212.16,115.22 212.16,116.22 213.5,117.56 217.11,117.56 217.44,117.89 221.24,117.89 222.13,117 222.13,114.65 v2(223.09,113.7)
  BOTTOM w0.089: UG9.BJ6 222.47,114.31 v2(223.09,113.7)
N19842722: length 2.4
  TOP w0.102: RG130.1 v1(227.24,59.26)
  TOP w0.305: v2(225.39,59.31) 225.43,59.26 RG130.1
  BOTTOM w0.122: UG5.J13 v2(225.39,59.31)
N19842724: length 4.9
  TOP w0.102: v2(214.81,58.91) v1(215.2,58.52) 216.41,57.31 217.69,57.31 218.07,57.69 RG126.1
  BOTTOM w0.102: UG5.J1 v2(214.81,58.91)
N19842731: length 2
  TOP w0.102: v2(222.04,58.96) v1(222.04,58.45)
  TOP w0.305: v2(222.04,58.96) 222.26,59.18 RG128.1
  BOTTOM w0.111: v2(222.04,58.96) 222.09,58.91 UG5.J10
N19847413: length 3.1
  TOP w0.102: v1(277.55,69.95) 276.97,70.53 RG120.1
  TOP w0.305: v2(276.15,71.56) 276.36,71.35 RG120.1
  BOTTOM w0.102: v2(276.15,71.56) 276.55,71.96 UG4.J13
N19847417: length 3.5
  TOP w0.102: v1(275.13,81.76) 275.13,82.86 RG116.1
  TOP w0.508: v2(276.52,82.19) 275.75,82.96 RG116.1
  BOTTOM w0.305: v2(276.52,82.19) 276.55,82.16 UG4.J1
N19847426: length 2.1
  TOP w0.102: v2(276.5,74.91) v1(276.5,75.69)
  TOP w0.305: RG118.1 276.96,74.45 v2(276.5,74.91)
  BOTTOM w0.107: UG4.J10 276.55,74.86 v2(276.5,74.91)
N19849394: length 2.1
  TOP w0.102: RG119.1 260.47,59.22 v2(260.39,59.31) 260.39,59.36 v1(260.87,59.84)
  BOTTOM w0.102: UG3.J13 v2(260.39,59.31)
N19849396: length 2.5
  TOP w0.102: RG115.1 v1(249.06,60.01)
  TOP w0.305: RG115.1 249.12,58.91 v2(249.81,58.91)
  BOTTOM w0.3: UG3.J1 v2(249.81,58.91)
N19849403: length 1.9
  TOP w0.102: v2(257.04,58.96) v1(257.04,59.58)
  TOP w0.305: v2(257.04,58.96) 257.5,58.5 RG117.1
  BOTTOM w0.102: v2(257.04,58.96) 257.09,58.91 UG3.J10
N19854250: length 2.7
  TOP w0.102: v1(277.78,107.44) 276.93,106.59 RG109.1 276.24,106.47 v2(276.15,106.56)
  BOTTOM w0.125: v2(276.15,106.56) 276.36,106.77 UG2.J13
N19854254: length 4.2
  TOP w0.102: v2(276.52,117.21) 276.04,117.7 RG105.1 274.72,118.19 v1(273.96,118.95)
  BOTTOM w0.3: UG2.J1 276.55,117.19 v2(276.52,117.21)
N19854263: length 2.4
  TOP w0.102: v2(276.5,109.91) v1(277.26,109.91)
  TOP w0.305: v2(276.5,109.91) 276.25,109.66 RG107.1
  BOTTOM w0.125: UG2.J10 276.55,109.86 v2(276.5,109.91)
N19855299: length 5.5
  BOTTOM w0.305: RG111.1 278.7,101.86 v1(280.78,101.86) 283.87,101.86 QG2.1
N19856231: length 2
  TOP w0.102: v2(276.15,97.16) 276.25,97.26 RG108.1
  BOTTOM w0.125: UG1.J13 v2(276.15,97.16)
N19856233: length 2.7
  TOP w0.102: RG104.1 276.5,85.2 v1(276.02,84.72)
  TOP w0.305: RG104.1 276.54,85.8 276.54,86.55 v2(276.55,86.56)
  BOTTOM w0.3: UG1.J1 v2(276.55,86.56)
N19856240: length 1.9
  TOP w0.102: v2(276.5,93.81) v1(277.12,93.81)
  TOP w0.305: v2(276.5,93.81) 276.49,93.82 RG106.1
  BOTTOM w0.111: v2(276.5,93.81) 276.55,93.86 UG1.J10
N19942790: length 5.7
  TOP w0.381: CU27.1 31.43,44.46 UU5.2
  TOP w0.508: CU27.1 31.68,43.13 v1(31.75,43.06) 32.4,43.06 RU5.2 33.76,43.49 DU8.2
N19950372: length 3.1
  TOP w0.102: v1(18.17,42.83) 18.86,43.52 RU3.2
  TOP w0.107: UU1.16 19.73,43.83 RU3.2
N19950378: length 2.7
  TOP w0.102: RU2.2 v1(18.21,44.38)
  TOP w0.107: RU2.2 19.46,44.33 UU1.15
N19950402: length 3.2
  TOP w0.102: v1(26.22,44.42) 25.24,45.4 RU7.2
  TOP w0.107: UU1.8 24.91,45.33 RU7.2
N19950406: length 1.6
  TOP w0.107: UU1.4 23.08,42.55 23.4,42.23 RU1.2
N20474320: length 1.9
  BOTTOM w0.102: RA75.1 v1(33.73,3.7)
  BOTTOM w0.254: RA75.1 33.78,2.78 v2(34.46,2.1)
N20474322: length 1.1
  TOP w0.102: RA74.1 35.57,1.62 v1(34.95,1)
N20474324: length 1.4
  BOTTOM w0.102: 40.2,5.11 40.2,4.76 40.37,4.59 40.37,3.97 v1(40.23,3.83)
N20758419: length 1.6
  TOP w0.089: RH580.1 206.62,35.79 v2(206.84,35.57)
  BOTTOM w0.089: v2(206.84,35.57) 206.84,35.41 206.68,35.25 UH1.AD10
N20758429: length 4
  BOTTOM w0.089: 207.16,42.08 v1(207.16,41.65) 207.16,41.26 207.47,40.95 207.47,40.5 207.62,40.35 207.62,39.29 207.75,39.16 UH1.AG2
  BOTTOM w0.107: 207.16,42.13 207.16,42.08
  BOTTOM w0.127: RH581.1 207.16,42.13
N20762834: length 6
  BOTTOM w0.089: UH1.BC17 215.59,31.48 215.87,31.76 216.05,31.76 216.19,31.62 217.47,31.62 217.86,31.22 217.86,30.67 218.31,30.22 218.77,30.22
  BOTTOM w0.102: 218.77,30.22 219,30.22
  BOTTOM w0.127: 219,30.22 v1(219.12,30.09) 219.59,29.62 RH89.2
N20904379: length 2.9
  BOTTOM w0.089: 201.56,158.85 201.56,159.4 201.66,159.5 UT4.A8 UT4.A7 ; UT4.A7 UT4.A6 ; UT4.A7 UT4.B7
  BOTTOM w0.102: 201.56,158.85 RT22.1
N20905578: length 5.3
  TOP w0.102: v1(202.43,167.57) 202.65,167.36 v2(202.65,166.57)
  TOP w0.107: v2(201.41,164.09) 202.32,165 202.32,166.02 202.65,166.35 v2(202.65,166.57)
  BOTTOM w0.076: UT4.H7 201.16,163.83 v2(201.41,164.09)
  BOTTOM w0.089: v2(202.65,166.57) 202.63,166.59 202.63,166.66
  BOTTOM w0.102: CT104.1 202.63,166.66
N20905857: length 3.1
  TOP w0.102: RT83.2 196.53,163.29 v1(196.52,163.28) 196.52,163.02 196.89,162.65 v2(197,162.65)
  BOTTOM w0.076: UT4.F1 197.9,162.82 197.56,162.82 197.56,162.82 197.16,162.82
  BOTTOM w0.127: 197.16,162.82 v2(197,162.65)
N20960158: length 1.7
  TOP w0.107: RE528.2 RE527.1 230.54,30.93 230.2,31.27 QE53.5
N20960615: length 3.2
  TOP w0.107: RE511.1 RE449.2 225.54,25.14 225.29,25.38 QE54.2
N20960628: length 1.7
  BOTTOM w0.107: RE455.2 RE456.1 230.54,21.9 230.2,21.56 QE39.5
N20960654: length 1.7
  BOTTOM w0.107: RE396.2 RE397.1 236.44,31.62 236.1,31.27 QE29.5
N20960689: length 1.7
  BOTTOM w0.102: QE29.2 233.59,31.27 233.24,30.93 RE401.1 RE399.2
N20960760: length 1.7
  BOTTOM w0.107: RE454.2 RE453.1 227.15,21.22 227.38,21.22 227.72,21.56 QE39.2
N20960779: length 2.8
  TOP w0.102: RE513.2 231.71,25.14 v1(231.85,25.28)
  TOP w0.107: QE49.5 230.2,24.8 230.54,24.45 RE512.1 RE513.2
N20960882: length 2.8
  TOP w0.107: RE511.2 227.36,23.65 227.85,23.65 228.02,23.82 QE49.3 227.66,24.15 227.53,24.27 227.53,24.67 227.66,24.8 QE49.2
N20960884: length 1.7
  BOTTOM w0.102: RE460.2 RE458.1 227.31,24.26 227.85,24.8 QE40.2
N20960892: length 1.7
  BOTTOM w0.107: RE461.2 RE462.1 230.54,25.14 230.2,24.8 QE40.5
N20960976: length 1.6
  BOTTOM w0.102: QE41.2 227.72,28.04 227.44,27.76 RE465.1 RE467.2
N20960982: length 1.7
  BOTTOM w0.107: RE466.2 RE468.1 230.54,28.38 230.2,28.04 QE41.5
N20960988: length 3.8
  TOP w0.107: QE54.5 225.29,23.49 225.17,23.37 224.19,23.37 224.1,23.46 224.1,23.91 223.68,24.33 RE514.1 RE517.2
N20961029: length 3.1
  TOP w0.107: RE516.2 RE515.1 225.01,21.34 225.29,21.07 QE50.5
N20961045: length 3.5
  TOP w0.107: RE514.2 224,23.14 224.48,23.14 224.64,22.98 QE50.3 224.64,22.16 224.74,22.07 225.12,22.07 225.29,22.24 QE50.2
N20961145: length 1.7
  BOTTOM w0.107: RE474.2 RE472.1 227.15,30.93 227.38,30.93 227.72,31.27 QE42.2
N20961166: length 2.8
  BOTTOM w0.102: v1(231.91,30.93) RE471.2
  BOTTOM w0.107: RE471.2 RE473.1 230.54,31.62 230.2,31.27 QE42.5
N20961197: length 1.7
  BOTTOM w0.102: RE480.2 RE479.1 233.28,27.69 233.63,28.04 QE43.2
N20961228: length 1.7
  BOTTOM w0.107: QE43.5 236.1,28.04 236.44,28.38 RE478.1 RE476.2
N20961244: length 3
  TOP w0.107: QE55.2 225.29,28.65 225.4,28.54 225.67,28.54 225.77,28.44 227.09,28.44 RE521.2 RE518.1
N20961277: length 1.7
  TOP w0.107: QE51.5 230.2,28.04 230.54,27.69 RE519.1 RE520.2
N20961293: length 2.2
  TOP w0.107: RE518.2 227.43,27.11 227.7,27.39 QE51.3 228.27,27.39 228.37,27.49 228.37,27.93 228.27,28.04 QE51.2
N20961336: length 11
  TOP w0.102: v2(226.15,27.98) 226.09,28.04 225.84,28.04 225.29,27.49 QE55.5
  TOP w0.107: v2(226.61,21.19) 226.64,21.22 RE522.1 RE525.2
  IN1 w0.102: v2(226.61,21.19) 226.61,23.91 225.87,24.66 225.87,27.71 v2(226.15,27.98)
  BOTTOM w0.102: v1(225.93,28.92) 226.15,28.71 v2(226.15,27.98)
N20961369: length 2.7
  TOP w0.102: RE524.2 v1(231.76,21.9)
  TOP w0.107: QE52.5 230.32,21.56 230.67,21.22 RE523.1 RE524.2
N20961391: length 2.7
  TOP w0.102: v1(226.95,19.68) 226.95,20.43 RE522.2
  TOP w0.107: RE522.2 227.74,20.63 QE52.3 QE52.2
N20961418: length 1.7
  BOTTOM w0.102: QE44.2 233.63,24.8 233.28,24.45 RE485.1 RE486.2
N20961454: length 1.7
  BOTTOM w0.107: RE482.2 RE484.1 236.44,25.14 236.1,24.8 QE44.5
N20961510: length 1.7
  BOTTOM w0.102: QE45.2 233.67,21.56 233.33,21.22 RE491.1 RE492.2
N20961531: length 1.7
  BOTTOM w0.107: QE45.5 236.22,21.56 236.56,21.9 RE490.1 RE488.2
N20961580: length 1.7
  TOP w0.107: RE498.2 RE496.1 236.42,30.93 236.08,31.27 QE46.2
N20961592: length 1.6
  TOP w0.107: RE495.2 RE497.1 233.32,31.62 233.66,31.27 QE46.5
N20961638: length 6.8
  TOP w0.102: v1(223.33,33.51) 223.89,32.94 QE56.2
  TOP w0.107: QE56.2 223.89,31.61 223.91,31.59 223.91,31.53 224.29,31.15 224.54,31.15 225.24,30.45 225.85,30.45 226.34,30.93 RE526.1 RE529.2
N20961685: length 3.5
  TOP w0.102: RE526.2 226.26,30.35 v1(226.18,30.27)
  TOP w0.107: RE526.2 227.49,30.35 227.77,30.62 QE53.3 228.43,30.62 228.52,30.71 228.52,31.11 228.35,31.27 QE53.2
N20961740: length 1.7
  TOP w0.107: QE47.2 236.14,28.04 236.48,27.69 RE501.1 RE503.2
N20961750: length 1.5
  TOP w0.102: QE47.5 233.91,28.07 RE504.1 RE502.2
N20961813: length 1.7
  TOP w0.107: QE48.2 236.2,24.8 236.55,24.45 236.67,24.45 RE508.1 RE510.2
N20961825: length 1.7
  TOP w0.107: RE507.2 RE509.1 233.26,25.14 233.6,24.8 QE48.5
N20971521: length 3.7
  TOP w0.102: JLAN.9 245.95,170.96 v1(244.09,170.96) RL8.1
N20971565: length 2.7
  BOTTOM w0.102: RL5.1 v1(265.74,168.32)
  BOTTOM w0.107: UL2.3 267.59,167.69 RL5.1
N20971567: length 20
  TOP w0.102: LL1.2 265.88,159.43 266.12,159.67 CL31.1
  TOP w0.107: JLAN.12 v1(261.76,170.67) 262.7,170.67 267.75,165.61 267.75,161.73 266.12,160.1 CL31.1
N20972379: length 3.1
  BOTTOM w0.102: RL2.2 276.61,162.88 276.4,162.67 v1(276.4,162.36) 276.4,161.99 276.12,161.71 275.79,161.71 275.66,161.84 UL1.5
N20972746: length 9.3
  TOP w0.508: RL13.2 263.47,155.39 264.46,154.4 v1(264.82,154.4) 265.29,154.4 265.64,154.75 266.87,154.75 267.95,155.83 267.95,156.27 267.33,156.89 RL14.2 266.96,157.47 QL3.1
N20986399: length 7.5
  TOP w0.102: UE12.3 147.19,165.45 v2(147.12,165.38)
  TOP w0.107: RE161.1 152.47,164.68 v2(152.62,164.83)
  IN2 w0.102: v2(147.12,165.38) 147.68,164.81 149.36,164.81 149.61,165.07 152.38,165.07 v2(152.62,164.83)
N20995131: length 3.9
  TOP w0.102: RE25.2 225.5,161.64 v1(226.51,162.66) 227.21,162.66 227.51,162.36 UE3.24
N20995135: length 1.6
  TOP w0.102: UE3.30 225.41,157.86 RE31.1
N20999302: length 4.2
  BOTTOM w0.102: UM8.27 126.1,158.18 125.76,158.52 125.38,158.52 125.19,158.71 124.65,158.71 124.32,159.04 RM72.1 123.86,159.53 v1(123.86,160.18)
N20999314: length 1.8
  BOTTOM w0.107: RM61.2 138.18,154.58 v2(137.75,155.01) 137.58,155.18 UM8.52
N20999316: length 2.4
  BOTTOM w0.107: UM8.48 138.17,157.18 RM64.1 RM66.1
N21000707: length 3.8
  BOTTOM w0.102: v1(172.49,152.36) RM21.2
  BOTTOM w0.107: UM4.1 171.19,152.86 171.26,152.79 RM21.2 RM96.2
N21000709: length 3.5
  BOTTOM w0.102: CM99.1 RM29.1
  BOTTOM w0.107: RM28.1 166.19,162.5 166.04,162.5 165.68,162.15 164.66,162.15 RM29.1
N21000711: length 4.6
  BOTTOM w0.102: RM38.1 CM98.1
  BOTTOM w0.107: RM27.1 166.97,162.74 165.93,162.74 165.58,162.39 164.65,162.39 RM38.1
N21000719: length 1.4
  BOTTOM w0.102: CM17.1 172.4,161.11 v1(172.86,161.56)
N21000750: length 1.7
  BOTTOM w0.107: UM4.18 169.89,161.45 RM25.2
N21000786: length 1.7
  BOTTOM w0.107: RM28.2 166.43,160.89 166.64,160.68 UM4.13
N21000788: length 1.6
  BOTTOM w0.107: UM4.14 167.29,160.77 167.45,160.93 RM27.2
N21000830: length 7.3
  BOTTOM w0.107: QM2.6 149.22,166.42 148.53,167.1 v1(147.52,167.1) 146.19,167.1 145.74,166.66 145.74,165.78 QM1.2 146.81,164.69 RM92.2
N21000850: length 5.8
  BOTTOM w0.102: RM94.2 150.91,163.68 151.41,164.18 152.71,164.18 153.29,164.75 QM3.2 152.97,165.67 152.52,165.22 152.07,165.22 151.96,165.12 QM2.3
N21000877: length 3.8
  BOTTOM w0.102: RM20.2 168.84,151.85 v1(168.84,150.48)
  BOTTOM w0.107: RM20.2 169.24,152.47 UM4.4
N21002214: length 2.7
  BOTTOM w0.102: RE14.2 100.31,15.2 v1(99.96,14.84)
  BOTTOM w0.107: RE14.2 UE2.3
N21002223: length 2.6
  BOTTOM w0.107: RE11.1 CE20.1 UE2.6
N21002224: length 1.9
  BOTTOM w0.107: RE9.1 99.82,24.89 UE2.5
N21002246: length 1.6
  BOTTOM w0.107: RE13.2 UE2.7
N21002311: length 2
  TOP w0.102: 317,19.16 RE651.1
  TOP w0.107: UE1.20 317,19.16
N21002312: length 1.9
  TOP w0.102: 317.8,19.24 CE9.1
  TOP w0.107: UE1.19 317.8,19.24
N21002317: length 2
  TOP w0.107: UE1.11 322,12.33 322.3,12.03 CE18.1
N21002319: length 1.9
  TOP w0.107: UE1.12 321.99,13.13 322.2,12.92 CE17.1
N21002321: length 1.9
  TOP w0.107: UE1.13 322.21,13.93 322.33,13.81 CE16.1
N21002324: length 1.8
  TOP w0.107: UE1.14 322.68,14.73 CE15.1
N21002326: length 1.8
  TOP w0.107: UE1.15 322.71,15.53 CE14.1
N21002328: length 3.1
  TOP w0.102: CE13.1 322.75,16.99 v1(322.28,17.46)
  TOP w0.107: UE1.16 322.61,16.33 CE13.1
N21002352: length 1.6
  BOTTOM w0.107: RE10.1 102.36,15.56 UE2.2
N21002366: length 4.6
  TOP w0.107: UE1.23 314.6,18.77 315.1,19.27 RE8.2 315.6,20.21 DE1.2
N21002397: length 3.1
  BOTTOM w0.102: UE9.3 100.81,28.73 100.71,28.83 100.31,28.83 99.95,28.47 RE20.1 v1(99.39,27.47)
N21003330: length 2.8
  BOTTOM w0.102: U2407.7 187.39,39.77 R181.2 v1(187.35,38.54)
N21003701: length 5.9
  TOP w0.254: JFAN1.3 104.37,62.42 103.35,61.4 v1(102.88,61.4) 102.88,59.83 DF1.1 103.3,59.41 RF3.1
N21003743: length 12.7
  TOP w0.102: DF2.1 292.83,72.69 RF6.1 293.37,74.09 293.37,75.32 v1(292.38,76.31) 292.38,77.98 291.27,79.09 289.04,79.09 288.37,78.42 JFAN2.3
N21014812: length 2.9
  BOTTOM w0.102: v1(128.04,102.84) C3.1
  BOTTOM w0.127: C3.1 128.1,101.42 UZ21.6
N21181966: length 9.9
  TOP w0.089: 172.15,101.86 169.16,101.86 v2(168.78,101.47)
  TOP w0.102: RH154.2 173.66,101.64 173.51,101.8 173.51,102.79 173.41,102.89 v1(173.21,102.89) 173.1,102.79 173.1,102 173,101.9 172.8,101.9 172.7,102 172.7,102.79 172.6,102.89 172.39,102.89 172.29,102.79 172.29,102 172.15,101.86
  BOTTOM w0.076: CPU1.H13 168.41,101.84 v2(168.78,101.47)
N21181987: length 14.4
  IN6 w0.102: v2(129.04,119.98) 130.86,119.98 133.47,117.37 133.47,116.05 134.96,114.56 136.46,114.56 136.92,115.02 v2(136.92,115.92)
  BOTTOM w0.076: CPU1.BH31 137.17,115.66 v2(136.92,115.92)
  BOTTOM w0.102: RH153.2 128.71,120.72 v1(128.88,120.56) 129.04,120.39 v2(129.04,119.98)
N21182006: length 6.1
  BOTTOM w0.107: RH519.2 127.97,118.13 v1(129.03,118.13) 129.45,118.13 130.61,116.96 132.61,116.96 CPU1.BR33
N21182008: length 3.5
  BOTTOM w0.076: RH158.2 129.87,115.8 130.39,115.28 132.73,115.28 CPU1.BR30
N21182026: length 6.4
  BOTTOM w0.107: CPU1.BP31 133.31,116.13 131.43,116.13 131.38,116.18 130.33,116.18 129.72,116.78 v1(128.99,116.78) RH155.2
N21185219: length 2.8
  BOTTOM w0.102: UV17.3 166.54,166.59 RV45.1 167.98,166.2 v4(168.11,166.33)
N21185406: length 2.5
  TOP w0.102: v1(164.21,161.58) CV374.1 165.12,163.7 RV13.2
N21238299: length 5.4
  TOP w0.102: RE166.2 301.7,38.13 302.21,38.64 v1(302.5,38.64) 303.16,38.64 303.76,39.25 305.12,39.25 305.22,39.15 UE8.24
N21238303: length 3.1
  TOP w0.102: UE8.30 303.47,35.48 v1(302.95,34.96) 302,34 RE167.1
N22226841: length 6.3
  TOP w0.102: UX1.4 219.96,162.18 v1(219.85,162.06) 219.73,161.94 219.73,159.54 219.55,159.37 219.46,159.37 218.28,158.19 QV97.5
N22294463: length 2
  TOP w0.102: RG157.1 199.41,90.08 v2(199.43,90.05) 199.43,89.91 v1(199.86,89.48)
  BOTTOM w0.125: UG7.J13 199.18,90.3 v2(199.43,90.05)
N22294465: length 2.7
  TOP w0.102: RG158.1 v1(198.97,102.71)
  TOP w0.254: RG158.1 198.97,100.89 v2(199.03,100.83)
  BOTTOM w0.305: v2(199.03,100.83) UG7.J1
N22294469: length 2.3
  TOP w0.102: RG159.1 198.52,93.96 v2(199.08,93.4) 199.53,93.4 v1(199.83,93.71)
  BOTTOM w0.111: UG7.J10 199.08,92.9 v2(199.08,93.4)
N22295107: length 2.7
  TOP w0.102: v1(198.65,81.85) RG162.1 199.32,80.55 v2(199.43,80.65)
  BOTTOM w0.17: UG8.J13 199.2,80.43 v2(199.43,80.65)
N22295109: length 2.6
  TOP w0.102: RG161.1 v1(199.13,68.08)
  TOP w0.305: v2(199.08,70) 199.13,69.95 RG161.1
  BOTTOM w0.4: v2(199.08,70) 199.03,70.05 UG8.J1
N22295113: length 2.2
  TOP w0.102: v2(199.08,77.3) v1(199.08,78.16)
  TOP w0.305: RG163.1 198.58,76.8 v2(199.08,77.3)
  BOTTOM w0.125: 199.03,77.63 199.03,77.35 v2(199.08,77.3)
  BOTTOM w0.129: UG8.J10 199.03,77.63
N24365027: length 3.3
  TOP w0.102: v1(316.3,53.32) 316.3,53.4 316.32,53.41 CE63.2 RE530.2 317.26,54.28 UE10.3
N24371838: length 31.2
  IN6 w0.102: JHDMI.13 218.94,173.48 221.34,173.48 221.65,173.17 221.65,167.33 219.91,165.59 219.91,162.95 218.26,161.3 211.37,161.3 210.37,162.3 210.37,163.33 209.66,164.05 v2(208.84,164.05)
  BOTTOM w0.102: v2(208.84,164.05) 209.05,163.84 209.05,162.72 v1(209.04,162.71) 208.66,162.33 RV655.2
N24377091: length 10.3
  TOP w0.102: QV97.2 218.8,158.19 218.39,157.77 218.39,156.05 218.3,155.97 218.3,155.97 218.06,155.73 217.88,155.73 v2(217.88,155.73)
  BOTTOM w0.102: v2(217.88,155.73) 217.52,156.09 216.19,156.09 215.43,155.33 213.93,155.33 v1(213.4,155.86) 212.52,156.74 UX2.4
N24377100: length 2.6
  BOTTOM w0.102: v1(207.44,160.29) 208.05,159.68 RX6.1 208.74,159.57 QX3.2
N24405043: length 1.8
  BOTTOM w0.102: UV21.47 201.12,135.97 CV438.1
N24405047: length 1.9
  BOTTOM w0.102: RV24.1 195.54,135.26 195.92,134.88 UV21.34
N24405061: length 7.4
  BOTTOM w0.102: UV21.50 202.32,135.32 202.38,135.39 202.77,135.39 203.05,135.67 203.54,135.67 RV25.1 204.67,135.53 RV26.2 205.96,135.53 206.36,135.92 QV95.1 206.76,135.19 v1(207.16,134.79)
N24405079: length 3.6
  BOTTOM w0.102: RV26.1 205.05,136.85 205.18,136.98 v1(205.18,138.7) 205.18,139.01 CV439.1
N24654525:
  vias: v1(226.15,40.77)
N24654698: length 2.3
  TOP w0.102: R367.1 228.75,43.82 v1(228.48,44.09) U18.3
N25131299: length 3.7
  BOTTOM w0.102: v1(161.18,160.74) 161.18,161.13 QV2.1 160.21,162.11 160.21,163.46 RV12.2
N25288706: length 11.8
  TOP w0.102: v2(201.39,118.45) 200.14,117.19 v1(199.79,117.19) 198.38,117.19 v2(198.05,116.86)
  BOTTOM w0.102: RG7.1 197.98,116.69 197.98,116.78 v2(198.05,116.86) ; v2(201.39,118.45) 202.08,118.45 RG537.1 202.13,119.39 202.03,119.49 201.53,119.49 201.41,119.61 UG10.4 201.41,120.44 202.54,121.57 203.77,121.57 RG562.1
N25289505: length 7
  BOTTOM w0.089: UG9.BK23 234.37,115.2 234.02,115.55 234.02,115.99 233.81,116.2 233.81,116.52 232.71,117.62 231.28,117.62 v1(230.88,118.02) 230.64,118.26 RG26.1
N25289690: length 13.1
  BOTTOM w0.102: RG508.1 203.5,127.12 203.27,126.89 203.27,124.54 203.32,124.49 ; 203.32,124.49 203.91,124.49 204.29,124.11 v1(204.57,124.11) 204.67,124.01 206.25,124.01 206.59,123.68 208.48,123.68 208.58,123.78 208.58,124.11 208.81,124.34 209.46,124.34 209.62,124.17 QG500.5 209.62,123.22 209.88,122.97 211.02,122.97 211.15,123.1 RG519.1 ; 203.32,124.49 RG507.1
N25567095: length 17.4
  IN6 w0.102: v2(219.33,168.13) 218.87,167.67 218.87,164.52 218.63,164.27 218.63,163.29 217.98,162.64 216.19,162.64 216.07,162.76 214.91,162.76 214.81,162.66 v2(213.14,162.66)
  BOTTOM w0.102: DV13.1 221.49,166.4 219.76,168.13 v2(219.33,168.13) ; v2(213.14,162.66) 212.75,162.26 v1(212.75,161.36) 212.75,160.95 RV653.2
N25567097: length 17.4
  IN6 w0.102: v2(213.15,162.07) 213.54,161.69 217.87,161.69 218.86,162.68 218.86,164.18 219.13,164.46 219.13,167.34 v2(219.34,167.55)
  BOTTOM w0.102: v2(219.34,167.55) 219.8,167.55 v1(220.08,167.26) 221.32,166.02 222.45,166.02 222.83,166.4 DV12.1 ; RV649.2 213.15,161.43 v2(213.15,162.07)
N25732286: length 1.7
  BOTTOM w0.102: CG64.1 196.16,109.73 196.26,109.83 UG12.12
N25732288: length 1.9
  BOTTOM w0.102: UG12.10 197.06,110.01 196.96,109.91 196.96,109.47 CG65.1
N25769611: length 3.6
  TOP w0.102: v1(273.62,37.71) 273.03,38.3 272.35,38.3 272.06,38.01 RE637.2 RE638.1 271.87,37.03 QE57.5
N25769633: length 2.4
  TOP w0.102: v1(273.62,35.31) 272.78,34.48 QE57.3 272.52,33.53 RE636.2
N25769981: length 2.7
  TOP w0.102: RE639.2 271.22,37.39 QE57.6 v1(269.61,36.38)
N25769983: length 2.7
  TOP w0.102: v1(272.77,32.58) 272.21,32.58 271.75,33.04 RE640.2 RE641.1 271.87,33.79 QE57.2
N25774735: length 12.9
  TOP w0.102: v2(216.14,157.77) 216.14,157.44 215.92,157.22 UG22.2 ; v2(210.83,159.76) 210.98,159.91 211.53,159.91 RG516.2 211.97,159.51 212.29,159.19 212.29,158.58 212.05,158.34 QG502.6
  IN2 w0.102: v2(210.83,159.76) 210.83,158.9 211.24,158.49 212.34,158.49 213.52,159.67 214.24,159.67 v2(216.14,157.77)
  BOTTOM w0.102: v1(211.21,160.64) 211.21,160.14 v2(210.83,159.76)
N25802636: length 3.2
  BOTTOM w0.102: UG11.5 194.2,117.58 194.81,118.19 RG65.2 195,118.62 v1(194.52,119.11)
N25802642: length 35.5
  TOP w0.102: v2(184.72,114.29) 185.26,113.76 186.98,113.76 187.21,113.53 188.69,113.53 190.53,115.37 192.54,115.37 192.62,115.45 v1(193.38,115.45) 193.66,115.73 v2(194.31,115.73)
  BOTTOM w0.102: QG5.3 194.38,122.38 188.45,122.38 184.04,117.98 184.04,114.97 v2(184.72,114.29) ; 194.21,115.63 v2(194.31,115.73) 194.8,115.73 RG63.2 ; 194.21,115.63 192.97,114.39 192.97,114.27 192.29,113.58 192.29,112.82 191.97,112.5 RG529.2 ; 194.21,115.63 UG11.8
N25805684: length 27.1
  IN6 w0.102: v2(223.57,112.65) 224.01,113.09 224.01,116.08 223.4,116.68 223.4,117.42 222.89,117.92 222.89,119.86 221.97,120.78 220.21,120.78 218.57,119.15 216.72,119.15 216.23,118.65 213.96,118.65 210.76,121.85 209.81,121.85 208.34,120.38 v2(208.34,119.95)
  BOTTOM w0.1: UG9.BG8 v2(223.57,112.65)
  BOTTOM w0.102: RG19.1 208.43,119.86 v2(208.34,119.95)
N25805686: length 30.1
  IN6 w0.102: v2(207.65,118.84) 207.91,119.09 207.91,120.27 209.71,122.08 210.86,122.08 214.06,118.88 216.14,118.88 216.59,119.34 218.44,119.34 220.14,121.04 222.11,121.04 223.08,120.06 223.08,118.06 223.59,117.55 223.59,116.76 224.2,116.16 224.2,112.58 v2(223.57,111.95)
  BOTTOM w0.1: UG9.BF8 v2(223.57,111.95)
  BOTTOM w0.102: v2(207.65,118.84) 207.73,118.76 RG20.1
N25867602: length 3.4
  TOP w0.102: RE160.2 203.98,173.64 203.98,172.43 203.24,171.69 QE13.6
N25867965: length 3.3
  TOP w0.102: QE21.6 200.76,171.9 201.18,172.32 201.18,173.65 RE155.2
N25868866: length 5.5
  TOP w0.102: v1(207.02,175.22) RE157.2 206.23,174.72 206.23,172.31 205.71,171.79 QE22.6
N26196167: length 2.9
  TOP w0.102: UE5.2 305.14,25.04 305.06,25.11 RE646.2 v1(305.93,25.84)
N26590619: length 4.7
  TOP w0.102: v2(20.27,55.28) 20.9,54.64 RU15.1 v1(22.08,54.21)
  BOTTOM w0.107: v2(20.27,55.28) 20.27,54.07 19.82,53.63 UU7.1
N26590621: length 3.1
  TOP w0.102: v1(19,55.85) v2(19,55.34) 20.01,54.32 RU16.1
  BOTTOM w0.107: v2(19,55.34) 19,55.15 18.62,54.77 UU7.20
N26590623: length 4.2
  TOP w0.102: v1(13.56,54.15) RU17.1 14.87,54.39 v2(15.38,54.9)
  BOTTOM w0.107: v2(15.38,54.9) 15.64,54.63 15.64,53.88 15.89,53.63 UU7.16
N26590625: length 3.6
  TOP w0.102: v2(18.36,55.28) 19.12,54.52 RU20.1 v1(17.87,54.21)
  BOTTOM w0.107: UU7.19 18.12,55.03 v2(18.36,55.28)
N26590627: length 3.5
  TOP w0.102: RU19.1 16.65,54.26 v2(17.66,55.28)
  BOTTOM w0.102: v2(17.66,55.28) v1(18.44,56.05)
  BOTTOM w0.107: UU7.18 17.62,55.23 v2(17.66,55.28)
N26590629: length 5.1
  TOP w0.107: RU18.1 17.52,55.91 v2(17.66,55.91)
  BOTTOM w0.102: v2(17.66,55.91) v1(16.93,55.91)
  BOTTOM w0.107: v2(17.66,55.91) 17.12,55.37 UU7.17
N26590633: length 3.8
  BOTTOM w0.508: RU23.1 RU21.1 21.39,48.11 RU12.2
  vias: v1(21.42,51.91)
N26590645: length 3.9
  BOTTOM w0.102: v1(16.43,46.96) 16.43,47.94 RU14.1 17.62,49.13 UU7.9
N26590649: length 3.7
  BOTTOM w0.102: RU23.2 18.31,48.92 17.59,48.2 17.59,47.31 v1(17.83,47.07)
  BOTTOM w0.107: UU7.8 18.12,49.73 18.31,49.53 RU23.2
N26590685: length 2.6
  BOTTOM w0.102: RU14.2 v1(15.49,49.02)
  BOTTOM w0.107: UU7.10 17.12,49.91 16.6,49.39 RU14.2
N26590716: length 2.8
  BOTTOM w0.102: v1(20.28,48.67) 19.55,48.67 RU21.2
  BOTTOM w0.107: RU21.2 19.2,49.27 18.62,49.85 UU7.7
N27238854: length 3.5
  BOTTOM w0.102: RV671.1 236.2,163.8 236.13,163.72 UV3.9 234.87,163.72 v1(233.78,164.81)
N27238870: length 2.4
  BOTTOM w0.102: UV3.12 236.38,161.77 236.48,161.88 v1(236.8,161.88) RV672.1
N27472757: length 94.6
  TOP w0.102: v2(204.69,58.43) 204.1,57.84 204.1,56.69 204.56,56.23 205.6,56.23 212.42,49.41 v1(213.83,49.41)
  IN4 w0.102: v2(204.69,58.43) 204.69,62.63 198.82,68.51 191.8,68.51 190.59,69.72 190.59,73.9 190.17,74.32 190.17,79.42 191.09,80.35 191.09,94.34 190.61,94.83 190.61,101.42 192.29,103.1 192.29,103.89 192.44,104.05 192.44,104.75 191.13,106.06 191.13,109.81 193.51,112.19 195.05,112.19 196.12,113.27 196.71,113.27 196.96,113.52 196.96,114.51 196.02,115.45 196.02,117.3 197.37,118.65 v2(197.95,118.65)
  BOTTOM w0.102: QG510.2 198.88,119.1 198.44,118.65 v2(197.95,118.65) 197.68,118.38 RG1.1
N28080092: length 2.9
  TOP w0.102: CG313.1 RG523.2 RG102.2 v1(273.44,101.4)
N28084182: length 3.4
  TOP w0.102: RG524.2 RG103.2 CG314.1 v1(271.15,102.56)
N28087019: length 3.4
  BOTTOM w0.102: CG315.1 264.85,60.64 RG525.2 RG113.2 264.32,62.77 v1(264.83,63.28)
N28087890: length 3.1
  TOP w0.102: v1(274.6,65.34) CG316.1 RG526.2 RG114.2
N28090623: length 3.2
  TOP w0.102: RG527.2 RG124.2 CG317.1 229.4,63.61 v1(228.82,64.18)
N28092415: length 3.3
  TOP w0.102: CG318.1 RG528.2 RG125.2 230.93,63.05 v1(231.3,63.42)
N28094238: length 3
  BOTTOM w0.102: v1(202.22,86.05) RG160.2 RG531.2 CG387.1
N28096445: length 2.8
  BOTTOM w0.102: v1(199.11,84.49) CG388.1 RG532.2 RG164.2
N28329347: length 4.4
  BOTTOM w0.102: QG8.1 191.73,83.71 v1(191.44,83.42)
  BOTTOM w0.508: QG8.1 192.03,84.92 193.23,84.92 193.43,85.12 RG156.1
N28330529: length 5.6
  BOTTOM w0.102: RG133.1 v1(230.22,55.49) 230.42,55.29 230.42,51.94 QG4.1
N28331699: length 7.4
  BOTTOM w0.305: QG3.1 283.81,66.94 v1(280.83,66.94) 279.87,66.94 278.82,67.98 RG122.1
N29076894: length 3.4
  BOTTOM w0.102: RG530.2 207.82,125.41 208.4,124.82 RG540.2 208.87,124.82 209.13,124.57 210.03,124.57 210.27,124.32 QG500.6
N29125650: length 1.6
  BOTTOM w0.102: RG529.1 191.92,113.84 192.16,114.08 UG11.9
N29389682: length 4.1
  TOP w0.102: RE32.2 v1(189.96,23.81)
  TOP w0.107: RE32.2 191.03,23.37 190.57,22.92 190.57,22.52 191.03,22.07 191.03,21.8 190.92,21.69 UE4.24
N29389707: length 1.7
  TOP w0.107: UE4.30 187.1,23.63 RE37.1
N29418337: length 1
  BOTTOM w0.254: PC508.2 120.43,137.53 120.44,137.54 120.44,137.96 PR525.1
N29418339: length 4.8
  BOTTOM w0.203: PR531.1 121.33,139.46 v1(122.08,140.21) 122.36,140.48 PU500.5
  BOTTOM w0.254: PR522.1 PR525.2 120.63,139.19 PR531.1
N29418355: length 2.4
  BOTTOM w0.102: PC533.2 125.25,148.58 v1(125.79,149.12)
  BOTTOM w0.254: PR546.2 125.25,146.95 PC533.2
N29418359: length 4.3
  BOTTOM w0.203: PU500.17 125.87,144.93 125.61,145.2 125.61,145.68 PR546.1
  BOTTOM w0.254: PR549.1 PR546.1 PR550.2
N29418369: length 2
  BOTTOM w0.102: v1(134.24,144.85) 134.24,144.09 PC514.1
  BOTTOM w0.254: PR532.2 133.99,143.85 PC514.1
N29418371: length 51
  IN1 w0.254: v2(123.41,145.29) 124.61,146.49 128.77,146.49 129.96,147.68 129.96,148.69 130.54,149.28 130.54,149.7 132.01,151.16 141.87,151.16 142.3,150.73 143.72,150.73 144.47,151.48 149.23,151.48 150.12,150.59 158.26,150.59 159.39,149.46 161.98,149.46 v2(163.71,147.74)
  BOTTOM w0.102: v2(163.71,147.74) v1(163.71,148.29)
  BOTTOM w0.254: PC5011.2 121.1,146.28 121.35,146.02 PR547.2 123.4,146.02 PR545.1 v2(123.41,145.29) ; v2(163.71,147.74) 163.71,147.69 163.97,147.42 PH504.2
N29418373: length 6.6
  BOTTOM w0.102: PR532.1 131.11,143.85 v1(131,143.73)
  BOTTOM w0.203: PU500.30 130.86,141.28 131.64,142.06 131.64,142.39 PR533.1
  BOTTOM w0.254: PR536.1 132.17,144.76 PR532.1 132.17,142.93 PR533.1
N29418377: length 2.2
  BOTTOM w0.203: PU500.15 125.07,144.7 124.53,145.25 124.53,145.83 PR545.2
N29418393: length 39.7
  IN3 w0.254: v2(140.85,149.71) 140.59,149.71 138.45,151.85 131.44,151.85 130.09,150.5 127.19,150.5 126.76,150.07 126.76,148.02 124.53,145.79 124.53,144.43 123.77,143.67 121.99,143.67 121.12,142.79 121.12,140.99 120.6,140.47 120.6,135.67 v2(121.16,135.1)
  BOTTOM w0.102: PH500.2 v1(138.49,149.05)
  BOTTOM w0.254: PR514.1 120.43,135.26 PR513.2 ; PH500.2 140.34,149.71 v2(140.85,149.71) ; PR513.2 121.02,135.24 v2(121.16,135.1) ; PR513.2 120.45,134.36 PC5010.2
N29418395: length 4.8
  BOTTOM w0.203: PU500.3 122.89,139.68 122.05,138.85 122.05,136.84 PR514.2
N29418397: length 4.9
  TOP w0.102: PR521.2 121.17,139.48 v1(120.32,138.63)
  TOP w0.254: PR521.2 121.5,139.59 121.55,139.54 v2(122.06,139.54) 122.14,139.62 PC505.2
  BOTTOM w0.203: PU500.4 122.6,140.08 v2(122.06,139.54)
N29418405: length 3.3
  TOP w0.102: v2(130.28,137.88) 130.84,137.88 v1(131.1,137.62)
  TOP w0.254: PR527.1 129.74,137.31 129.75,137.32 129.75,137.35 v2(130.28,137.88)
  BOTTOM w0.203: v2(130.28,137.88) 130.31,137.91 130.31,138.47 129.89,138.88 PU500.36
N29418417: length 3.9
  BOTTOM w0.203: PR524.1 132.17,139.38 131.75,139.8 130.88,139.8 130.59,140.08 PU500.33
  BOTTOM w0.254: PC509.2 132.17,138.5 PR524.1
N29418423: length 3.7
  TOP w0.102: v2(130.56,141.77) 130.85,141.77 v1(131.07,141.55)
  TOP w0.254: v2(130.56,141.77) 130.48,141.84 130.12,141.84 PR537.1 129.63,142.34 PC520.2
  BOTTOM w0.203: PU500.29 130.48,141.68 v2(130.56,141.77)
N29418425: length 5.7
  TOP w0.102: v2(131.13,142.23) 131.22,142.23 v1(131.89,142.89)
  TOP w0.254: PR539.1 129.23,143.21 PC519.1 130.49,142.4 130.56,142.4 130.74,142.23 v2(131.13,142.23)
  BOTTOM w0.203: v2(131.13,142.23) 130.26,142.23 130.12,142.08 PU500.28
N29418433: length 4.6
  TOP w0.102: PR515.2 v1(121.28,136.13)
  TOP w0.254: PR515.2 PR520.2 124.02,136.7 v2(124.02,136.75)
  BOTTOM w0.203: v2(124.02,136.75) 124.02,136.75 124.67,137.4 PU500.47
N29418441: length 2.1
  BOTTOM w0.203: PR518.1 127.83,136.42 127.83,137.07 127.47,137.42 PU500.40
N29418445: length 2.1
  BOTTOM w0.203: PR517.1 128.16,136.55 128.16,137.2 127.87,137.49 PU500.39
N29418451: length 2.3
  BOTTOM w0.203: PU500.38 128.27,137.58 128.53,137.32 128.53,137.07 PR516.1
N29418455: length 4
  BOTTOM w0.102: v1(131.47,135.76) 131.14,135.76 130.69,136.2 PR519.1
  BOTTOM w0.203: PU500.37 128.67,137.68 129.1,137.26 129.23,137.26 PR519.1
N29418473: length 4.3
  TOP w0.254: PC536.1 125.04,143.42 125.02,143.43 PR551.1 125.04,144.32 v2(125.04,145.39)
  BOTTOM w0.203: PU500.16 125.47,144.82 125.04,145.26 v2(125.04,145.39)
N29418487: length 4.5
  TOP w0.102: v1(127.85,135.11) 127.6,135.35 PR506.1
  TOP w0.254: PC504.1 127.64,137.14 v2(127.32,136.83) 127.6,136.55 PR506.1
  BOTTOM w0.203: v2(127.32,136.83) 127.32,137.07 127.07,137.32 PU500.41
N29418491: length 2.5
  BOTTOM w0.203: PU500.48 124.27,137.7 124.02,137.45 123.83,137.45 123.17,136.79 PR523.2
N29419473: length 5.6
  TOP w0.102: v2(122.51,138.53) 122.34,138.53 v1(122.07,138.8)
  TOP w0.254: PR500.2 125.4,137.9 124.06,137.9 PC500.2 123.17,138.8 122.78,138.8 v2(122.51,138.53)
  BOTTOM w0.203: v2(122.51,138.53) 122.5,138.54 122.5,138.78 123,139.28 PU500.2
N29419486: length 3.4
  BOTTOM w0.203: PC518.2 121.39,142.6 v1(122.17,141.83) 122.31,141.68 PU500.8
  BOTTOM w0.254: PR540.2 PC518.2
N29419576: length 2.2
  TOP w0.254: PC506.2 122.86,140.51 122.47,140.12 v1(122.11,140.12) 121.74,140.12 121.34,140.51 PR521.1
N29419623: length 2.1
  TOP w0.102: PH502.1 121.8,147.3 v1(121.28,146.78)
  TOP w0.254: PH502.1 PR534.2
N29419647: length 2.1
  TOP w0.102: PC521.1 129.74,139.76 v1(129.37,139.39)
  TOP w0.254: PC521.1 PR537.2
N29419655: length 2.3
  BOTTOM w0.102: v1(134.27,146.21) 133.72,145.65 PC522.1
  BOTTOM w0.254: PC522.1 PR536.2
N29419663: length 3.4
  BOTTOM w0.102: PR530.1 186.59,135.93 v1(187.09,136.43)
  BOTTOM w0.254: PH501.2 PR530.1
N29419667: length 61.4
  TOP w0.254: PR544.1 122.27,146.94 v2(121.87,146.53)
  IN6 w0.254: v2(121.87,146.53) 122.27,146.94 122.84,146.94 124.5,145.27 124.5,145.22 125.1,144.62 128.32,144.62 129.4,145.7 129.85,145.7 130.95,144.61 130.95,144.15 131.39,143.71 131.57,143.71 132.25,143.03 133.52,143.03 134.91,141.64 134.91,130.91 136.92,128.9 154.27,128.9 155.26,129.89 160.37,129.89 161.3,128.96 163.3,128.96 v2(164.29,129.96)
  BOTTOM w0.254: v2(164.29,129.96) PH503.2
N29419693: length 0.9
  BOTTOM w0.254: PR538.2 121.41,143.65 PC518.1
N29419713: length 3.4
  BOTTOM w0.203: PR526.2 122.28,136.6 v1(122.71,137.02) 123,137.32 123,138.78 123.11,138.88 PU500.1
N29419730: length 2
  BOTTOM w0.102: v1(131.09,137.56) PC509.1
  BOTTOM w0.254: PC509.1 PR528.2
N29419832: length 3.9
  TOP w0.102: PR505.2 126.19,136.2 v1(125.67,136.73)
  TOP w0.254: PR505.2 126.73,136.92 v2(126.75,136.94) 126.5,137.19 PC503.1
  BOTTOM w0.203: v2(126.75,136.94) 126.67,137.02 PU500.42
N29419860: length 5.4
  TOP w0.102: PR548.1 122.54,144.2 v1(122.54,145.05)
  TOP w0.254: v2(124.02,145.07) 124.36,144.73 124.36,144.25 124.31,144.2 124.31,144.18 123.89,143.76 PC535.2 PR548.1
  BOTTOM w0.203: v2(124.02,145.07) 124.21,145.07 124.67,144.61 PU500.14
N29419910: length 1.8
  TOP w0.254: PC538.2 125.93,144.3 PR551.2
N29419918: length 2.3
  BOTTOM w0.102: v1(123.96,149.12) 124.38,148.7 PR549.2
  BOTTOM w0.254: PR549.2 123.51,147.82 PC537.1
N29419943: length 4.2
  BOTTOM w0.102: v4(127.42,148.15) 127.29,148.02 PC532.1
  BOTTOM w0.203: PR541.1 127.29,145.58 127.2,145.49 127.2,145.07 127.07,144.95 PU500.20
  BOTTOM w0.254: PR541.1 PC532.1
N29419947: length 3.4
  BOTTOM w0.102: v1(128.95,148.47) 128.44,148.47 127.76,147.78 127.76,147.31 128.15,146.92 PC532.2
  BOTTOM w0.254: PC532.2 129.06,146.92 PR543.1
N29425467: length 7.7
  TOP w0.102: v1(173.63,137.89) PR575.1
  TOP w0.254: v2(177.02,134.97) 176.89,135.1 PR578.1 176.1,135.67 PR577.2
  TOP w0.508: PR575.1 v2(175.46,139.1)
  BOTTOM w0.254: PL503.2 v2(177.02,134.97)
N29425497: length 7.6
  TOP w0.102: v1(165.73,137.55) 166.01,137.83 PR565.1
  TOP w0.254: PR567.2 168,135.77 PR568.1 168.58,135.18 v2(168.66,135.1)
  TOP w0.508: v2(167.2,139.04) PR565.1
  BOTTOM w0.254: PL502.2 171.01,135.1 v2(168.66,135.1)
N29425633: length 9.1
  TOP w0.102: PR555.1 v1(156.23,137.89)
  TOP w0.254: v2(160.28,135.1) 160.23,135.05 PR558.1 159.58,135.71 PR557.2
  TOP w0.508: v2(158.71,137.89) PR555.1
  BOTTOM w0.254: v2(160.28,135.1) 159.81,135.57 PL501.2
N29426641: length 3.2
  BOTTOM w0.102: v1(172.86,146.18) 173.06,146.39 PR573.2
  BOTTOM w0.254: PR573.2 174.27,146.37 174.27,145.77 174.75,145.29 PU504.1
N29426805: length 3.7
  TOP w0.102: v1(161.23,134.58) PC548.1
  TOP w0.508: PR555.2 161.23,137.07 PC548.1
N29426831: length 3.1
  TOP w0.102: v1(169.87,134.75) PC556.1
  TOP w0.508: PC556.1 PR565.2
N29426855: length 3.2
  TOP w0.102: v1(178.12,134.69) PC564.1
  TOP w0.508: PC564.1 PR575.2
N29435109: length 2.5
  TOP w0.254: v2(185.05,134.53) 185.05,134.4 185.33,134.11 PR5002.1 185.33,133.1 184.83,132.59 PR5003.1
  vias: v1(185.89,137.55)
N29435333: length 8.4
  TOP w0.102: v1(149.5,141.34) 149.78,141.07 PR593.1
  TOP w0.254: v2(152.15,137.96) 151.77,138.34 PR596.1 151.4,138.82 PR595.2
  TOP w0.508: PR593.1 v2(151.2,142.34)
  BOTTOM w0.254: PL506.2 150.69,139.41 v2(152.15,137.96)
N29435335: length 4.2
  TOP w0.102: v1(182.27,133.51) 182.27,133.52 PC587.1
  TOP w0.508: PC587.1 185,136.25 PR5002.2
N29436554: length 7.6
  TOP w0.102: v1(144.78,136.61) 144.78,137.52 v2(143.96,138.34)
  TOP w0.254: v2(143.96,138.34) 143.92,138.38 PR587.1 143.31,138.88 PR586.2
  TOP w0.508: v2(142.56,142.28) PR584.1
  BOTTOM w0.254: v2(143.96,138.34) 143.57,138.73 PL505.2
N29436709: length 3.1
  TOP w0.102: v1(153.87,137.96) PC580.1
  TOP w0.508: PC580.1 PR593.2
N29436789: length 3.7
  TOP w0.102: PC570.1 145.29,138.75 v1(146.24,137.8)
  TOP w0.508: PC570.1 145.23,139.48 PR584.2
N29438561: length 2.1
  BOTTOM w0.203: PU500.43 126.27,136.66 126.3,136.63 126.3,136.54 126.7,136.14 PR512.2
N29438565: length 1.9
  BOTTOM w0.203: PU500.44 125.87,136.18 PR510.2
N29438567: length 2.7
  TOP w0.102: v1(125.75,135) 125.84,134.92 v2(125.84,134.5)
  TOP w0.107: PR502.2 125.83,134.5 v2(125.84,134.5)
  BOTTOM w0.107: PR510.1 v2(125.84,134.5) PR509.1
N29438569: length 3.2
  TOP w0.102: v1(124.44,135.02) 124.63,134.84 v2(124.63,134.55)
  TOP w0.107: v2(124.63,134.55) 124.62,134.54 124.62,134.1 PR501.2
  BOTTOM w0.107: PR507.2 124.63,134.11 v2(124.63,134.55) 124.63,134.97 124.88,135.23 PR508.1
N29438571: length 2.2
  BOTTOM w0.203: PU500.45 125.47,136.64 124.97,136.14 PR508.2
N29438583: length 4.1
  TOP w0.102: v1(128.13,133.43) 127.77,133.79 PR503.2
  TOP w0.107: PR503.2 126.72,134.18 v2(127.04,134.5)
  BOTTOM w0.107: PR512.1 126.79,135.23 127.04,134.97 v2(127.04,134.5) 126.73,134.19 PR511.1
N29438934: length 2.3
  BOTTOM w0.203: PU500.46 125.07,137.15 124.06,136.14 PR504.2
N29599145: length 2.2
  BOTTOM w0.102: PC507.1 v1(118.36,137.03)
  BOTTOM w0.254: PR522.2 119.55,137.96 PC507.1
N29647096: length 2.7
  TOP w0.102: v1(297.43,64.84) RU25.1 RU24.2 296.49,64.24 QU1.2
N29700600: length 2.4
  TOP w0.102: v1(188.91,96.27) RG535.2 188.85,97.3 UG24.2 UG24.3
N29702846: length 1
  TOP w0.102: RX38.2 210.68,161.54 LX8.1
N29702855: length 2.5
  TOP w0.102: v1(212.63,162.19) 212.63,161.52 LX7.1 212.03,161.13 RX37.2
N29702861: length 0.9
  TOP w0.102: LX6.1 216,161.47 RX36.2
N29702867: length 1.9
  TOP w0.102: v1(217.37,162.5) 216.78,161.91 RX35.2 216.56,161.46 LX5.1
N29702873: length 0.9
  TOP w0.102: LX4.1 218.26,161.33 RX34.2
N29702889: length 0.9
  TOP w0.102: LX3.1 218.83,161.43 RX33.2
N29702919: length 0.9
  TOP w0.102: RX32.2 213.7,161.43 LX2.1
N29702925: length 2.2
  TOP w0.102: LX1.1 214.27,161.39 RX31.2 214.47,161.88 214.69,162.1 214.69,162.34 v1(215.12,162.78)
N30005754: length 2.4
  TOP w0.089: v2(214.19,26.41) 214.19,26.4 214.65,26.87 CH70.1 v1(215.67,27.01)
  BOTTOM w0.203: v2(214.19,26.41) 214.19,26.57 214.45,26.84 UH1.BA26
N30070819: length 2.4
  TOP w0.102: v1(235.21,60.34) 235.21,59.81 234.79,59.38 v2(234.79,59.31)
  TOP w0.305: v2(234.79,59.31) 234.24,59.31 RG131.1
  BOTTOM w0.107: UG6.J13 v2(234.79,59.31)
N30070822: length 2
  TOP w0.102: v2(245.39,58.91) 244.99,58.91 v1(244.89,58.81)
  TOP w0.305: v2(245.39,58.91) 245.41,58.88 RG127.1
  BOTTOM w0.305: UG6.J1 v2(245.39,58.91)
N30070830: length 2.7
  TOP w0.102: RG129.1 v1(239.89,58.27)
  TOP w0.305: v2(238.14,58.96) 238.71,58.39 RG129.1
  BOTTOM w0.102: v2(238.14,58.96) 238.09,58.91 UG6.J10
N30712936: length 3.9
  TOP w0.102: PR727.2 54.42,18.65 v1(53.82,18.05)
  TOP w0.203: PR727.2 55.25,19.4 55.63,19.78 56.04,19.78 56.24,19.98 PU700.15
N30746783: length 2.3
  BOTTOM w0.203: PR210.2 95.77,41.79 95.2,42.36 95.2,42.56 94.56,43.2 PU201.10
N30816588: length 1.5
  TOP w0.254: UA2.B2 22,28.28 RA84.1 RA85.1
N30963031: length 3.8
  TOP w0.102: v1(187.49,110.57) 187.89,110.98 RG509.2 188.49,110.97 QG503.5 189.84,110.97 190,110.8 190,110.4 189.92,110.32 QG503.6
N30963037: length 1.1
  TOP w0.432: QG503.3 192,111.62 RG510.2
N30963062: length 3.8
  TOP w0.102: QG504.6 188.89,106.52 189.02,106.39 189.43,106.39 189.54,106.51 QG504.5 189.54,107.53 189.63,107.61 RG511.2 v1(190.61,108.05)
N30963079: length 2.9
  TOP w0.102: RG512.2 188.22,104.11 v1(188.11,103.99)
  TOP w0.432: RG512.2 189.8,104.29 190.19,104.68 QG504.3
N30963101: length 4.1
  TOP w0.102: 192.55,106.46 193.11,106.46 193.23,106.58 QG505.5 ; 192.55,106.46 191.6,106.46 RG513.2 v1(191.27,105.2) ; 192.55,106.46 192.58,106.49 QG505.6
N30963122: length 2.5
  TOP w0.102: RG514.2 195.98,105.14 v1(196.26,105.42)
  TOP w0.508: QG505.3 193.92,105.14 RG514.2
N30964064: length 3.1
  BOTTOM w0.102: QG507.5 QG507.6 289.34,84.13 RG541.2 v1(288.12,83.13)
N30964087: length 1.1
  BOTTOM w0.102: RG542.2 v1(290.88,88.49)
N31077401: length 2.5
  TOP w0.102: v1(119.93,76.19) 119.73,76.4 PQ710.3
  TOP w0.254: PR732.2 118.88,77.83 119.45,77.25 PQ710.3
N31077403: length 5.7
  TOP w0.254: PR729.1 122.32,77.95 ; 122.32,77.95 122.32,78.35 ; 122.32,77.95 122.28,77.9 PQ710.5 ; PQ710.6 122.12,78.55 122.32,78.35 ; PR730.2 122.13,79.71 122.56,79.28 v1(122.56,78.82) 122.32,78.58 122.32,78.35
N31077444: length 4.1
  TOP w0.102: v1(116.44,77.83) PR731.2
  TOP w0.254: PQ710.2 119.51,77.9 PC724.1 117.75,77.87 PR731.2
N31201664: length 2.5
  TOP w0.102: UG26.4 278.37,154.79 RG545.1 278.74,155.73 v1(278.44,156.03)
N31204217: length 1.7
  TOP w0.102: v1(307.26,59.47) 306.89,59.84 306.89,60.29 307.22,60.62 RG533.2
N31214366: length 2.4
  TOP w0.102: QG502.2 RG553.2 212.7,154.4 v1(213.11,153.98)
N31214429: length 1.9
  TOP w0.102: v2(217.01,158.11) 216.61,158.52 UG22.4
  BOTTOM w0.102: RG554.1 217.01,157.39 v2(217.01,158.11) v1(216.63,158.49)
N31214439: length 6.3
  TOP w0.102: v2(214.09,156.22) 213.58,156.72 213.14,156.72 212.86,157 212.86,157.45 212.7,157.61 QG502.5
  BOTTOM w0.102: v2(214.09,156.22) 214.52,155.78 215.01,155.78 v1(216.01,156.79) RG554.2
N31227786: length 3.1
  BOTTOM w0.102: QG508.6 QG508.5 289.74,81.14 RG543.2 289.57,81.31 v1(288.36,81.31)
N31227804: length 1.2
  BOTTOM w0.102: RG544.2 v1(287.96,77.16)
N31306212: length 2
  BOTTOM w0.254: 181.75,144.11 182.09,143.77 182.18,143.77 182.43,143.51 PU511.1
  BOTTOM w0.279: PR5006.2 181.68,144.74 181.68,144.18 181.75,144.11
N31425874: length 1.6
  BOTTOM w0.102: v1(159.32,148.8) 160.41,147.71 PC541.1
N31426231: length 2
  BOTTOM w0.254: PR552.2 157.38,145.96 158.08,145.26 PU502.1
N31426252: length 2
  BOTTOM w0.254: PR556.2 158.07,146.47 158.07,145.83 158.58,145.32 PU502.2
N31426527: length 7
  TOP w0.102: PR5028.2 158.26,142.4 v1(158.26,143.33)
  TOP w0.305: PR5028.2 158.22,142.28 157.45,141.51 PC5005.1
  TOP w0.381: v2(156.45,141.61) 157.23,141.61 PC5005.1
  IN1 w0.254: v2(156.45,141.61) 156.82,141.61 157.23,142.02 157.23,143.11 156.98,143.36 156.58,143.36 v2(156.53,143.41)
  BOTTOM w0.254: PU502.24 156.74,143.2 v2(156.53,143.41)
N31427446: length 3.5
  TOP w0.102: v2(158.8,146.03) 158.8,146.39 v1(159.09,146.68)
  TOP w0.254: PC540.2 158.67,145.9 v2(158.8,146.03)
  BOTTOM w0.254: PU502.3 159.08,145.38 158.8,145.66 v2(158.8,146.03) 158.8,146.3 PR553.1
N31433757: length 1.7
  BOTTOM w0.102: PR564.1 171.08,147.64 v1(171.51,148.08)
N31433761: length 1.4
  BOTTOM w0.102: PR564.2 170.45,146.24 170.68,146.48 v1(171.29,146.48)
N31434994: length 1.6
  BOTTOM w0.254: PU503.2 166.91,145.38 166.69,145.6 166.69,146.23 PR566.2
N31435092: length 1.7
  BOTTOM w0.254: PU503.1 166.41,145.23 165.93,145.71 PR563.2
N31436196: length 1.6
  BOTTOM w0.102: PC558.1 177.1,147.8 v1(176.07,148.83)
N31436380: length 1.5
  BOTTOM w0.254: PU504.2 175.25,145.35 175.1,145.5 175.1,146.32 PR576.2
N31438582: length 5.2
  TOP w0.102: v1(173.45,139.61) 173.35,139.71 173.35,140.89 174.01,141.54 PC5007.1
  TOP w0.254: v2(173.17,142.84) 173.17,142.72 173.47,142.42 PR5030.2 173.95,141.62 PC5007.1
  BOTTOM w0.254: PU504.24 173.5,143.17 v2(173.17,142.84)
N31438896: length 3.4
  TOP w0.102: v2(175.58,145.7) 175.58,146.23 v1(175.85,146.5)
  TOP w0.254: PC557.2 175.53,145.65 v2(175.58,145.7)
  BOTTOM w0.254: PR5020.1 176.05,146.38 175.58,145.91 v2(175.58,145.7) 175.58,145.56 175.75,145.39 PU504.3
N31439632: length 1.7
  BOTTOM w0.102: v1(147.14,151.61) 146.49,150.96 PR583.1
N31439637: length 7.6
  TOP w0.102: PR8215.2 242.86,30.88 v1(242.87,30.89)
  TOP w0.254: PR8218.2 241.89,32.66 v2(242.2,32.35) ; PR8218.2 PC8217.1 PR8215.2 ; PR8218.2 PR8211.1
  BOTTOM w0.203: PR8208.2 242.2,31.26 v2(242.2,32.35) 242.35,32.51 PU8200.7
N31439658: length 1.4
  BOTTOM w0.102: PR583.2 146.75,149.56 v1(146.99,149.79)
N31439736: length 1.5
  BOTTOM w0.254: PU507.2 142.56,148.67 142.43,148.8 142.43,149.6 PR585.2
N31439790: length 1.7
  BOTTOM w0.254: PU507.1 142.06,148.57 141.58,149.06 PR590.2
N31442956: length 3.6
  TOP w0.102: v1(143.35,149.96) 142.93,149.53 v2(142.93,148.98)
  TOP w0.254: PC566.2 142.84,148.89 v2(142.93,148.98)
  BOTTOM w0.254: PR5022.1 143.36,149.58 142.93,149.16 v2(142.93,148.98) 143.06,148.85 PU507.3
N31442990: length 4.1
  TOP w0.102: PC5008.1 140.64,144.79 v1(140.34,144.49)
  TOP w0.254: v2(140.47,146.27) 140.47,146.02 140.83,145.66 PR5031.2 141.3,144.82 PC5008.1
  BOTTOM w0.254: PU507.24 140.63,146.44 v2(140.47,146.27)
N31443441: length 5.4
  TOP w0.102: v2(167.26,145.7) 167.26,145.02 v1(167.76,144.52)
  TOP w0.254: v2(167.26,145.7) 167.26,146.33 168.17,147.24 PC549.2
  BOTTOM w0.254: PU503.3 167.41,145.56 v2(167.26,145.7) 167.26,145.77 167.7,146.21 PR5004.1
N31452288: length 1.1
  BOTTOM w0.102: PC574.1 v1(152.74,152.11)
N31452345: length 3
  BOTTOM w0.102: PR591.2 149.12,149.67 v1(148.75,150.04)
  BOTTOM w0.254: PU510.1 150.39,148.44 150.17,148.67 150.17,148.92 149.91,149.18 PR591.2
N31452390: length 1.6
  BOTTOM w0.254: PU510.2 150.89,148.64 150.67,148.86 150.67,149.54 PR594.2
N31459506: length 3.5
  TOP w0.102: v1(151.62,149.94) 151.26,149.58 v2(151.26,149.01)
  TOP w0.254: PC573.2 151.15,148.89 v2(151.26,149.01)
  BOTTOM w0.254: PU510.3 151.39,148.87 v2(151.26,149.01) 151.26,149.2 151.69,149.62 PR5024.1
N31460044: length 5.1
  TOP w0.102: v1(148.94,143.01) 148.94,144.16 149.62,144.85 PC5009.1
  TOP w0.254: v2(148.79,146.21) 148.79,146.02 149.1,145.71 PR5032.2 PC5009.1
  BOTTOM w0.254: PU510.24 149.04,146.46 v2(148.79,146.21)
N31470989: length 1.4
  TOP w0.102: PR733.1 v1(79.89,26.03)
N31483113: length 3.9
  BOTTOM w0.102: PR8214.2 239.16,27.9 v1(238.71,27.44)
  BOTTOM w0.203: PQ8202.2 238.45,30.19 238.25,29.99 PC8222.1
  BOTTOM w0.254: PR8214.2 239.16,28.63 238.75,29.05 238.75,29.23 238.25,29.72 PC8222.1
N31483116: length 5
  TOP w0.102: v2(239.92,31.89) 239.43,31.89 v1(239.35,31.97)
  TOP w0.254: PR8215.1 240.45,30.88 239.92,31.41 v2(239.92,31.89)
  BOTTOM w0.254: PQ8202.3 237.8,31.3 238.21,31.71 239.74,31.71 v2(239.92,31.89)
N31483118: length 2.6
  BOTTOM w0.102: v1(237.31,36.29) 238.74,34.86 PR8220.2
N31487005: length 2.7
  BOTTOM w0.254: PU802.17 229.17,42.75 229.21,42.78 ; PU802.16 228.72,42.65 228.85,42.78 229.21,42.78 ; 229.21,42.78 229.56,43.14 PC822.1
N31487055:
  vias: v1(232.72,38.41)
N31487101: length 2.9
  BOTTOM w0.254: PR814.1 PR815.2 227.29,40.35 227.42,40.48 PU802.13
N31487107: length 1.7
  BOTTOM w0.102: PC823.1 234.35,42.45 v1(235.37,41.43)
N31487111: length 2.4
  BOTTOM w0.102: PR816.1 232.74,41.05 v1(234.36,39.43)
N31494164: length 1.4
  BOTTOM w0.102: PR5005.1 v1(186.56,146.15)
N31494209: length 1.3
  BOTTOM w0.102: PR5005.2 185.29,144.63 v1(186.44,144.63)
N31494627: length 7
  IN6 w0.254: v2(179.9,145.89) 181.55,145.89 181.75,145.7 181.75,143.8 v2(181.24,143.29)
  BOTTOM w0.254: PR5001.1 180.36,144.93 179.9,145.39 v2(179.9,145.89)
  BOTTOM w0.279: PU511.12 181.39,142.63 181.24,142.78 v2(181.24,143.29)
N31495785: length 5.4
  TOP w0.102: PC588.2 183.46,145.84 184.81,145.84 v1(184.96,145.69)
  TOP w0.254: PC588.2 182.32,144.7 v2(182.32,144.3)
  BOTTOM w0.254: PR5025.1 182.32,144.87 v2(182.32,144.3) 182.37,144.3 182.93,143.74 PU511.2
N31495969: length 4
  TOP w0.254: v2(180.73,142.84) 180.73,142.65 v1(181,142.39) 181.47,142.39 181.53,142.45 PR5026.2 182,141.71 PC5002.2
  BOTTOM w0.279: PU511.11 181.07,142.13 180.79,142.41 180.79,142.78 v2(180.73,142.84)
N31535656: length 2.4
  BOTTOM w0.203: PU100.19 51.8,46.08 51.62,46.25 v1(51.14,46.25) 50.37,46.25 PR107.1
N31565200: length 2
  TOP w0.102: v2(157.33,144.87) 157.33,144.9 v1(156.93,145.29)
  TOP w0.254: PR599.1 157.34,144.86 v2(157.33,144.87)
  BOTTOM w0.254: v2(157.33,144.87) PU502.26
N31565645: length 5.4
  TOP w0.254: PR5011.1 166.57,143.01 166.57,143.86 v2(165.66,144.77)
  BOTTOM w0.102: v2(165.66,144.77) 164.88,145.55 v1(163.71,145.55)
  BOTTOM w0.254: v2(165.66,144.77) PU503.26
N31565698: length 5.2
  TOP w0.102: PC5006.1 v1(165.88,139.14)
  TOP w0.254: PC5006.1 165.91,140.15 PR5029.2 165.31,141.59 165.31,142.45 v2(164.79,142.97)
  BOTTOM w0.254: PU503.24 164.97,143.15 v2(164.79,142.97)
N31566286: length 1.9
  TOP w0.102: v1(173.93,145.37) 174,145.29 v2(174,144.85)
  TOP w0.254: PR5019.1 174.02,144.83 v2(174,144.85)
  BOTTOM w0.254: v2(174,144.85) PU504.26
N31567454: length 2.7
  TOP w0.254: v2(141.31,148.11) 141.33,148.1 PR5021.1
  BOTTOM w0.102: v1(140.61,149.21) 141.31,148.5 v2(141.31,148.11)
  BOTTOM w0.254: v2(141.31,148.11) PU507.26
N31567631: length 2
  TOP w0.102: v1(149.55,148.79) 149.64,148.69 v2(149.64,148.13)
  TOP w0.254: v2(149.64,148.13) 149.66,148.12 PR5023.1
  BOTTOM w0.254: v2(149.64,148.13) PU510.26
N31787119: length 1.2
  TOP w0.102: PR6107.1 v1(253.84,153.78)
N31800685: length 4.9
  TOP w0.102: PR725.1 v1(67.26,32.15)
  TOP w0.508: PR725.1 67.26,33.69 67.64,34.07 69.25,34.07 69.76,34.58 PQ701.4
N31813250: length 8.7
  TOP w0.102: v2(65.03,40.86) v1(65.03,41.69)
  TOP w0.508: v2(65.03,40.86) 65.34,40.56 PR726.1
  BOTTOM w0.508: PQ707.4 69.73,39.15 68.67,40.21 65.68,40.21 v2(65.03,40.86)
N32073814: length 5
  TOP w0.102: v1(242.83,33.05) v2(242.19,33.05)
  TOP w0.254: v2(242.19,33.05) 242.19,33.85 241.6,34.44 PC8215.1
  BOTTOM w0.203: PR8208.1 241.69,32.67 242.07,33.05 v2(242.19,33.05) 242.33,32.91 PU8200.8
N32074224: length 3.2
  TOP w0.102: PR8204.2 v1(263.22,30.89)
  TOP w0.254: PR8204.2 265.12,30.4 PC8210.1
N32074541: length 3.2
  TOP w0.102: PR8210.2 v1(254.29,30.96)
  TOP w0.254: PC8219.1 252.48,30.4 PR8210.2
N32209563: length 3.8
  BOTTOM w0.254: PU1300.7 100.25,42.17 PR1304.2 99.35,42.17 PR1305.1 99.35,41.73 99.7,41.37 PC1305.2
N32209746: length 4.9
  BOTTOM w0.127: v1(95.63,49.47) 96.31,49.47 96.99,48.8 PR1300.2
  BOTTOM w0.254: PR1300.2 98.05,48.26 98.05,48.17 98.24,47.97 98.69,47.97 98.98,48.26 PU1300.1
N32274706: length 18.4
  TOP w1.016: 284.32,48.86 290.33,48.86 293.95,45.24 297.89,45.24 298.97,46.32 298.97,48.18
  vias: v1(281.4,51.51) v2(283.98,49.75) v2(284.62,49.75)
N32274716: length 13.3
  IN1 w0.762: 288.69,49.44 293.76,49.44 297.01,52.69
  IN2 w0.762: 286.77,48.66 286.77,45.02
  vias: v1(296.87,53.6) v2(287.08,49.75) v2(287.22,43.7) v2(287.35,44.27) v2(287.66,49.75) v2(297.57,54.02) v2(297.57,53.44)
N32295361: length 10.7
  IN6 w1.016: 304.11,47.72 303.03,47.72 298.71,43.4 295.16,43.4
  vias: v1(306.5,47.61) v2(289.72,50.36) v2(290.31,50.36) v2(293.12,43.53) v2(293.76,43.53) v2(305.38,47.91) v2(306.02,47.91)
N32295402: length 27.7
  IN1 w0.762: 290.08,44.29 290.46,44.29 292.3,42.45 302.97,42.45 304.43,43.91 304.43,46.13 305.25,46.96 306.9,46.96 308.84,48.9 308.84,49.44
  IN2 w0.762: 288.93,43.12 288.93,39.5
  vias: v1(309.62,49.71) v2(288.35,38.56) v2(288.55,44.5) v2(288.93,44.05) v2(288.93,38.56) v2(308.84,51) v2(308.84,50.42)
N32424441: length 1.3
  BOTTOM w0.102: 243.77,39.63 243.51,39.36 v1(243.51,38.4)
N32424557: length 4.1
  TOP w0.102: v2(239.4,40.86) v1(239.4,39.96)
  TOP w0.254: PR812.1 PR813.2 239.21,41.05 v2(239.4,40.86)
  BOTTOM w0.254: PU800.13 239.59,41.05 v2(239.4,40.86)
