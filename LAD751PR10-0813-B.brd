# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_A_TTX_C_DRX_N0: length 17.8
  TOP w0.089: v2(189.24,171.61) arc(189.2,171.62) 189.18,171.64 188.83,171.98 arc(188.77,172.07) 188.75,172.18 arc(188.72,172.24) 188.67,172.3 187.63,173.34 arc(187.5,173.43) 187.34,173.46 186.7,173.46 arc(186.19,173.54) 185.72,173.76 arc(185.7,173.78) 185.68,173.79 arc(185.62,173.84) 185.56,173.9 arc(185.48,174) 185.41,174.11 arc(185.34,174.32) 185.31,174.53 185.31,174.71 arc(185.18,175.04) 184.86,175.17 183.9,175.17 arc(183.71,175.11) 183.59,174.94 arc(183.58,174.89) 183.57,174.84 183.57,174.84 183.57,174.73 arc(183.58,174.69) 183.58,174.66 183.58,174.62 arc(183.58,174.61) 183.58,174.61 183.59,174.48 arc(183.6,174.44) 183.62,174.4 183.66,174.35 arc(183.68,174.32) 183.71,174.29 arc(183.73,174.27) 183.75,174.26 arc(183.78,174.23) 183.81,174.21 183.87,174.18 arc(183.92,174.17) 183.97,174.16 arc(184.19,174.1) 184.34,173.93 arc(184.39,173.78) 184.41,173.63 184.41,173.16 arc(184.46,172.9) CT42.1
  BOTTOM w0.089: JUSBC1.A3 191.1,177.64 arc(191.05,177.44) 190.94,177.27 arc(190.94,177.22) 190.93,177.18 arc(190.88,177.02) 190.78,176.88 190.69,176.79 arc(190.67,176.76) 190.64,176.74 arc(190.61,176.69) 190.59,176.64 arc(190.56,176.57) 190.55,176.48 arc(190.54,176.46) 190.54,176.44 190.54,176.37 arc(190.54,176.33) 190.54,176.28 arc(190.53,176.24) 190.53,176.2 arc(190.53,176.11) 190.58,176.04 DT3.1 arc(190.67,175.68) 190.63,175.49 190.63,175.49 190.61,175.31 arc(190.61,175.3) 190.61,175.3 arc(190.58,175.21) 190.55,175.12 arc(190.51,174.91) 190.5,174.7 190.5,174.7 190.5,173.01 arc(190.37,172.35) 190,171.8 arc(189.87,171.72) 189.72,171.68 189.42,171.68 arc(189.32,171.67) v2(189.24,171.61)
USB3_A_TTX_C_DRX_N1: length 25.9
  TOP w0.089: v2(194.69,178.82) arc(194.86,178.57) 194.92,178.28 194.92,177.7 arc(194.97,177.44) 195.12,177.23 195.64,176.7 arc(195.75,176.53) 195.79,176.33 195.79,174.53 arc(195.75,174.32) 195.63,174.15 DT7.1 arc(195.78,173.94) 195.84,173.7 195.84,173.05 arc(195.82,172.93) 195.75,172.83 arc(195.72,172.81) 195.69,172.81 195.53,172.81 arc(194.95,172.76) 194.38,172.63 arc(194.11,172.51) 193.88,172.33 193.38,171.83 arc(193.28,171.76) 193.15,171.74 191.84,171.74 arc(191.26,171.85) 190.76,172.18 190.53,172.41 arc(190.42,172.58) 190.38,172.77 190.38,172.88 arc(190.33,173.12) 190.19,173.33 190.06,173.47 arc(189.93,173.58) 189.79,173.66 arc(189.57,173.74) 189.33,173.77 arc(189.32,173.78) 189.3,173.78 189.3,173.77 189.06,173.77 arc(188.64,173.86) 188.29,174.1 186.51,175.87 arc(186.22,176.07) 185.87,176.14 183.85,176.14 arc(183.01,175.82) 182.58,175.03 182.57,174.99 arc(182.55,174.77) 182.54,174.55 182.54,174.02 arc(182.57,173.83) 182.66,173.66 arc(182.68,173.62) 182.72,173.59 arc(182.73,173.56) 182.75,173.52 arc(182.77,173.43) 182.78,173.34 182.78,173.26 arc(182.71,172.96) CT40.1
  BOTTOM w0.089: JUSBC1.B3 194.35,179.31 arc(194.36,179.24) 194.4,179.17 194.41,179.17 arc(194.46,179.13) 194.52,179.12 arc(194.58,179.11) 194.63,179.08 194.65,179.06 arc(194.68,179.01) 194.69,178.95 v2(194.69,178.82)
USB3_A_TTX_C_DRX_P0: length 17.8
  TOP w0.089: CT41.1 184.1,172.74 arc(184.2,172.89) 184.24,173.07 184.24,173.63 184.23,173.63 arc(184.22,173.73) 184.19,173.83 184.18,173.84 arc(184.16,173.88) 184.12,173.92 arc(184.05,173.97) 183.97,173.98 arc(183.88,173.99) 183.8,174.02 183.74,174.05 arc(183.68,174.08) 183.64,174.12 arc(183.61,174.14) 183.59,174.16 arc(183.55,174.2) 183.51,174.25 183.47,174.3 arc(183.44,174.37) 183.41,174.45 183.4,174.6 arc(183.4,174.6) 183.4,174.61 arc(183.4,174.67) 183.4,174.73 183.4,174.84 arc(183.4,174.92) 183.42,174.99 arc(183.6,175.25) 183.9,175.35 184.86,175.35 arc(185.31,175.17) 185.49,174.71 185.49,174.53 arc(185.51,174.36) 185.57,174.19 arc(185.63,174.1) 185.69,174.02 arc(185.75,173.96) 185.82,173.91 arc(186.24,173.71) 186.7,173.64 187.34,173.64 arc(187.57,173.59) 187.76,173.46 188.88,172.35 arc(188.88,172.34) 188.89,172.33 arc(189.05,172.23) v2(189.24,172.2)
  BOTTOM w0.089: v2(189.24,172.2) 189.47,171.97 189.5,171.94 arc(189.6,171.88) 189.72,171.86 189.72,171.86 arc(189.8,171.88) 189.87,171.93 arc(190.2,172.42) 190.32,173.01 190.32,174.92 arc(190.35,175.08) 190.4,175.22 arc(190.41,175.26) 190.42,175.3 arc(190.43,175.33) 190.44,175.35 190.46,175.5 190.46,175.52 arc(190.45,175.56) 190.44,175.61 arc(190.32,175.78) DT2.1 190.17,175.89 arc(190.3,176.07) 190.36,176.29 190.36,176.38 arc(190.37,176.47) 190.38,176.55 arc(190.4,176.63) 190.43,176.72 arc(190.46,176.78) 190.5,176.84 arc(190.53,176.88) 190.56,176.91 190.65,177 arc(190.72,177.1) 190.76,177.21 arc(190.76,177.24) 190.76,177.27 arc(190.76,177.3) 190.74,177.33 190.7,177.37 arc(190.62,177.48) 190.6,177.62 JUSBC1.A2
USB3_A_TTX_C_DRX_P1: length 26
  TOP w0.089: CT39.1 183.05,172.78 arc(182.96,172.91) 182.93,173.07 arc(182.95,173.16) 182.96,173.25 182.96,173.34 arc(182.95,173.47) 182.91,173.59 arc(182.89,173.64) 182.86,173.7 arc(182.85,173.71) 182.84,173.71 arc(182.82,173.74) 182.8,173.76 arc(182.74,173.88) 182.72,174.02 182.72,174.55 arc(182.73,174.76) 182.75,174.96 182.76,175 arc(183.13,175.69) 183.85,175.96 185.87,175.96 arc(186.15,175.9) 186.39,175.74 188.16,173.97 arc(188.58,173.69) 189.07,173.6 189.32,173.6 arc(189.52,173.57) 189.71,173.5 arc(189.83,173.43) 189.93,173.34 190.07,173.21 arc(190.17,173.06) 190.2,172.88 190.2,172.77 arc(190.26,172.51) 190.4,172.29 190.63,172.06 arc(191.19,171.69) 191.84,171.56 193.15,171.56 arc(193.34,171.6) 193.51,171.71 193.99,172.19 arc(193.99,172.19) 194,172.2 arc(194.2,172.36) 194.43,172.46 arc(194.98,172.59) 195.53,172.63 195.69,172.63 arc(195.79,172.65) 195.88,172.71 arc(195.98,172.87) 196.02,173.05 196.02,173.52 arc(196.09,173.85) DT6.1 196.09,174.3 arc(196,174.44) 195.97,174.59 195.97,176.33 arc(195.92,176.6) 195.76,176.83 195.24,177.35 arc(195.13,177.51) 195.1,177.7 195.1,178.36 arc(195.14,178.59) v2(195.28,178.8)
  BOTTOM w0.089: v2(195.28,178.8) 195.28,178.81 194.91,179.18 arc(194.86,179.25) 194.85,179.33 JUSBC1.B2
USB3_A_TTX_DRX_N0: length 2.9
  TOP w0.089: UT1.B19 184.3,169.48 arc(184.4,169.62) 184.43,169.79 184.43,170.04 arc(184.42,170.08) 184.4,170.12 arc(184.37,170.16) 184.35,170.22 184.35,170.29 arc(184.37,170.38) 184.38,170.47 184.38,170.93 arc(184.38,170.93) 184.38,170.94 arc(184.42,171.21) 184.44,171.48 184.44,171.49 arc(184.44,171.51) 184.44,171.54 arc(184.49,171.83) CT42.2
USB3_A_TTX_DRX_N1: length 3
  TOP w0.089: UT1.B17 183.26,169.38 183.18,169.46 arc(183.09,169.59) 183.06,169.75 183.06,170.9 arc(183.03,171.01) 182.97,171.11 182.87,171.21 arc(182.81,171.3) 182.79,171.41 182.79,171.74 arc(182.73,171.94) CT40.2
USB3_A_TTX_DRX_P0: length 2.9
  TOP w0.089: UT1.A19 184.2,169.8 arc(184.19,169.75) 184.16,169.7 184.03,169.7 184,169.73 arc(183.98,169.77) 183.96,169.82 183.96,170 arc(183.98,170.06) 184.01,170.11 184.09,170.19 184.12,170.23 arc(184.13,170.25) 184.14,170.26 arc(184.16,170.3) 184.17,170.34 arc(184.19,170.41) 184.19,170.47 184.19,170.66 184.19,170.66 184.19,170.91 arc(184.19,170.94) 184.19,170.98 arc(184.24,171.23) 184.25,171.48 184.25,171.76 arc(184.19,171.96) CT41.2
USB3_A_TTX_DRX_P1: length 3
  TOP w0.089: UT1.A17 183.28,169.75 arc(183.31,169.69) 183.37,169.66 183.42,169.66 183.46,169.7 arc(183.5,169.76) 183.51,169.82 183.51,169.97 arc(183.5,170.04) 183.46,170.09 183.33,170.23 arc(183.27,170.32) 183.25,170.42 183.25,170.9 arc(183.21,171.09) 183.1,171.25 183,171.35 arc(182.98,171.37) 182.98,171.41 182.98,171.74 arc(183.02,171.94) CT39.2
USB3_CC1: length 21.9
  TOP w0.102: JUSBC2.A5 v2(8.38,60.92)
  IN4 w0.097: 14.61,52.79 12.77,54.63 12.77,57.56 13.28,58.07 13.28,61.45 v2(13.04,61.69) ; 11.57,63.28 v2(11.95,63.28)
  IN4 w0.102: 11.57,63.28 10.42,62.14 8.14,62.14 7.96,61.96 7.96,61.34 v2(8.38,60.92) ; v2(15.52,51.02) 14.61,51.92 14.61,52.79
  BOTTOM w0.107: v2(13.04,61.69) DU20.2 12.53,62.82 12.07,63.28 v2(11.95,63.28) ; v2(15.52,51.02) 15.63,51.13 UU7.11
USB3_CC2: length 28.1
  TOP w0.107: JUSBC2.B5 6.39,59.68 6.61,59.46 v2(6.71,59.46)
  IN4 w0.097: 13.04,65.13 v2(13.04,65.82) ; v2(13.72,61.69) 13.72,57.82 13.03,57.12 13.03,55.19 15.07,53.14 v2(15.07,52.13) ; 7.5,61.88 7.5,60.25 v2(6.71,59.46)
  IN4 w0.102: 7.5,61.88 8.04,62.42 10.33,62.42 13.04,65.13
  BOTTOM w0.107: v2(13.04,65.82) DU20.3 13.52,64.75 14.04,64.23 14.04,62.01 v2(13.72,61.69) ; v2(15.07,52.13) UU7.13
USB3_CRX_L_DTX_N1: length 9.8
  TOP w0.099: JUSB1.5 15.05,34.28
  TOP w0.107: 15.05,34.28 15.14,34.38 15.4,34.38 16.41,35.39 17.41,35.39 v3(17.66,35.64) 18.17,36.15 18.17,36.66 18.2,36.69 18.2,37.26 18.17,37.29 18.17,37.43 18.36,37.62 18.8,37.62 18.94,37.49 DU2.9 DU2.1 20.73,37.49 20.86,37.62 21.17,37.62 21.32,37.48 LU5.2
USB3_CRX_L_DTX_N2: length 7.2
  TOP w0.107: JUSBC2.B10 6.31,62.17 6.46,62.33 6.68,62.33 6.9,62.55 6.9,63.06 7.36,63.52 8.58,63.52 8.97,63.9 9.25,63.9 9.38,63.78 DU12.7 DU12.4 11.05,63.78 11.18,63.91 11.45,63.91 11.52,63.84 LU8.2
USB3_CRX_L_DTX_N5: length 5.8
  TOP w0.107: LU11.3 11.71,59.78 11.53,59.6 11.34,59.6 11.17,59.76 DU13.9 DU13.1 9.51,59.76 9.04,59.29 9.04,58.73 v3(8.8,58.49) 8.59,58.27 8.25,58.27 8.1,58.42 JUSBC2.A10
USB3_CRX_L_DTX_P1: length 9.9
  TOP w0.099: JUSB1.6 15.05,34.68
  TOP w0.107: LU5.3 21.31,37.98 21.17,37.83 20.89,37.83 20.73,37.99 DU2.2 DU2.8 19.05,37.99 18.89,37.83 18.28,37.83 17.97,37.52 v3(17.97,36.98) 17.97,36.24 17.74,36.01 17.7,36.01 17.28,35.59 16.33,35.59 15.32,34.58 15.15,34.58 15.05,34.68
USB3_CRX_L_DTX_P2: length 7.3
  TOP w0.107: JUSBC2.B11 6.31,62.68 6.46,62.53 6.59,62.53 6.7,62.64 6.7,63.15 7.27,63.72 8.46,63.72 v3(8.64,63.9) 8.84,64.1 9.23,64.1 9.4,64.28 DU12.6 DU12.5 11.09,64.28 11.25,64.11 11.45,64.11 11.68,64.34 LU8.3
USB3_CRX_L_DTX_P5: length 5.7
  TOP w0.107: LU11.2 11.71,59.28 11.6,59.39 11.28,59.39 11.15,59.26 DU13.8 DU13.2 9.3,59.26 9.24,59.2 9.24,58.6 8.71,58.07 8.2,58.07 8.06,57.92 JUSBC2.A11
USB3_CTX_C_DRX_N1: length 1.5
  TOP w0.099: CU13.1 23.83,39.14 23.54,39.14 23.4,39 LU4.1
USB3_CTX_C_DRX_N2: length 1.5
  TOP w0.107: CU30.1 14.06,62.38 13.79,62.38 13.67,62.25 LU7.1
USB3_CTX_C_DRX_N5: length 1.5
  TOP w0.107: CU38.1 14.41,58.13 14.11,58.13 13.92,58.32 LU10.4
USB3_CTX_C_DRX_P1: length 1.5
  TOP w0.099: CU12.1 23.83,39.36 23.54,39.36 23.4,39.5 LU4.4
USB3_CTX_C_DRX_P2: length 1.4
  TOP w0.107: LU7.4 13.61,62.75 13.79,62.58 14.2,62.58 CU31.1
USB3_CTX_C_DRX_P5: length 1.5
  TOP w0.107: CU39.1 14.39,57.93 14.03,57.93 13.92,57.82 LU10.1
USB3_CTX_C_L_DRX_N1: length 8.7
  TOP w0.099: 18.96,39.13 18.96,39.13 ; JUSB1.8 15.05,41.03 15.18,41.16
  TOP w0.107: LU4.2 21.25,39 21.13,39.12 20.86,39.12 20.73,38.99 DU2.4 DU2.7 19.1,38.99 18.96,39.13 ; 18.96,39.13 18.95,39.14 v3(18.23,39.14) 17.95,39.14 17.55,39.53 17.55,39.84 17.17,40.21 16.24,40.21 15.3,41.16 15.18,41.16
USB3_CTX_C_L_DRX_N2: length 4.8
  TOP w0.107: LU7.2 11.64,62.25 11.47,62.42 11.08,62.42 10.93,62.28 DU12.1 DU12.9 8.84,62.28 8.62,62.06 8.19,62.06 8.05,61.92 JUSBC2.A3
USB3_CTX_C_L_DRX_N5: length 8.8
  TOP w0.107: JUSBC2.B3 6.33,58.68 6.8,58.2 6.8,57.38 7.12,57.07 7.85,57.07 8.17,56.75 8.38,56.75 8.41,56.78 8.93,56.78 9.17,57.01 9.17,57.88 9.54,58.26 DU13.4 DU13.7 11.17,58.26 11.28,58.15 11.52,58.15 11.69,58.32 LU10.3
USB3_CTX_C_L_DRX_P1: length 8.8
  TOP w0.099: 15.36,41.39 15.18,41.39 15.05,41.52 JUSB1.9
  TOP w0.107: LU4.3 21.25,39.5 21.09,39.34 20.87,39.34 20.73,39.49 DU2.5 DU2.6 19.08,39.49 18.94,39.34 18.53,39.34 18.51,39.37 18,39.37 17.75,39.62 17.75,39.96 v3(17.5,40.22) 17.29,40.42 16.33,40.42 15.36,41.39
USB3_CTX_C_L_DRX_P2: length 4.9
  TOP w0.107: JUSBC2.A2 8.04,62.42 8.2,62.26 8.49,62.26 v3(8.77,62.54) 9.01,62.78 DU12.8 DU12.2 10.97,62.78 11.1,62.64 11.41,62.64 11.52,62.75 LU7.3
USB3_CTX_C_L_DRX_P5: length 8.5
  TOP w0.107: JUSBC2.B2 6.54,58.17 6.6,58.11 6.6,57.3 7.03,56.86 7.77,56.86 8.09,56.55 v3(8.75,56.55) 8.99,56.55 9.37,56.93 9.37,57.63 9.5,57.76 DU13.5 DU13.6 11.15,57.76 11.34,57.94 11.59,57.94 11.71,57.82 LU10.2
USB3_RUF1: length 11.9
  TOP w0.107: v2(8.36,59.47) 8.23,59.47 8.19,59.42 JUSBC2.A8
  BOTTOM w0.107: DU21.2 11.74,66.82 11.18,66.26 11.18,65.18 9.85,63.85 8.39,63.85 7.57,63.02 v1(7.57,62.77) 7.57,59.7 7.8,59.47 v2(8.36,59.47)
USB3_RUF2: length 11.8
  TOP w0.107: JUSBC2.B8 6.68,61.17 v2(6.71,61.21)
  BOTTOM w0.107: DU21.3 11.52,68.75 10.87,68.1 10.87,65.31 9.74,64.18 v1(9.29,64.18) 8.34,64.18 7.21,63.05 7.21,61.71 v2(6.71,61.21)
USB3RN1: length 198.5
  TOP w0.099: v2(24.2,37.42) 24.03,37.59 23.41,37.59 23.29,37.48 LU5.1
  IN6 w0.089: v2(189.7,39.14) 189.35,39.49 188.48,39.49 188.32,39.34 187.68,39.34 178.66,30.32 171.08,30.32 170.32,29.56 108.99,29.56 104.63,33.92 104.63,40.19 97.8,47.02 96.53,47.02 95.1,48.45 87.57,48.45 87.09,48.93 81.73,48.93 81.57,48.76 67.19,48.76 66.89,49.06 46.38,49.06 45.53,49.9 34.37,49.9 29.29,44.83 28.28,44.83 24.27,40.82 24.27,39.13 24.94,38.45 24.94,37.83 24.75,37.65 24.43,37.65 v2(24.2,37.42)
  BOTTOM w0.107: UH1.B7 195.18,36.54 194.88,36.25 194.56,36.25 194.01,36.8 194.01,36.87 193.34,37.53 193.34,38.1 192.3,39.14 v2(189.7,39.14)
USB3RN2: length 227.3
  TOP w0.107: v2(15.25,64.85) 15.05,65.06 14.61,65.06 14.5,64.95 14.5,64.26 14.23,63.99 13.99,63.99 13.85,63.84 LU8.1
  IN3 w0.127: v2(193.77,36.48) 193.61,36.32 193.28,36.32 193.02,36.06 193.02,33.84 189.02,29.84 189.02,28.9 186.45,26.33 186.45,25.5 183.33,22.38 173.44,22.38 172.86,21.81 124.6,21.81 123.72,20.93 108.8,20.93 104.9,17.03 91.79,17.03 83,25.81 83,31.84 69.82,45.02 67.75,45.02 64.89,47.88 58.56,47.88 57.78,48.66 56.14,48.66 55.66,48.18 46.39,48.18 45.67,47.46 41.96,47.46 40.73,48.7 34.38,48.7 33.75,49.33 26.78,49.33 24.39,51.72 21.92,51.72 21.61,52.03 19.38,52.03 19.3,51.95 16.15,51.95 14.74,53.36 14.74,58.33 15.53,59.11 15.53,60.27 14.8,60.99 14.8,62.71 14.49,63.02 14.49,64.74 14.74,64.99 15.11,64.99 v2(15.25,64.85)
  BOTTOM w0.107: v2(193.77,36.48) 193.99,36.26 194.27,36.26 194.48,36.05 194.96,36.05 195.08,36.17 195.43,36.17 UH1.C8
USB3RN3: length 175.8
  IN1 w0.089: v2(192.78,36.98) 192.39,37.37 192.39,37.73 193.01,38.35 193.01,40.33 189.52,43.82 189.52,62.05 186.32,65.25 186.32,67.94 185.74,68.51 185.74,85.35 187.96,87.57 187.96,92.85 184.88,95.93 184.88,111.28 187.44,113.83 187.44,120.66 189.52,122.74 189.52,131.16 192.03,133.67 192.79,133.67 194.07,134.96 194.07,146 190.72,149.35 190.72,151.69 188.6,153.82 181.83,153.82 181.21,154.44 177.08,154.44 176.71,154.81 173.32,154.81 173.16,154.97 172.28,154.97 171.84,154.53 169.42,154.53 164.05,159.89 164.05,163.03 163.27,163.82 163.27,167.02 165.87,169.62 165.87,172.63 v2(165.85,172.64)
  BOTTOM w0.107: v2(165.85,172.64) 166.04,172.83 166.04,173.41 CI38.1 ; v2(192.78,36.98) 192.78,36.11 193.53,35.36 194.48,35.36 194.63,35.21 194.89,35.21 195,35.32 UH1.B10
USB3RN3_C: length 3.5
  BOTTOM w0.099: CI38.2 166,175 ; 166.62,176.66 JCDRA.36
  BOTTOM w0.102: 166,175 166.05,175.06 166.05,175.5 166.72,176.17 166.72,176.56 166.62,176.66
USB3RN4: length 151.8
  TOP w0.107: JIO.26 325.16,22.36 324.86,22.65 323.84,22.65 323.63,22.44 323.63,21.97 323.73,21.86 v2(323.97,21.86)
  IN6 w0.089: v2(196.91,34.22) 197.17,34.49 197.17,34.69 197.87,35.38 201.17,35.38 201.58,35.79 201.58,37.12 202.46,38.01 202.46,41.13 203,41.67 205.22,41.67 205.65,42.1 207.27,42.1 207.94,42.77 212.22,42.77 213.79,41.2 214.29,41.2 214.57,41.48 216.8,41.48 217.03,41.25 218.91,41.25 218.96,41.29 223.15,41.29 226.44,38 227.35,38 228.31,37.04 232.13,37.04 232.33,37.24 239.39,37.24 241.17,35.46 241.17,32.03 243.46,29.73 247.2,29.73 247.61,30.15 253.91,30.15 254.33,29.73 273.01,29.73 273.79,30.51 281.44,30.51 282.15,29.79 286.33,29.79 286.54,30 289.65,30 291.37,31.72 298.84,31.72 299.31,31.25 304.56,31.25 305.83,29.98 316.27,29.98 317.48,28.76 317.48,27.1 321.92,22.66 323.18,22.66 323.62,22.22 323.62,21.95 323.71,21.86 v2(323.97,21.86)
  BOTTOM w0.089: v2(196.91,34.22) 196.91,34.56 UH1.E11
USB3RN5: length 224.2
  TOP w0.099: 14.61,59.85 v2(14.8,60.04)
  TOP w0.107: 14.61,59.85 14.07,59.85 14,59.78 LU11.4
  IN3 w0.127: v2(14.8,60.04) 14.64,59.88 13.95,59.88 13.38,59.3 13.38,52.26 16.24,49.4 18.95,49.4 20.84,47.5 26.67,47.5 27.57,48.4 33.45,48.4 34.35,47.5 40.18,47.5 41.15,46.52 48.56,46.52 49.35,47.31 56.02,47.31 56.5,47.79 57.42,47.79 58.2,47.01 63.96,47.01 67.03,43.94 69.65,43.94 82.12,31.48 82.12,25.31 91.27,16.16 105.36,16.16 109.09,19.89 124.27,19.89 124.76,20.39 179.94,20.39 180.76,21.21 183.54,21.21 187.1,24.77 189.59,24.77 192.67,27.85 192.67,30.26 196,33.59 196.91,33.59 197.02,33.48 197.02,33.3 196.87,33.14 v2(196.85,33.14)
  BOTTOM w0.097: UH1.G13 197.34,33.64 v2(196.85,33.14)
USB3RP1: length 198.5
  TOP w0.099: LU5.4 23.28,37.98 23.42,37.84 24.04,37.84 v2(24.2,38.01)
  IN6 w0.089: v2(189.7,40.04) 189.32,39.66 188.41,39.66 188.26,39.5 187.62,39.5 178.59,30.48 171.01,30.48 170.26,29.72 109.06,29.72 104.8,33.99 104.8,40.26 97.86,47.19 96.6,47.19 95.17,48.61 87.64,48.61 87.16,49.09 81.66,49.09 81.5,48.93 67.25,48.93 66.96,49.22 46.45,49.22 45.6,50.07 34.3,50.07 29.22,45 28.21,45 24.1,40.89 24.1,39.06 24.77,38.39 24.77,37.9 24.68,37.81 24.39,37.81 v2(24.2,38.01)
  BOTTOM w0.107: UH1.A7 194.6,36.49 194.54,36.55 194.21,36.88 194.21,36.95 193.54,37.62 193.54,38.18 192.38,39.34 190.08,39.34 189.87,39.55 189.73,39.55 189.62,39.66 189.62,39.95 v2(189.7,40.04)
USB3RP2: length 228.1
  TOP w0.107: LU8.4 13.85,64.34 13.99,64.19 14.15,64.19 14.3,64.34 14.3,65.03 14.52,65.26 15.07,65.26 v2(15.25,65.44)
  IN3 w0.127: v2(193.77,35.93) 193.61,36.1 193.37,36.1 193.24,35.97 193.24,33.75 189.24,29.75 189.24,28.81 186.67,26.24 186.67,25.41 183.42,22.17 173.53,22.17 172.95,21.59 124.69,21.59 123.81,20.71 108.89,20.71 104.99,16.81 91.7,16.81 82.78,25.72 82.78,31.75 69.73,44.81 67.66,44.81 64.8,47.66 58.47,47.66 57.69,48.44 56.23,48.44 55.75,47.96 46.48,47.96 45.76,47.24 41.87,47.24 40.64,48.48 34.29,48.48 33.66,49.11 26.69,49.11 24.3,51.5 21.83,51.5 21.52,51.81 19.47,51.81 19.39,51.73 16.06,51.73 14.52,53.27 14.52,58.42 15.31,59.21 15.31,60.17 14.59,60.9 14.59,62.62 14.27,62.93 14.27,64.83 14.65,65.21 15.02,65.21 v2(15.25,65.44)
  BOTTOM w0.107: UH1.B8 195.32,35.86 195.4,35.78 195.4,35.66 195.33,35.59 195.02,35.59 194.76,35.85 194.39,35.85 194.19,36.06 193.89,36.06 v2(193.77,35.93)
USB3RP3: length 175.7
  IN1 w0.089: v2(192.79,37.57) 192.98,37.38 193.11,37.38 193.19,37.47 193.19,37.73 193.01,37.92 193.01,38.11 193.18,38.28 193.18,40.4 189.68,43.89 189.68,62.12 186.48,65.32 186.48,68 185.91,68.58 185.91,85.28 188.13,87.51 188.13,92.92 185.05,96 185.05,111.21 187.6,113.77 187.6,120.59 189.68,122.67 189.68,131.1 192.1,133.51 192.86,133.51 194.24,134.89 194.24,146.07 190.89,149.42 190.89,151.76 188.67,153.98 181.9,153.98 181.28,154.6 177.14,154.6 176.78,154.97 173.39,154.97 173.23,155.13 172.21,155.13 171.77,154.69 169.49,154.69 164.22,159.96 164.22,163.1 163.43,163.89 163.43,166.95 166.04,169.55 166.04,172.26 166.42,172.64 v2(166.44,172.64)
  BOTTOM w0.107: v2(192.79,37.57) 193.03,37.57 193.19,37.41 193.19,36.81 192.99,36.61 192.99,36.2 193.62,35.56 194.65,35.56 UH1.A9 ; v2(166.44,172.64) 166.24,172.84 166.24,173.44 CI39.1
USB3RP3_C: length 3.5
  BOTTOM w0.099: JCDRA.37 167.02,176.66
  BOTTOM w0.102: 167.02,176.66 166.95,176.59 166.95,176.08 v3(166.57,175.7) 166.28,175.41 166.28,174.97 CI39.2
USB3RP4: length 151.8
  TOP w0.107: v2(323.05,21.94) 323.06,21.94 323.42,22.31 323.42,22.52 323.75,22.85 JIO.27
  IN6 w0.089: v2(197.51,34.17) 197.34,34.34 197.34,34.62 197.94,35.22 201.24,35.22 201.74,35.72 201.74,37.06 202.63,37.94 202.63,41.07 203.07,41.51 205.29,41.51 205.72,41.93 207.34,41.93 208.01,42.61 212.15,42.61 213.72,41.04 214.36,41.04 214.64,41.31 216.73,41.31 216.96,41.08 218.98,41.08 219.02,41.13 223.08,41.13 226.37,37.84 227.28,37.84 228.24,36.87 232.2,36.87 232.4,37.07 239.32,37.07 241,35.39 241,31.96 243.39,29.57 247.26,29.57 247.68,29.98 253.84,29.98 254.26,29.57 273.08,29.57 273.85,30.34 281.37,30.34 282.08,29.63 286.4,29.63 286.61,29.83 289.71,29.83 291.44,31.56 298.77,31.56 299.24,31.08 304.49,31.08 305.76,29.81 316.2,29.81 317.32,28.69 317.32,27.03 321.85,22.5 323.11,22.5 323.45,22.15 323.45,21.71 323.36,21.62 323.14,21.62 323.05,21.71 v2(323.05,21.94)
  BOTTOM w0.107: UH1.G11 197.47,34.64 197.37,34.53 197.37,34.31 v2(197.51,34.17)
USB3RP5: length 224.2
  TOP w0.107: LU11.1 13.79,59.28 14.16,59.65 14.61,59.65 v2(14.8,59.46)
  IN3 w0.127: v2(14.8,59.46) 14.6,59.66 14.04,59.66 13.6,59.21 13.6,52.35 16.33,49.62 19.04,49.62 20.93,47.72 26.58,47.72 27.48,48.62 33.54,48.62 34.44,47.72 40.27,47.72 41.25,46.74 48.47,46.74 49.26,47.53 55.93,47.53 56.41,48.01 57.51,48.01 58.29,47.23 64.05,47.23 67.12,44.16 69.74,44.16 82.34,31.57 82.34,25.4 91.36,16.38 105.26,16.38 109,20.11 124.18,20.11 124.67,20.61 179.85,20.61 180.67,21.43 183.45,21.43 187.01,24.99 189.5,24.99 192.45,27.94 192.45,30.35 195.91,33.81 197,33.81 197.24,33.57 197.24,33.3 v2(197.39,33.14)
  BOTTOM w0.089: UH1.H13 197.9,33.59 197.46,33.14 v2(197.39,33.14)
USB3TN1: length 195.6
  TOP w0.107: v2(25.85,38.95) 25.66,39.14 25.41,39.14 CU13.2
  IN6 w0.089: v2(25.85,38.95) 25.07,38.95 24.86,39.17 24.86,40.62 28.59,44.35 31.12,44.35 35.11,48.34 44.43,48.34 44.76,48.67 57.43,48.67 58.04,48.05 65.91,48.05 66.24,47.72 95.12,47.72 96.35,46.49 97.77,46.49 104.15,40.11 104.15,33.81 109.06,28.9 171.33,28.9 172.15,29.72 179.37,29.72 188.19,38.56 v2(189.85,38.56)
  BOTTOM w0.107: UH1.C11 195.48,35.01 195.38,35.01 195.38,35.01 195.34,35.01 195.3,35.05 195.05,35.05 195.01,35.01 194.52,35.01 194.37,35.16 193.1,35.16 192.22,36.04 192.22,36.86 190.83,38.26 190.15,38.26 v2(189.85,38.56)
USB3TN2: length 218.5
  TOP w0.107: CU30.2 15.42,62.06 15.66,62.29 15.81,62.29 v2(16.04,62.07)
  IN3 w0.127: v2(16.04,62.07) 15.84,62.26 15.63,62.26 15.5,62.14 15.5,61.3 16.23,60.57 16.23,58.8 15.5,58.07 15.5,55.72 16.01,55.21 16.01,53.7 16.69,53.03 19.16,53.03 19.19,53 24.06,53 26.54,50.51 33.49,50.51 34.64,49.36 41.55,49.36 42.63,48.29 44.76,48.29 45.31,48.83 55.38,48.83 55.86,49.31 64.8,49.31 68.43,45.67 70.25,45.67 83.67,32.26 83.67,26.07 92.06,17.68 104.26,17.68 108.3,21.71 122.92,21.71 124.51,23.3 183.04,23.3 185.18,25.45 185.18,27.02 191.37,33.21 191.37,34.35 191.62,34.6 192.33,34.6 v2(192.54,34.82)
  BOTTOM w0.107: UH1.B12 195.08,34.19 195.03,34.25 195.03,34.3 194.88,34.44 194.7,34.44 194.61,34.53 192.84,34.53 v2(192.54,34.82)
USB3TN3: length 205.4
  IN3 w0.127: v2(189.85,36.48) 189.61,36.72 188.56,36.72 184.9,40.38 184.9,53.09 183.18,54.81 183.18,58.26 182.57,58.86 182.57,63.44 182.07,63.94 182.07,68.31 184.49,70.73 184.49,87.09 185.49,88.1 185.49,93.39 185.15,93.74 185.15,98.54 185.34,98.73 185.34,104.23 190.3,109.19 191.82,109.19 192.2,109.57 192.2,111.03 193.61,112.44 195.77,112.44 196.43,113.1 197.47,113.1 198.19,113.82 198.19,114.28 200.25,116.34 200.25,118.79 202.23,120.77 202.23,121.44 205.91,125.12 205.91,126.14 206.17,126.4 206.17,129.06 205.72,129.51 205.72,132.26 206.41,132.95 206.41,136.75 206,137.16 206,141.75 204.4,143.35 204.4,148.52 205.62,149.74 205.62,153.06 205.88,153.31 205.88,153.69 205.59,153.97 205.59,156.21 208.29,158.9 208.29,162.73 207.65,163.37 207.65,164.76 205.24,167.17 205.24,168.45 204.63,169.06 202.99,169.06 201.17,170.89 193.49,170.89 193.05,171.33 191.28,171.33 189.4,173.21 188.93,173.21 188.67,172.94 185.18,172.94 183.24,174.88 179.76,174.88 179.26,174.38 172.31,174.38 172.12,174.18 169.72,174.18 168.89,175.01 v2(168.89,175.73)
  BOTTOM w0.089: 193.16,33.55 193.49,33.88 194.41,33.88 194.52,33.77 195.27,33.77 195.4,33.64 195.64,33.64 UH1.C13
  BOTTOM w0.099: JCDRA.42 169.02,176.78
  BOTTOM w0.107: v2(168.89,175.73) 169.11,175.95 169.11,176.69 169.02,176.78 ; 193.16,33.55 192.08,33.55 191.39,34.24 191.39,36.54 191.03,36.9 189.76,36.9 189.65,36.79 189.65,36.64 189.81,36.48 v2(189.85,36.48)
USB3TN4: length 153.8
  TOP w0.107: JIO.29 325.05,23.85 324.94,23.96 324.94,24.1 324.89,24.15 324.05,24.15 323.68,23.78 323.68,23.58 323.9,23.36 v2(324.04,23.36)
  IN6 w0.089: v2(324.04,23.36) 323.94,23.46 323.94,23.96 322.84,25.07 321.85,25.07 319.53,27.39 319.53,28.37 317.22,30.68 312.68,30.68 310.61,32.75 291.61,32.75 289.92,31.06 271.97,31.06 271.52,30.61 266.71,30.61 266.58,30.75 246.73,30.75 245.69,31.78 244.42,31.78 241.73,34.47 241.73,36.11 240.04,37.8 231.85,37.8 231.69,37.64 228.82,37.64 226.84,39.62 226.26,39.62 223.4,42.48 219.53,42.48 219.09,42.04 218.46,42.04 218.02,42.48 214.89,42.48 214.04,43.33 207.58,43.33 207,42.75 205.3,42.75 204.74,42.2 200.73,42.2 198.08,39.55 198.08,38.27 197.13,37.31 197.13,35.98 196.34,35.19 194.51,35.19 193.37,34.05 v2(193.37,33.16)
  BOTTOM w0.107: v2(193.37,33.16) 193.62,33.16 193.85,32.93 194.53,32.93 UH1.A14
USB3TN5: length 214.1
  TOP w0.107: CU38.2 15.99,58.13 16.3,58.13 17.22,57.22 17.22,56.88 v2(17.48,56.61)
  IN3 w0.127: v2(189.85,35.85) 189.66,35.66 189.01,35.66 185.34,31.99 185.34,29.66 183.53,27.85 183.53,25.88 183.14,25.5 179.71,25.5 179.09,24.87 120.88,24.87 118.74,22.73 106.6,22.73 103.01,19.15 100.41,19.15 99.87,18.6 92.56,18.6 84.52,26.64 84.52,32.34 70.43,46.43 68.69,46.43 65.12,50 55.61,50 55.13,49.51 46.63,49.51 46.02,50.13 34.79,50.13 33.75,51.17 26.86,51.17 24.38,53.65 19.99,53.65 19.56,54.08 17.71,54.08 17.19,54.59 17.19,56.25 v2(17.48,56.61)
  BOTTOM w0.089: UH1.B14 195.45,33.16 195.45,33.22 195.37,33.3 195.09,33.3 195.02,33.22 195.02,33.01
  BOTTOM w0.107: v2(189.85,35.85) 190.09,35.6 190.68,35.6 190.89,35.39 190.89,34.13 192.03,32.99 192.83,32.99 193.08,32.73 194.71,32.73 194.96,32.98 194.99,32.98 195.02,33.01
USB3TP1: length 195.5
  TOP w0.107: CU12.2 25.08,39.61 25.35,39.34 25.66,39.34 v2(25.85,39.53)
  IN6 w0.089: v2(25.85,39.53) 25.85,39.46 25.74,39.35 25.68,39.35 25.45,39.11 25.14,39.11 25.02,39.23 25.02,40.55 28.66,44.19 31.19,44.19 35.17,48.17 44.5,48.17 44.83,48.5 57.36,48.5 57.98,47.89 65.84,47.89 66.17,47.56 95.05,47.56 96.29,46.32 97.7,46.32 103.99,40.04 103.99,33.74 109,28.73 171.4,28.73 172.22,29.56 179.43,29.56 188.26,38.39 189.45,38.39 189.68,38.16 189.72,38.16 189.85,38.03 v2(189.85,37.97)
  BOTTOM w0.107: UH1.B11 195.29,34.81 195.4,34.7 195.4,34.64 195.33,34.57 195.03,34.57 194.79,34.81 194.43,34.81 194.28,34.96 193.01,34.96 192.02,35.95 192.02,36.78 190.74,38.06 189.93,38.06 v2(189.85,37.97)
USB3TP2: length 218.4
  TOP w0.107: CU31.2 15.42,62.83 15.75,62.51 15.9,62.51 v2(16.04,62.65)
  IN3 w0.127: v2(192.54,34.24) 192.39,34.39 191.72,34.39 191.59,34.26 191.59,33.12 185.4,26.93 185.4,25.35 183.13,23.08 124.6,23.08 123.01,21.5 108.39,21.5 104.36,17.46 91.97,17.46 83.45,25.98 83.45,32.16 70.16,45.46 68.34,45.46 64.71,49.09 55.95,49.09 55.47,48.61 45.4,48.61 44.85,48.07 42.54,48.07 41.46,49.15 34.55,49.15 33.39,50.3 26.45,50.3 23.97,52.78 19.1,52.78 19.07,52.81 16.6,52.81 15.79,53.61 15.79,55.12 15.28,55.63 15.28,58.16 16.01,58.89 16.01,60.48 15.28,61.21 15.28,62.23 15.54,62.48 15.87,62.48 v2(16.04,62.65)
  BOTTOM w0.107: UH1.A12 194.66,34.19 194.53,34.32 192.63,34.32 v2(192.54,34.24)
USB3TP3: length 205.3
  IN3 w0.127: v2(189.85,37.3) 189.85,37.09 189.7,36.94 188.65,36.94 185.12,40.47 185.12,53.18 183.4,54.9 183.4,58.35 182.79,58.96 182.79,63.54 182.29,64.04 182.29,68.22 184.71,70.64 184.71,87 185.71,88.01 185.71,93.49 185.37,93.83 185.37,98.45 185.56,98.64 185.56,104.14 190.4,108.98 191.91,108.98 192.41,109.48 192.41,110.94 193.7,112.22 195.86,112.22 196.52,112.88 197.56,112.88 198.41,113.73 198.41,114.19 200.47,116.25 200.47,118.7 202.45,120.68 202.45,121.35 206.13,125.03 206.13,126.05 206.39,126.31 206.39,129.15 205.94,129.6 205.94,132.17 206.63,132.86 206.63,136.84 206.22,137.25 206.22,141.84 204.62,143.44 204.62,148.43 205.84,149.65 205.84,152.97 206.09,153.22 206.09,153.78 205.81,154.06 205.81,156.12 208.51,158.81 208.51,162.82 207.87,163.46 207.87,164.85 205.46,167.26 205.46,168.54 204.72,169.28 203.08,169.28 201.26,171.1 193.58,171.1 193.14,171.55 191.37,171.55 189.49,173.43 188.84,173.43 188.58,173.16 185.27,173.16 183.33,175.1 179.67,175.1 179.17,174.6 172.22,174.6 172.03,174.4 169.81,174.4 169.11,175.1 169.11,175.35 169.47,175.72 v2(169.47,175.73)
  BOTTOM w0.089: 193.05,33.75 193.1,33.75 193.42,34.06 194.49,34.06 194.6,33.95 195.67,33.95 195.97,33.66 UH1.D13
  BOTTOM w0.099: JCDRA.43 169.42,176.81
  BOTTOM w0.107: 193.05,33.75 192.16,33.75 191.59,34.32 191.59,36.63 191.12,37.1 190.06,37.1 v2(189.85,37.3) ; 169.42,176.81 169.31,176.7 169.31,175.89 v2(169.47,175.73)
USB3TP4: length 153.7
  TOP w0.107: JIO.30 323.97,24.36 323.48,23.87 323.48,23.59 v2(323.29,23.4)
  IN6 w0.089: v2(194,33.3) 193.94,33.24 193.79,33.24 193.53,33.51 193.53,33.98 194.58,35.03 196.41,35.03 197.3,35.91 197.3,37.25 198.25,38.2 198.25,39.48 200.79,42.03 204.81,42.03 205.36,42.58 207.07,42.58 207.65,43.17 213.97,43.17 214.82,42.31 217.94,42.31 218.39,41.87 218.39,41.87 218.4,41.87 219.16,41.87 219.59,42.31 223.34,42.31 226.2,39.45 226.78,39.45 228.76,37.47 231.76,37.47 231.92,37.63 239.97,37.63 241.56,36.04 241.56,34.41 244.35,31.62 245.62,31.62 246.66,30.58 266.51,30.58 266.65,30.45 271.59,30.45 272.04,30.9 289.99,30.9 291.68,32.59 310.54,32.59 312.61,30.52 317.16,30.52 319.37,28.31 319.37,27.32 321.78,24.9 322.77,24.9 323.78,23.9 323.78,23.67 323.51,23.4 v2(323.29,23.4)
  BOTTOM w0.107: UH1.B13 195.09,33.49 194.46,33.49 194.31,33.63 194.04,33.63 193.94,33.53 193.94,33.36 v2(194,33.3)
USB3TP5: length 214
  TOP w0.099: CU39.2 15.98,57.91
  TOP w0.107: v2(16.84,56.54) 17.01,56.71 17.01,57.13 16.21,57.93 16.01,57.93 15.98,57.91
  IN3 w0.127: v2(16.84,56.54) 16.97,56.41 16.97,54.5 17.62,53.86 19.46,53.86 19.9,53.43 24.29,53.43 26.77,50.95 33.66,50.95 34.7,49.91 45.93,49.91 46.54,49.3 55.22,49.3 55.7,49.78 65.03,49.78 68.6,46.21 70.34,46.21 84.3,32.25 84.3,26.55 92.47,18.38 99.96,18.38 100.5,18.93 103.1,18.93 106.69,22.51 118.83,22.51 120.97,24.65 179.18,24.65 179.8,25.28 183.23,25.28 183.75,25.79 183.75,27.76 185.56,29.57 185.56,31.9 189.1,35.44 189.67,35.44 v2(189.85,35.26)
  BOTTOM w0.089: UH1.C14 195.69,33.05 195.42,32.78
  BOTTOM w0.107: v2(189.85,35.26) 189.99,35.4 190.59,35.4 190.69,35.31 190.69,34.05 191.95,32.79 192.74,32.79 193,32.53 194.8,32.53 195.05,32.78 195.3,32.78 195.3,32.78 195.42,32.78
USB20_CAM_N7_R: length 25.1
  TOP w0.107: JEDP.19 160.62,179.58 160.77,179.43 160.77,178.48 161.38,177.86 161.38,176.58 160.66,175.86 160.66,172.72 161.29,172.1 161.29,170.29 162.57,169.01 166.63,169.01 166.85,168.79 166.85,167.48 DV4.3 166.74,166.62 166.85,166.51 166.85,165.96 167.83,164.98 167.83,164.18 167.17,163.52 167.17,163.19 167.02,163.04 LV2.2
USB20_CAM_P7_R: length 25.1
  TOP w0.107: LV2.3 167.52,163.04 167.37,163.19 167.37,163.44 168.03,164.1 168.03,165.07 167.05,166.05 167.05,166.51 167.16,166.62 DV4.2 167.05,167.48 167.05,168.87 166.72,169.21 162.65,169.21 161.49,170.37 161.49,172.18 160.87,172.8 160.87,175.78 161.59,176.5 161.59,177.95 160.97,178.56 160.97,179.43 161.12,179.58 JEDP.20
USB20_N1: length 212.2
  TOP w0.107: v2(25.74,40.11) 25.9,40.27 25.9,40.58 25.74,40.74 25.16,40.74 25.13,40.77 22.6,40.77 22.22,41.15 22.22,42.43 22.08,42.57 UU1.2
  IN6 w0.089: v2(25.74,40.11) 25.87,40.24 25.87,40.74 28.84,43.7 31.42,43.7 35.38,47.66 48.77,47.66 49.14,48.03 57.14,48.03 57.77,47.41 65.66,47.41 65.97,47.09 94.83,47.09 96.07,45.85 97.51,45.85 103.52,39.84 103.52,33.43 109.13,27.82 172.16,27.82 173.43,29.09 180.91,29.09 182.25,30.42 186.04,30.42 187.13,31.51 191.66,31.51 193.99,29.18 198.91,29.18 199.72,29.99 199.72,30.88 200.41,31.57 201.99,31.57 203.46,33.04 203.46,33.68 204.04,34.26 205.08,34.26 205.18,34.36 205.18,34.83 207.23,36.88 207.23,37.16 207.44,37.38 207.75,37.38 v2(207.89,37.52)
  BOTTOM w0.089: UH1.AF5 207.32,37.52 v2(207.89,37.52)
USB20_N1_CONN: length 14.1
  BOTTOM w0.107: LU3.2 23.25,39.08 23.44,38.89 23.44,37.43 23.09,37.09 22.58,37.09 22.45,37.21 DU1.2 22.17,37.67 22.17,37.31 21.97,37.11 21.94,37.11 21.77,37.11 21.35,37.52 21.35,38.85 20.71,39.5 v3(20.1,39.5) 19.57,39.5 18.95,38.88 18.91,38.88 18.5,38.47 18.5,38.44 17.95,37.88 16.67,37.88 16.55,38 JUSB1.2
USB20_N2: length 152
  TOP w0.107: v2(323.63,17.99) 323.62,17.99 323.25,18.35 323.25,19.03 323.83,19.62 323.83,20.64 324.3,21.11 324.81,21.11 324.87,21.05 324.87,20.96 324.98,20.85 JIO.23
  IN6 w0.089: v2(205.7,36.63) 206.49,36.63 206.64,36.78 206.64,37.18 207.57,38.11 208.31,38.11 208.56,37.86 209.86,37.86 209.99,37.99 210.11,37.99 211.06,38.94 215.79,38.94 216.46,38.27 216.46,37.76 217.31,36.91 217.97,36.91 220.7,34.18 222.68,34.18 223.71,35.21 226.19,35.21 228.55,32.85 228.55,26.86 230.43,24.97 230.43,22.95 232.53,20.86 236.22,20.86 237.11,19.97 239.88,19.97 242.65,22.74 243.34,22.74 248.42,27.83 273.95,27.83 275.3,26.48 289.81,26.48 291.75,28.42 300.81,28.42 301.36,27.87 313.92,27.87 315.72,26.07 315.72,20.76 318.17,18.31 322.45,18.31 322.87,18.72 323.36,18.72 323.54,18.54 323.54,18.08 v2(323.63,17.99)
  BOTTOM w0.089: v2(205.7,36.63) 205.7,36.66 206.24,37.2 UH1.AD5
USB20_N3: length 185.1
  IN1 w0.089: v2(168.49,172.16) 168.47,172.16 168.19,171.88 168.19,170.71 166.57,169.09 166.57,167.63 165.47,166.53 164.41,166.53 164.07,166.19 164.07,164.15 164.85,163.37 164.85,160.23 168.18,156.9 171.5,156.9 172.63,155.77 174.45,155.77 174.61,155.61 176.56,155.61 176.74,155.78 181,155.78 182.17,154.62 188.93,154.62 191.56,151.98 191.56,149.65 194.87,146.33 194.87,137.53 195.2,137.2 195.2,136.7 194.87,136.37 194.87,134.57 190.36,130.05 190.36,122.45 188.62,120.71 188.62,113.61 185.75,110.73 185.75,96.2 188.76,93.18 188.76,87.24 186.54,85.02 186.54,68.84 187.56,67.82 187.56,66.18 189.73,64.01 193,64.01 194.44,62.57 194.44,61.43 193.8,60.8 193.8,57.94 193.63,57.77 193.63,51.34 195.69,49.28 196.39,49.28 198.3,47.36 198.3,45.68 204.63,39.35 206.56,39.35 207.44,38.47 207.44,35.08 207.53,34.99 207.76,34.99 207.85,35.08 v2(207.85,35.19)
  BOTTOM w0.089: v2(207.85,35.19) 207.34,35.7 UH1.AG8
  BOTTOM w0.107: LM1.1 168.47,173 168.32,172.85 168.32,172.32 v2(168.49,172.16)
USB20_N3_CONN: length 3.4
  BOTTOM w0.099: LM1.2 168.47,174.91 ; JCDRA.40 168.22,176.66
  BOTTOM w0.107: 168.22,176.66 168.09,176.53 168.09,176.27 168.35,176.02 v3(168.35,175.55) 168.35,175.04 168.47,174.91
USB20_N4: length 149.9
  TOP w0.107: v2(322.35,18.86) 322.16,18.67 322.16,18.14 321.15,17.13 320.5,17.13 319.82,16.46 319.82,14.98 316.7,11.86 316.7,10.36 317,10.07 UE1.5
  IN6 w0.089: v2(322.35,18.86) 322.14,19.06 322.14,19.24 321.9,19.49 320.09,19.49 319.66,19.92 317.9,19.92 316.44,21.38 316.44,26.56 314.35,28.65 305.22,28.65 303.3,30.56 299.04,30.56 298.54,31.07 291.69,31.07 289.41,28.79 277.5,28.79 277.04,28.33 275.24,28.33 274.47,29.1 253.82,29.1 253.4,29.51 248.12,29.51 247.7,29.1 243.2,29.1 240.53,31.76 240.53,34.95 238.88,36.6 232.78,36.6 232.5,36.33 228.12,36.33 227.09,37.37 226.18,37.37 222.89,40.66 216.75,40.66 216.42,40.99 214.71,40.99 214.37,40.65 213.86,40.65 213.31,41.2 210.85,41.2 210.33,40.68 209.33,40.68 209.24,40.77 209.24,41.2 209.3,41.26 209.3,41.82 208.98,42.14 208.22,42.14 207.03,40.94 206.15,40.94 v2(206.14,40.93)
  BOTTOM w0.089: 206.5,40.03 206.5,40.61
  BOTTOM w0.107: 206.5,40.61 206.18,40.93 v2(206.14,40.93) ; UH1.AE1 206.59,39.41 206.5,39.5 206.5,40.02 206.5,40.03
USB20_N5: length 120
  IN6 w0.089: v2(301.58,29.27) 301.35,29.5 301.35,29.74 301.16,29.93 291.44,29.93 288.96,27.44 275.23,27.44 274.21,28.46 248.1,28.46 243.34,23.69 242.7,23.69 239.61,20.61 237.37,20.61 235.66,22.32 233.22,22.32 231.4,24.15 231.4,26.75 229.59,28.55 229.59,33.66 229.21,34.04 228.25,34.04 226.45,35.84 225.55,35.84 222.47,38.92 218.8,38.92 218.28,39.44 210.06,39.44 209.56,38.94 207.65,38.94 206.19,37.48 206,37.48 v2(205.72,37.76)
  BOTTOM w0.099: JWLAN.5 301.32,32.65
  BOTTOM w0.107: v2(205.72,37.76) 205.75,37.79 205.75,38.72 205.63,38.83 UH1.AC2 ; v2(301.58,29.27) 301.25,29.59 301.25,32.58 301.32,32.65
USB20_N6: length 193.2
  TOP w0.099: DV2.3 161.73,166.61 162.19,166.15
  TOP w0.107: 162.19,166.15 162.39,166.15 162.52,166.02 162.52,165.78 162.82,165.47 163.18,165.47 163.92,164.74 164.83,164.74 165.12,164.45 165.57,164.45 165.79,164.66 v2(166.09,164.66) ; JEDP.17 159.62,179.64 159.75,179.51 159.75,179.05 158.34,177.64 158.17,177.64 157.27,176.74 157.27,174.48 160.08,171.67 160.08,170.48 162.68,167.88 162.68,166.99 162.31,166.62 DV2.3
  IN1 w0.089: v2(166.09,164.66) 166.35,164.66 166.4,164.71 166.4,164.96 166.47,165.02 166.74,165.02 167.42,164.34 167.42,161.5 168.5,160.42 175.56,160.42 177.95,158.03 183.14,158.03 183.71,157.45 186.68,157.45 186.98,157.75 188,157.75 188.25,157.5 188.25,157.11 192.76,152.6 192.76,150.47 195.98,147.24 195.98,137.98 196.36,137.61 196.36,134.31 195.64,133.59 195.64,132.9 195.42,132.68 194.95,132.68 194.45,132.18 194.45,131.82 193.96,131.33 193.96,130.22 191.74,127.99 191.74,122.27 189.75,120.27 189.75,112.47 186.86,109.58 186.86,97.27 187.65,96.48 187.65,95.86 189.87,93.64 189.87,86.78 187.65,84.56 187.65,69.3 188.67,68.28 188.67,66.64 190.19,65.12 193.46,65.12 196.56,62.02 196.56,58.95 194.89,57.28 194.89,52.34 199.41,47.82 199.41,46.14 203.45,42.09 206.06,42.09 207.36,40.79 207.36,40.16 207.25,40.05 207.14,40.05 206.87,40.32 v2(206.87,40.41)
  BOTTOM w0.089: v2(206.87,40.41) 207.23,40.05 207.23,39.67
  BOTTOM w0.107: 207.23,39.67 207.23,39.66 UH1.AF2
USB20_N7: length 164.3
  TOP w0.107: LV2.1 167.02,160.89 167.17,160.74 167.17,160.14 v3(167.59,159.72) 167.96,159.35 167.96,158.32 v2(167.77,158.13)
  IN1 w0.089: v2(205.57,40.42) 205.28,40.71 204.88,40.71 204.19,41.4 203.25,41.4 198.77,45.87 198.77,47.56 196.59,49.75 195.89,49.75 194.1,51.53 194.1,57.39 195.17,58.45 195.17,60.16 194.92,60.42 194.92,62.76 193.19,64.48 189.92,64.48 188.03,66.38 188.03,68.02 187.01,69.04 187.01,84.83 189.23,87.05 189.23,93.38 187.01,95.6 187.01,96.22 186.22,97.01 186.22,110.54 189.09,113.41 189.09,120.52 191.02,122.44 191.02,128.17 193.3,130.45 193.3,131.57 193.53,131.79 193.53,132.38 195.36,134.21 195.36,136.05 195.67,136.37 195.67,137.39 195.34,137.72 195.34,146.98 192.06,150.27 192.06,152.15 188.01,156.2 182.42,156.2 181.31,157.31 175.81,157.31 175.4,156.9 172.6,156.9 172.13,157.37 168.38,157.37 167.99,157.75 167.99,157.9 v2(167.77,158.13)
  BOTTOM w0.107: UH1.AB3 204.96,38.6 205.22,38.85 205.22,39.44 205.18,39.48 205.18,40.21 205.41,40.45 205.54,40.45 v2(205.57,40.42)
USB20_N8: length 237.6
  IN6 w0.089: v2(16.13,55.83) 16.13,55.85 16.33,56.05 16.46,56.05 16.67,55.83 16.67,51.06 18.24,49.49 19.18,49.49 21.74,46.93 21.74,43.65 22.31,43.09 22.31,37.25 23.19,36.36 24.83,36.36 29.28,40.81 29.71,40.81 35.77,46.86 49.1,46.86 49.47,47.23 56.79,47.23 57.75,46.27 92.05,46.27 92.5,45.82 94.97,45.82 95.74,45.05 97.16,45.05 102.72,39.49 102.72,32.98 108.8,26.89 173.68,26.89 175.07,28.29 181.68,28.29 182.95,29.56 186.64,29.56 187.68,30.6 191.39,30.6 193.93,28.06 198.84,28.06 201.05,30.27 203.85,30.27 205.87,32.28 205.87,32.86 206.65,33.65 207.02,33.65 207.46,34.08 207.46,35.91 207.84,36.3 208.16,36.3 208.46,36.6 209.02,36.6 v2(209.26,36.36)
  BOTTOM w0.089: UH1.AL8 209.64,35.98 v2(209.26,36.36)
  BOTTOM w0.107: LU9.4 15.66,57.31 15.22,56.87 15.22,56.15 15.53,55.83 v2(16.13,55.83)
USB20_N8_CONN: length 19.9
  TOP w0.107: v2(8.82,59.9) 8.61,60.1 8.21,60.1 8.03,59.92 JUSBC2.A7 ; JUSBC2.B7 6.66,60.68 v2(6.71,60.62)
  IN1 w0.089: v2(8.82,59.9) 8.83,59.89 9.35,59.89 10.4,60.94 10.4,61.89 10.02,62.26 8.01,62.26 7.23,61.48 7.23,61.14 v2(6.71,60.62)
  BOTTOM w0.107: LU9.3 15.66,59.56 15.82,59.72 15.82,59.85 15.71,59.96 15.41,59.96 15.25,59.81 15.25,59.03 14.97,58.76 DU11.3 13.94,59.42 13.83,59.53 13.28,59.53 12.4,60.41 11,60.41 10.49,59.9 10.14,59.9 10.11,59.87 9.54,59.87 9.51,59.9 v2(8.82,59.9)
USB20_N9: length 172.8
  IN1 w0.089: v2(156.96,160.61) 156.95,160.61 156.55,160.21 156.55,159.25 156.22,158.93 156.22,153.26 158.09,151.39 163.36,151.39 166.02,148.72 184.79,148.72 188.05,145.47 188.05,122.94 186.38,121.27 186.38,114.28 183.82,111.72 183.82,95.49 186.86,92.45 186.86,88.15 184.67,85.96 184.67,68.58 184.22,68.14 184.22,67.53 185.17,66.59 185.17,63.86 186.7,62.33 186.7,61.31 187.17,60.84 188.18,60.84 188.45,61.11 v2(188.45,61.13)
  BOTTOM w0.107: UH1.AA1 204.28,39.41 202.84,40.85 202.84,42.99 202.84,43.16 202.84,43.39 199.97,46.26 199.97,50.39 202.64,53.05 202.64,58.64 200.82,60.46 189.12,60.46 188.68,60.9 188.68,60.98 188.53,61.13 v2(188.45,61.13) ; v2(156.96,160.61) 156.81,160.76 156.81,160.98 156.91,161.09 LE3.1 157.08,161.63 RE647.1
USB20_N9_L: length 10.2
  TOP w0.102: v2(156.86,167.56) 156.67,167.37 156.45,167.37 156.16,167.07 JTOBII.3
  BOTTOM w0.102: v2(156.86,167.56) 157.02,167.39 157.28,167.39 157.51,167.16 157.51,166 158.44,165.07 158.76,165.07 DV14.2 159.17,164.4 158.19,163.42 157.04,163.42 156.91,163.29 LE3.2 157.08,162.54 RE647.2
USB20_P1: length 212.2
  TOP w0.107: UU1.3 22.58,42.55 22.42,42.39 22.42,41.24 22.69,40.97 v3(25.45,40.97) 25.79,40.97 26.11,40.66 26.11,40.32 v2(26.33,40.1)
  IN6 w0.089: v2(26.33,40.1) 26.31,40.1 26.04,40.37 26.04,40.67 28.91,43.54 31.49,43.54 35.45,47.5 48.83,47.5 49.2,47.87 57.08,47.87 57.7,47.24 65.59,47.24 65.91,46.92 94.76,46.92 96,45.69 97.44,45.69 103.35,39.78 103.35,33.36 109.06,27.65 172.23,27.65 173.5,28.92 180.98,28.92 182.32,30.26 186.11,30.26 187.19,31.35 191.59,31.35 193.92,29.01 198.97,29.01 199.88,29.92 199.88,30.81 200.48,31.41 202.06,31.41 203.63,32.97 203.63,33.61 204.11,34.09 205.15,34.09 205.34,34.29 205.34,34.76 207.39,36.81 207.39,37.09 207.51,37.21 207.7,37.21 207.89,37.02 v2(207.89,36.96)
  BOTTOM w0.089: UH1.AG7 207.52,36.96 v2(207.89,36.96)
USB20_P1_CONN: length 14.1
  BOTTOM w0.107: LU3.3 23.75,39.02 23.64,38.91 23.64,37.35 23.18,36.88 22.76,36.88 22.45,36.57 DU1.3 22.11,36.37 22.11,36.8 22,36.91 21.94,36.9 21.68,36.9 21.15,37.43 21.15,38.77 20.62,39.3 20.41,39.3 20.39,39.27 19.82,39.27 19.8,39.29 19.65,39.29 v3(18.87,38.51) 18.03,37.68 16.66,37.68 16.55,37.57 JUSB1.3
USB20_P2: length 152
  TOP w0.107: v2(323.05,17.98) 323.05,19.12 323.63,19.7 323.63,20.73 324.26,21.36 JIO.24
  IN6 w0.089: v2(205.68,36.07) 206.08,36.47 206.56,36.47 206.8,36.71 206.8,37.11 207.64,37.95 208.24,37.95 208.49,37.7 209.93,37.7 210.05,37.82 210.18,37.82 211.13,38.78 215.72,38.78 216.3,38.2 216.3,37.69 217.25,36.74 217.9,36.74 220.63,34.01 222.75,34.01 223.78,35.04 226.12,35.04 228.38,32.78 228.38,26.79 230.27,24.91 230.27,22.89 232.46,20.69 236.15,20.69 237.04,19.81 239.94,19.81 242.71,22.57 243.4,22.57 248.49,27.66 273.88,27.66 275.23,26.31 289.88,26.31 291.82,28.25 300.74,28.25 301.29,27.7 313.85,27.7 315.55,26 315.55,20.69 318.11,18.14 322.52,18.14 322.94,18.56 323.29,18.56 323.38,18.47 323.38,18.3 323.06,17.98 v2(323.05,17.98)
  BOTTOM w0.107: UH1.AD7 206.32,36.69 206.32,36.51 205.88,36.07 v2(205.68,36.07)
USB20_P3: length 185.3
  IN1 w0.089: v2(167.9,172.16) 168.03,172.03 168.03,170.78 166.4,169.16 166.4,167.7 165.4,166.69 164.34,166.69 163.9,166.25 163.9,164.09 164.69,163.3 164.69,160.16 168.11,156.73 171.43,156.73 172.56,155.6 174.38,155.6 174.54,155.44 176.63,155.44 176.81,155.61 180.93,155.61 182.1,154.45 188.86,154.45 191.4,151.91 191.4,149.58 194.71,146.27 194.71,137.46 195.04,137.13 195.04,136.77 194.71,136.44 194.71,134.64 190.19,130.12 190.19,122.51 188.46,120.78 188.46,113.68 185.58,110.8 185.58,96.13 188.6,93.12 188.6,87.31 186.38,85.09 186.38,68.78 187.4,67.76 187.4,66.11 189.66,63.85 192.93,63.85 194.27,62.5 194.27,61.5 193.64,60.86 193.64,58.01 193.47,57.83 193.47,51.27 195.62,49.11 196.32,49.11 198.14,47.3 198.14,45.61 204.56,39.19 206.49,39.19 207.27,38.41 207.27,35.01 207.46,34.82 207.64,34.82 v2(207.83,34.63)
  BOTTOM w0.107: LM1.4 167.97,173 168.12,172.85 168.12,172.37 v2(167.9,172.16) ; UH1.AG10 207.25,35.15 207.25,35 207.62,34.63 v2(207.83,34.63)
USB20_P3_CONN: length 3.4
  BOTTOM w0.099: JCDRA.39 167.82,176.66 ; 167.97,174.85 LM1.3
  BOTTOM w0.107: 167.82,176.66 167.89,176.59 167.89,176.19 168.12,175.96 168.12,175.21 168.14,175.18 168.14,175.03 167.97,174.85
USB20_P4: length 149.9
  TOP w0.107: UE1.4 316.2,10.08 316.5,10.39 316.5,11.95 319.62,15.06 319.62,16.54 320.41,17.34 321.06,17.34 321.95,18.23 321.95,18.67 v2(321.76,18.86)
  IN6 w0.089: v2(321.76,18.86) 321.98,19.08 321.98,19.17 321.83,19.32 320.02,19.32 319.59,19.76 317.83,19.76 316.28,21.31 316.28,26.49 314.28,28.48 305.15,28.48 303.23,30.4 298.97,30.4 298.47,30.91 291.76,30.91 289.48,28.63 277.57,28.63 277.11,28.17 275.17,28.17 274.41,28.93 253.75,28.93 253.33,29.35 248.19,29.35 247.77,28.93 243.13,28.93 240.37,31.69 240.37,34.88 238.81,36.44 232.84,36.44 232.57,36.16 228.05,36.16 227.02,37.2 226.11,37.2 222.82,40.49 216.68,40.49 216.35,40.82 214.78,40.82 214.44,40.48 213.79,40.48 213.24,41.04 210.92,41.04 210.4,40.51 209.26,40.51 209.08,40.7 209.08,41.27 209.14,41.33 209.14,41.75 208.91,41.97 208.29,41.97 207.09,40.77 206.49,40.77 206.34,40.62 206.32,40.62 206.14,40.44 v2(206.14,40.35)
  BOTTOM w0.089: UH1.AE2 206.65,38.94 206.65,39.06 206.58,39.13 206.37,39.13
  BOTTOM w0.107: 206.37,39.13 206.18,39.33 206.18,40.3 v2(206.14,40.35)
USB20_P5: length 120.1
  IN6 w0.089: v2(300.78,29.31) 300.91,29.18 301.09,29.18 301.18,29.27 301.18,29.67 301.09,29.76 291.51,29.76 289.03,27.28 275.16,27.28 274.14,28.3 248.17,28.3 243.4,23.53 242.77,23.53 239.68,20.44 237.3,20.44 235.59,22.16 233.16,22.16 231.23,24.08 231.23,26.68 229.43,28.48 229.43,33.59 229.14,33.88 228.18,33.88 226.39,35.68 225.48,35.68 222.4,38.76 218.73,38.76 218.22,39.28 210.13,39.28 209.63,38.78 207.72,38.78 206.25,37.31 206,37.31 205.83,37.31 v2(205.72,37.2)
  BOTTOM w0.089: v2(205.72,37.2) 205.34,37.57 205.34,37.9 205.47,38.03 UH1.AC3
  BOTTOM w0.099: JWLAN.3 300.82,32.65
  BOTTOM w0.107: v2(300.78,29.31) 301.05,29.57 301.05,32.42 300.82,32.65
USB20_P6: length 193.1
  TOP w0.107: v2(166.09,165.25) 165.49,164.65 165.21,164.65 164.91,164.94 164,164.94 163.26,165.68 162.91,165.68 162.72,165.86 162.72,166.03 162.83,166.14 163.18,166.14 DV2.2 163.02,166.62 162.89,166.76 162.89,167.96 160.28,170.56 160.28,171.75 157.47,174.56 157.47,176.65 158.26,177.44 158.43,177.44 159.95,178.96 159.95,179.46 160.12,179.63 JEDP.18
  IN1 w0.089: v2(166.09,165.25) 166.14,165.19 166.81,165.19 167.59,164.41 167.59,161.57 168.57,160.59 175.62,160.59 178.02,158.19 183.21,158.19 183.78,157.62 186.61,157.62 186.91,157.92 188.07,157.92 188.41,157.57 188.41,157.18 192.92,152.67 192.92,150.54 196.14,147.31 196.14,138.05 196.52,137.67 196.52,134.24 195.8,133.52 195.8,132.83 195.49,132.52 195.02,132.52 194.61,132.11 194.61,131.75 194.13,131.26 194.13,130.15 191.91,127.93 191.91,122.2 189.91,120.2 189.91,112.4 187.02,109.51 187.02,97.34 187.81,96.55 187.81,95.93 190.03,93.71 190.03,86.71 187.81,84.49 187.81,69.37 188.83,68.35 188.83,66.71 190.26,65.28 193.52,65.28 196.73,62.08 196.73,58.88 195.06,57.21 195.06,52.41 199.57,47.89 199.57,46.2 203.52,42.26 206.13,42.26 207.53,40.86 207.53,40.09 207.32,39.88 206.95,39.88 v2(206.87,39.81)
  BOTTOM w0.107: UH1.AF3 207.23,38.63 206.98,38.88 206.98,39.7 v2(206.87,39.81)
USB20_P7: length 164.3
  TOP w0.107: v2(168.35,158.13) 168.16,158.32 168.16,159.43 167.95,159.64 167.95,159.68 167.55,160.09 167.51,160.09 167.37,160.23 167.37,160.74 167.52,160.89 LV2.4
  IN1 w0.089: v2(168.35,158.13) 168.26,158.13 168.16,158.03 168.16,157.82 168.45,157.53 172.2,157.53 172.67,157.07 175.33,157.07 175.74,157.47 181.38,157.47 182.49,156.37 188.08,156.37 192.22,152.22 192.22,150.34 195.51,147.05 195.51,137.79 195.84,137.46 195.84,136.3 195.53,135.99 195.53,134.14 193.69,132.31 193.69,131.73 193.47,131.5 193.47,130.39 191.18,128.1 191.18,122.37 189.26,120.45 189.26,113.35 186.38,110.47 186.38,97.08 187.18,96.28 187.18,95.67 189.4,93.45 189.4,86.98 187.18,84.76 187.18,69.11 188.2,68.09 188.2,66.44 189.99,64.65 193.26,64.65 195.08,62.83 195.08,60.48 195.33,60.23 195.33,58.39 194.27,57.32 194.27,51.6 195.96,49.91 196.66,49.91 198.94,47.63 198.94,45.94 203.32,41.56 204.26,41.56 204.94,40.87 205.08,40.87 205.17,40.96 205.17,41.08 205.3,41.22 205.43,41.22 205.57,41.08 v2(205.57,40.99)
  BOTTOM w0.107: UH1.AB2 204.87,39.08 204.87,39.46 204.97,39.56 204.97,40.41 205.55,40.99 v2(205.57,40.99)
USB20_P8: length 237.5
  IN6 w0.089: v2(16.13,56.41) 16.13,56.41 16.33,56.21 16.53,56.21 16.84,55.9 16.84,51.13 18.31,49.66 19.25,49.66 21.9,47 21.9,43.72 22.47,43.16 22.47,37.31 23.26,36.53 24.77,36.53 29.21,40.97 29.65,40.97 35.7,47.03 49.03,47.03 49.4,47.4 56.86,47.4 57.82,46.44 92.12,46.44 92.57,45.99 95.04,45.99 95.81,45.22 97.22,45.22 102.88,39.56 102.88,33.05 108.87,27.06 173.61,27.06 175.01,28.45 181.61,28.45 182.88,29.72 186.57,29.72 187.61,30.77 191.46,30.77 194,28.23 198.77,28.23 200.98,30.43 203.78,30.43 205.7,32.35 205.7,32.93 206.59,33.81 206.96,33.81 207.29,34.15 207.29,35.98 207.77,36.46 208.09,36.46 208.39,36.76 209.03,36.76 v2(209.26,36.99)
  BOTTOM w0.089: v2(209.26,36.99) 209.58,36.67 UH1.AL7
  BOTTOM w0.107: LU9.1 16.16,57.52 16.08,57.44 15.97,57.44 15.86,57.33 15.86,57.22 15.42,56.78 15.42,56.23 15.61,56.04 15.76,56.04 15.96,56.24 16.02,56.24 16.13,56.35 v2(16.13,56.41)
USB20_P8_CONN: length 19.8
  TOP w0.107: JUSBC2.B6 6.57,60.17 v2(6.71,60.04) ; JUSBC2.A6 8.09,60.42 8.21,60.31 8.64,60.31 v2(8.82,60.48)
  IN1 w0.089: v2(6.71,60.04) 7.39,60.72 7.39,61.41 8.08,62.1 9.95,62.1 10.23,61.82 10.23,61.01 9.4,60.18 9.28,60.18 9.19,60.27 9.03,60.27 v2(8.82,60.48)
  BOTTOM w0.107: v2(8.82,60.48) 8.87,60.48 9.25,60.1 v3(9.83,60.1) 10.4,60.1 10.91,60.61 12.48,60.61 13.36,59.73 13.83,59.73 13.94,59.84 DU11.2 15.13,60.69 15.25,60.57 15.25,60.36 15.44,60.17 15.79,60.17 16.02,59.93 16.02,59.71 16.16,59.57 LU9.2
USB20_P9: length 172.8
  IN1 w0.089: v2(188.45,60.55) 188.32,60.67 187.1,60.67 186.53,61.24 186.53,62.26 185,63.79 185,66.52 184.06,67.46 184.06,68.21 184.5,68.65 184.5,86.03 186.69,88.22 186.69,92.38 183.65,95.43 183.65,111.78 186.21,114.34 186.21,121.34 187.88,123.01 187.88,145.4 184.73,148.56 165.95,148.56 163.29,151.23 158.02,151.23 156.05,153.19 156.05,159 156.38,159.32 v2(156.38,160.61)
  BOTTOM w0.107: v2(156.38,160.61) 156.6,160.83 156.6,160.94 156.41,161.13 LE3.4 156.25,161.63 RE648.1 ; UH1.AA2 204.34,38.95 204.08,39.22 204.08,39.32 202.63,40.77 202.63,42.99 202.63,43.16 202.63,43.31 199.77,46.18 199.77,50.47 202.43,53.14 202.43,58.56 200.74,60.25 189.04,60.25 188.74,60.55 v2(188.45,60.55)
USB20_P9_L: length 10.3
  TOP w0.102: v2(156.86,166.97) 156.69,167.14 156.55,167.14 156.39,166.98 156.39,166.53 156.51,166.4 156.85,166.4 156.96,166.3 JTOBII.4
  BOTTOM w0.102: RE648.2 156.25,162.54 LE3.3 156.57,162.86 156.57,163.26 156.95,163.65 158.09,163.65 158.19,163.75 158.19,164.08 158.08,164.18 157.62,164.18 157.23,164.56 DV14.3 157.72,164.66 157.93,164.88 157.93,165.25 157.29,165.9 157.29,167.06 157.18,167.16 157.05,167.16 v2(156.86,166.97)
