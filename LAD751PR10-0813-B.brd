# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EC_TX: length 69.2
  TOP w0.102: RM31.1 309.83,43.3 310.11,43.01 310.11,42.67 v2(309.7,42.26)
  TOP w0.107: v2(294.96,11.2) 294.96,14.61 295.32,14.97 295.32,19.05 294.94,19.43 294.94,22.03 293.94,23.03 UE5.30 293.94,24.82 294.43,25.31 294.43,27.53 292.91,29.05 292.91,32.81 290.39,35.33 v1(290.39,35.97) v2(290.39,36.74)
  IN1 w0.102: v2(290.39,36.74) 291.23,37.57 302.15,37.57 305.12,40.55 307.98,40.55 v2(309.7,42.26)
  BOTTOM w0.102: v2(309.7,42.26) 309.57,42.14 JWLAN.30
  BOTTOM w0.107: v2(294.96,11.2) 294.53,11.63 294.04,11.63 293.35,10.94 292.52,10.94 290.84,9.25 286.31,9.25 285.12,8.06 283.78,8.06 283.45,8.38 283.45,10.7 283.69,10.94 JEC.6
ECAGND: length 260
  TOP w0.254: PH1.2 153.81,109.5 v2(153.94,109.63) ; v2(280.17,28.22) 280.29,28.1 280.29,19.08 282.7,16.67 v1(282.7,16.63) 282.7,16.25 284.93,14.03 v2(284.93,12.41) 284.93,12.03 285.19,11.78 288.04,11.78 288.36,11.46 CE33.2 288.36,10.81 288.71,10.46 CE35.1 288.43,10.08 288.22,9.87 LE2.2
  IN1 w0.254: v2(284.93,12.41) 285.49,11.86 287.32,11.86 288.95,10.23 293.96,10.23 v2(294.76,9.43)
  IN2 w0.254: v2(280.17,28.22) 280.17,28.45 279.91,28.71 276.39,28.71 275.48,29.62 270.06,29.62 268.63,31.05 256.45,31.05 256.07,30.66 249.58,30.66 248.95,31.3 248.95,35.32 246.93,37.33 240.78,37.33 239.55,38.56 236.27,38.56 236.03,38.81 236.03,39.63 235.17,40.48 233.29,40.48 232.06,39.25 231.02,39.25 230.39,38.63 223.87,38.63 221.32,41.17 217.7,41.17 217.63,41.1 214.79,41.1 214.39,40.7 211.22,40.7 209.87,42.04 205.91,42.04 205.08,41.21 205.08,40.42 204.73,40.08 202.82,40.08 201.65,41.25 199.98,41.25 199.4,40.67 188.18,40.67 182.14,34.64 181.95,34.64 180.21,32.9 165.26,32.9 v2(163.9,34.26)
  IN3 w0.254: v2(153.94,109.63) 152.94,108.63 152.94,97.02 153.19,96.77 153.19,87.37 155.85,84.7 166.19,84.7 169.05,81.85 169.05,58.96 168.22,58.13 168.22,53.25 165.24,50.26 165.24,46.51 164.47,45.75 164.47,38.77 163.9,38.2 v2(163.9,34.26)
EDP_AUX#_C: length 15.6
  TOP w0.107: CV13.1 151.95,167.79 151.95,167.91 152.46,168.42 153,168.42 153.64,169.06 153.64,171.47 156.03,173.87 156.03,176.93 157.95,178.85 157.95,179.41 158.12,179.58 JEDP.14
EDP_AUX_C: length 15.6
  TOP w0.107: JEDP.13 157.62,179.58 157.75,179.45 157.75,178.93 155.83,177.01 155.83,173.95 153.44,171.56 153.44,169.14 152.92,168.62 152.37,168.62 151.71,167.96 151.71,167.79 151.69,167.77 151.69,167.76 CV12.1
EDP_HPD: length 113.4
  TOP w0.102: v2(204.22,126.59) 203.39,127.41 201.68,127.41 200.8,128.3 v1(200.8,130.08) 200.8,134.6 v2(199.92,135.48) ; v2(158.81,178.92) 159.12,179.23 JEDP.16
  IN1 w0.102: v2(158.81,178.92) 160.82,176.92 171.17,176.92 171.67,176.41 174.76,176.41 175.37,175.8 180.5,175.8 181.07,175.23 182.61,175.23 182.93,174.91 186.98,174.91 188.3,173.59 190.72,173.59 193.53,170.78 196.96,170.78 198.07,169.68 198.96,169.68 200.07,170.78 201.62,170.78 203.87,168.54 203.87,166.81 202.97,165.92 202.97,159.88 203.81,159.05 203.81,155.77 206.84,152.74 207.35,152.74 207.86,152.23 207.86,150.36 204.3,146.8 204.3,142.51 205.14,141.67 205.14,127.4 204.33,126.59 v2(204.22,126.59)
  BOTTOM w0.102: RH657.1 199.92,136.12 v2(199.92,135.48) UV21.44 ; v2(204.22,126.59) 204.22,127.34 203.86,127.71 RG508.2
EDP_HPD_CPU: length 13.3
  IN2 w0.102: v2(197.37,128.66) 197.37,129.6 198.5,130.73 198.5,133.04 200.34,134.88 200.34,138.55 v2(199.84,139.05)
  BOTTOM w0.102: UV21.13 197.52,128.81 v2(197.37,128.66) ; RH656.1 199.93,138.77 199.84,138.86 v2(199.84,139.05)
EDP_HPD_GPU: length 8.2
  IN4 w0.102: v2(203.17,123.64) 203.17,125.3 202.9,125.57 202.9,127.22 v2(201.52,128.6)
  BOTTOM w0.102: v1(203.17,123.03) v2(203.17,123.64) 202.73,124.09 RG507.2 ; UV21.3 v2(201.52,128.6)
EDP_HPD_GPU#: length 24.8
  IN1 w0.089: 217.92,118.18 217.59,117.85 216.12,117.85 215.44,117.16 215.44,115.96 215.93,115.46 217.05,115.46 218.58,113.94 v2(218.64,113.94)
  IN1 w0.102: 217.92,118.18 218.07,118.34 218.07,119.02 217.86,119.23 214.64,119.23 v2(214.45,119.42)
  BOTTOM w0.089: v2(218.64,113.94) 218.93,113.65 UG9.BH1
  BOTTOM w0.102: v2(214.45,119.42) v1(213.51,120.36) 212.61,120.36 211.86,121.11 211.86,121.69 210.88,122.67 209.37,122.67 209.1,122.4 209.1,122.06 209,121.95 QG500.3 208.79,122.14 208.79,122.5 207.84,123.45 206.19,123.45 RG500.2
EDP_MUX_PD: length 165.7
  IN2 w0.102: v2(201.3,140.94) 200.56,140.2 200.56,134.79 199.02,133.24 199.02,130.45 197.9,129.34 197.9,128.62 197.21,127.92 194.46,127.92 193.01,126.47 193.01,125.1 188.92,121.01 188.92,113.54 186.43,111.05 186.43,102.65 185.34,101.56 185.34,94.21 187.18,92.36 187.18,85.29 179.12,77.23 179.12,74.49 179.82,73.8 183.95,73.8 191.32,66.42 191.32,66.23 191.32,63.01 192.09,62.25 v2(192.62,62.25)
  IN3 w0.089: 197.89,42.08 197.89,41.57 198.67,40.78 198.67,39.93 199.14,39.47 200.48,39.47 201.11,38.83 201.11,37.56 201.61,37.07 201.61,34.31 201.36,34.07 201.36,32.29 200.62,31.55 200.62,28.71 201.43,27.9 201.43,24.16 201.78,23.81 202.42,23.81 203.23,23.01 204.17,23.01 205.11,22.07 207.84,22.07 208.16,21.75 208.16,21.18 208.34,21 208.34,20.45 209.07,19.72 209.07,19.72 209.79,19.01 210.57,19.01 210.84,19.27 v2(212.29,19.27)
  IN3 w0.102: v2(192.62,62.25) 192.13,61.76 192.13,60.26 191.67,59.79 191.67,58.52 191.25,58.1 191.25,57.24 192.12,56.36 192.12,52.98 197.89,47.21 197.89,42.08
  BOTTOM w0.089: UH1.AU43 212.49,19.08 v2(212.29,19.27)
  BOTTOM w0.102: QV95.2 206.11,139.16 RV658.1 204.99,140.29 204.99,141.02 204.68,141.32 202.58,141.32 202.17,140.91 v1(202.05,140.91) 201.33,140.91 v2(201.3,140.94)
EDP_RCOMP: length 8.1
  BOTTOM w0.089: RC30.1 v1(177.62,121.39)
  BOTTOM w0.152: CPU1.D37 171,119.58 171.28,119.85 171.28,120.43 171.42,120.57 171.93,120.57 172.36,121
  BOTTOM w0.508: RC30.1 172.75,121.39 172.36,121
EDP_SW: length 339.5
  TOP w0.102: v2(179.27,15.34) 180.15,15.34 v1(180.35,15.14) 187.79,7.7 192.67,7.7 193.05,8.08 RV659.1 UV22.1
  TOP w0.107: v2(300.78,13.67) 303.92,10.54 305.44,10.54 305.77,10.21 UE5.98
  IN2 w0.102: v2(203.88,132.54) 202.7,131.36 200.83,131.36 199.68,130.21 199.1,130.21 198.26,129.37 198.26,128.65 197.3,127.69 194.56,127.69 193.24,126.38 193.24,125 189.15,120.91 189.15,113.44 186.66,110.96 186.66,102.56 185.57,101.46 185.57,94.3 187.41,92.46 187.41,85.2 179.35,77.14 179.35,74.59 179.91,74.03 184.04,74.03 191.55,66.52 191.55,66.14 191.55,63.18 191.96,62.77 192.69,62.77 v2(193.21,62.25)
  IN3 w0.089: v2(213.11,19.78) 212.82,20.08 212.82,21.22 212.39,21.65 211.86,21.65 211,22.51 210.39,22.51 209.86,23.03 209.86,24.17 209.37,24.67 208.74,24.67 208.34,25.07 206.67,25.07 206.36,24.76 206.36,24.19 206.06,23.89 205.11,23.89 204.04,24.96 203.28,24.96 202.5,25.74 202.5,30.24 202.92,30.66 202.92,31.81 203.64,32.54 203.64,39.39 201.18,41.85 201.18,42.08
  IN3 w0.102: 201.18,42.08 201.18,42.58 199.26,44.49 199.26,47.77 196.72,50.32 196.72,51.26 193.49,54.49 193.49,57.65 194.04,58.2 194.04,61.42 v2(193.21,62.25)
  IN4 w0.102: v2(300.78,13.67) 299.91,14.55 298.55,14.55 297.82,15.29 292.44,15.29 289.8,17.92 280.43,17.92 278.31,15.8 269.19,15.8 268.06,16.93 266.8,16.93 265.73,18 263.05,18 258.84,13.8 255.06,13.8 254.61,13.35 247.28,13.35 246.41,14.22 246.41,14.45 244.94,15.92 242.59,15.92 239.53,18.99 239.53,21.33 237.93,22.94 235.14,22.94 234.13,23.95 234.13,29.06 232.38,30.82 230.75,30.82 229.2,32.37 228.65,32.37 228.15,31.87 228.15,28.73 227.08,27.66 227.08,25.49 226.48,24.89 225.69,24.89 223.46,22.66 222.6,22.66 218.32,18.38 216.54,18.38 215.97,17.81 213.69,17.81 213.21,18.29 213.21,19.69 v2(213.11,19.78) 212.8,20.1 212.8,20.85 211.57,22.07 211.57,22.07 210.94,22.07 209.67,20.8 208.35,20.8 207.97,21.17 205.8,21.17 204.86,22.12 203.83,22.12 203.62,21.9 203.02,21.9 202.47,21.35 201.64,21.35 201.24,20.95 201.24,18.89 200.59,18.24 199.25,18.24 198.03,19.46 197.43,19.46 197.15,19.74 194.85,19.74 194.03,18.92 193.02,18.92 192.52,18.42 190.32,18.42 189.71,17.81 181.75,17.81 v2(179.27,15.34)
  BOTTOM w0.089: v2(213.11,19.78) 213.11,19.25 212.73,18.86 212.73,18.44 UH1.AV44
  BOTTOM w0.102: v2(203.88,132.54) 203.84,132.58 UV21.54
EDP_TX0#_C: length 15
  TOP w0.107: CV2.1 147.53,167.44 147.53,167.72 148.99,169.18 148.99,169.68 149.33,170.02 149.33,174.34 150.22,175.23 150.22,177.27 151.95,178.99 151.95,179.4 152.12,179.58 JEDP.2
EDP_TX0_C: length 15
  TOP w0.107: JEDP.1 151.62,179.58 151.74,179.46 151.74,179.07 150.02,177.35 150.02,175.31 149.13,174.42 149.13,170.11 148.79,169.77 148.79,169.27 147.33,167.8 147.33,167.52 CV1.1
EDP_TX1#_C: length 14.7
  TOP w0.107: CV4.1 148.87,167.76 148.87,168.08 149.68,168.89 149.68,169.4 150.03,169.74 150.03,171.73 151.05,172.76 151.05,175.97 152.2,177.11 152.2,177.78 153.41,178.99 153.41,179.37 153.62,179.58 JEDP.5
EDP_TX1_C: length 14.7
  TOP w0.107: JEDP.4 153.12,179.58 153.21,179.49 153.21,179.08 151.99,177.86 151.99,177.2 150.85,176.05 150.85,172.84 149.82,171.82 149.82,169.82 149.48,169.48 149.48,168.98 148.67,168.17 148.67,167.84 CV3.1
EDP_TX2#_C: length 14.8
  TOP w0.107: JEDP.8 155.12,179.58 154.95,179.41 154.95,178.65 153.28,176.98 153.28,173.52 150.77,171 150.77,168.83 150.12,168.18 150.12,167.77 CV6.1
EDP_TX2_C: length 14.8
  TOP w0.107: JEDP.7 154.62,179.58 154.75,179.45 154.75,178.74 153.08,177.07 153.08,173.6 150.57,171.09 150.57,168.91 149.92,168.26 149.92,167.82 CV8.1
EDP_TX3#_C: length 16.5
  TOP w0.107: JEDP.11 156.62,179.58 156.46,179.42 156.46,178.92 154.96,177.42 154.96,174.22 151.47,170.73 151.47,168.41 151.01,167.96 151.01,166.38 CV11.1
EDP_TX3_C: length 16.5
  TOP w0.107: CV7.1 150.81,166.43 150.81,168.04 151.27,168.5 151.27,170.81 154.76,174.3 154.76,177.5 156.26,179 156.26,179.45 156.12,179.58 JEDP.10
ELC_8051_C2CK_RST#: length 179.2
  TOP w0.102: v2(322.75,10.07) 322.75,9.99 v1(322.23,9.47)
  TOP w0.107: UE1.9 322.72,10.73 RE7.2 v2(322.75,10.07)
  IN6 w0.102: v2(322.75,10.07) 322.35,10.47 305.35,10.47 304.03,11.79 292.15,11.79 289.91,9.56 281.12,9.56 279.59,11.09 256.11,11.09 250.53,5.51 186.5,5.51 181.02,10.99 171.01,10.99 v2(167.62,14.38)
  BOTTOM w0.102: v2(167.62,14.38) 167.97,14.74 167.97,25.24 167.4,25.81 JELC.2
ELC_8051_C2D_P3: length 176.9
  TOP w0.107: v2(322.77,11.4) 322.63,11.53 UE1.10
  IN6 w0.102: v2(168.2,14.38) 171.36,11.22 181.12,11.22 186.6,5.74 250.43,5.74 256.05,11.36 279.64,11.36 281.22,9.79 289.82,9.79 292.05,12.02 304.12,12.02 305.44,10.7 322.07,10.7 v2(322.77,11.4)
  BOTTOM w0.102: JELC.3 v2(168.2,14.38)
ELC_EC#: length 313.6
  TOP w0.102: QE22.5 205.06,170.68 204.96,170.58 202.59,170.58 ; QE21.5 200.11,170.89 200.21,170.78 200.61,170.78 v2(201.05,170.34) 201.26,170.55 202.56,170.55 202.59,170.58 ; UE10.6 318.76,55.23 v2(319.1,54.9) ; 202.59,170.58 QE13.5
  IN4 w0.102: v2(201.05,170.34) 200.47,170.92 198.32,170.92 197.79,170.39 197.79,164.41 195.68,162.3 195.68,161.47 191.93,157.72 191.93,153.22 193.32,151.84 193.32,149.74 196.8,146.25 196.8,140.45 197.8,139.44 197.8,134.83 197.02,134.04 197.02,129.86 196.52,129.36 196.52,127.02 196.38,126.89 196.38,125.27 195.79,124.68 195.79,123.81 193.1,121.12 193.1,115.45 186.84,109.19 186.84,98.55 186.65,98.36 186.65,97.02 187.25,96.43 187.25,94.32 188.32,93.24 188.45,93.11 188.45,81.51 187.55,80.61 187.55,73.05 187.97,72.63 187.97,68.41 188.51,67.87 188.51,67.15 190.55,65.11 197.87,65.11 200.53,62.45 200.53,60.21 201.61,59.13 201.61,50.68 201.08,50.15 201.08,46.85 203.42,44.51 210.3,44.51 211.44,43.37 213.5,43.37 214.59,42.28 218.51,42.28 218.77,42.03 219.09,42.03 219.86,42.81 221.59,42.81 225.07,39.33 229.55,39.33 230.57,40.34 235.74,40.34 236.38,39.7 238.22,39.7 238.29,39.63 238.59,39.33 239.26,39.33 239.78,39.85 247.05,39.85 249.26,42.06 258.94,42.06 259.5,41.5 265.76,41.5 272.84,34.42 277.49,34.42 278.31,33.6 281.54,33.6 282.83,34.89 291.03,34.89 292.71,33.22 321.24,33.22 321.94,32.52 322.65,32.52 v2(323.07,32.94)
  BOTTOM w0.102: v2(323.07,32.94) 323.07,33.55 322.63,33.99 322.63,35.71 321.71,36.63 321.71,37.64 322.21,38.13 322.21,39.37 v1(322.09,39.49) 322.09,40.29 320.55,41.83 320.55,50.06 319.44,51.17 319.44,51.96 319.26,52.14 319.26,54.73 v2(319.1,54.9)
EN_0.6VSP: length 5.2
  BOTTOM w0.102: PR211.1 95.88,47.8 v1(96.36,48.28)
  BOTTOM w0.203: PU201.7 94.93,44.4 95.13,44.6
  BOTTOM w0.254: 95.13,44.6 95.13,44.75 95.82,45.43 PC214.1 PR209.1 PR211.1
EN_1.2V: length 2.8
  BOTTOM w0.203: PU201.8 95.05,44 95.6,44.55 PC213.1
  BOTTOM w0.254: PC213.1 PR208.2
EN_+1VALWP: length 3
  TOP w0.254: PU300.3 242.44,17.99 241.83,17.38 PR300.2 PC300.1
EN_INVPWR: length 297.9
  TOP w0.107: UE5.68 294.34,9.04 294.27,9.11 294.27,10.4 293.96,10.7 293.96,16.4 294.29,16.73 294.29,18.87 294.01,19.14 v2(294.01,19.81)
  IN4 w0.102: v2(294.01,19.81) 293.38,20.44 283.6,20.44 281.99,22.05 272.35,22.05 271.53,21.24 271.53,20.5 271.1,20.07 269.08,20.07 268.32,20.83 266.17,20.83 265.41,20.07 259.43,20.07 255.23,15.87 249.13,15.87 247.48,17.52 243.33,17.52 241.16,19.69 241.16,22.75 237.92,25.99 237.92,30.11 237.38,30.64 237.38,33.24 236.23,34.4 232.79,34.4 231.69,33.31 231,33.31 230.85,33.15 230.68,33.15 230.37,33.46 230.37,33.58 229.4,34.55 227.02,34.55 224.73,32.26 216.25,32.26 215.89,32.61 212.73,32.61 209.94,35.4 209.43,35.4 208.67,36.16 206.64,36.16 205.88,35.4 205.18,35.4 204.46,36.12 203.34,36.12 201.54,37.91 201.54,39.11 201.05,39.6 201.05,41 200.41,41.64 199.41,41.64 199.04,42.01 192.38,42.01 188.93,45.46 188.93,51.26 183.6,56.59 183.6,59.16 182.85,59.91 182.85,64.12 182.06,64.91 182.06,68.37 182.89,69.19 182.89,69.9 183.53,70.54 183.53,71.22 182.28,72.48 182.28,73.62 181.81,74.08 180.92,74.08 180.65,74.36 180.65,79.7 178.24,82.12 178.24,91.76 181.7,95.22 181.7,106.65 182.73,107.68 182.73,115.16 184.06,116.5 184.06,118.8 190.33,125.07 190.33,140.46 190.99,141.12 190.99,145.2 184.14,152.05 181.43,152.05 180.78,152.7 172.07,152.7 171.4,153.37 169.15,153.37 167.78,154.74 165.88,154.74 165.25,155.37 165.25,159.65 163.02,161.87 159.56,161.87 v2(159.5,161.93)
  BOTTOM w0.102: v2(159.5,161.93) 158.91,161.33 QV2.2
EN_WOL#: length 430.7
  TOP w0.102: v2(321.12,50.78) 321.12,59.99 v1(320.89,60.21) 320.56,60.55 318.46,60.55 318.26,60.35 UE10.14 ; v2(308.49,7) 309.11,7.63 RE79.2
  IN2 w0.102: v2(190.32,66.33) 189.54,66.33 183.96,71.91 178.61,71.91 178.01,72.51 178.01,78.34 186.72,87.05 186.72,92.18 184.88,94.02 184.88,101.75 185.98,102.84 185.98,111.24 188.46,113.73 188.46,121.19 192.56,125.29 192.56,127.06 194.48,128.98 194.98,128.98 196.47,130.47 196.47,131.66 199.19,134.38 199.19,139.72 209.38,149.91 209.38,151.67 211.39,153.68 214.31,153.68 215.16,154.53 223.42,154.53 224.95,156.06 224.97,156.06 225.24,156.34 227,156.34 227.29,156.05 231.54,156.05 231.61,155.99 238.42,155.99 239.99,154.41 242.05,154.41 243.02,155.39 264.14,155.39 264.78,156.03 264.78,158.53 266.34,160.09 266.34,166.99 267.06,167.71 267.06,169.37 v2(266.15,170.29)
  IN3 w0.102: v2(308.49,7) 308.99,7.5 315.05,7.5 315.35,7.21 327.16,7.21 337.29,17.34 337.29,47.24 334.08,50.45 321.45,50.45 v2(321.12,50.78)
  IN6 w0.102: v2(321.12,50.78) 321.05,50.72 317.27,50.72 316.45,51.53 308.11,51.53 307.73,51.91 298.8,51.91 293.82,46.93 277.27,46.93 276.42,47.78 273.15,47.78 272.23,48.7 261.22,48.7 259.9,47.38 249.98,47.38 248.63,48.72 241.41,48.72 240.84,48.15 237.65,48.15 236.88,47.38 233.8,47.38 231.74,49.44 227.6,49.44 227.15,49.9 213.67,49.9 211.64,51.92 211.64,54.36 209.08,56.93 209.08,63.89 207.31,65.65 191.61,65.65 190.93,66.33 v2(190.32,66.33)
  BOTTOM w0.102: v2(266.15,170.29) CL42.1 267.95,170.29 UL2.4
ENBKL: length 106
  TOP w0.102: v2(297.39,9.6) 297.54,9.45 UE5.76 ; v2(204.5,9.57) v1(204.5,8.88) 204.5,6.98 202.36,4.83 UV22.9
  IN4 w0.102: v2(297.39,9.6) 296.4,8.6 290.28,8.6 287.17,11.71 279.88,11.71 279.28,12.31 269.08,12.31 268.08,13.32 266.13,13.32 265.38,12.57 260.52,12.57 259.7,11.74 256.45,11.74 254.59,9.89 251.71,9.89 251.55,10.05 204.99,10.05 v2(204.5,9.57)
ENVDD: length 211.1
  TOP w0.102: UV22.7 193.61,5.48 192.76,6.33 186.5,6.33 v1(182.6,10.23) 181.4,11.43 179.43,11.43 v2(176.22,14.64)
  IN4 w0.102: v2(187.4,55.15) 187.08,55.47 187.08,56.48 185.21,58.35 185.21,66 184.26,66.94 184.26,68.3 184.49,68.53 184.49,69.24 185.13,69.88 185.13,71.89 184.88,72.14 184.88,81.49 185.94,82.55 185.94,92.07 184.13,93.87 184.13,99.4 184.33,99.6 184.33,110.82 185.36,111.85 185.36,115.44 186.81,116.89 186.81,119.29 191.93,124.4 191.93,128.1 192.61,128.79 192.61,129.91 193.14,130.44 193.14,131.2 191.93,132.41 191.93,135.8 193.65,137.53 193.65,144.95 184.95,153.65 182.09,153.65 180.44,155.3 180.05,155.3 179.49,155.86 176.48,155.86 176.22,155.61 173.18,155.61 171.9,156.89 168.11,156.89 166.85,158.15 166.85,163.27 v2(166.75,163.36)
  IN6 w0.102: v2(187.4,55.15) 184.55,52.3 184.55,45.63 180.67,41.75 v2(180.42,41.75)
  BOTTOM w0.102: v2(166.75,163.36) 166.75,163.77 RV600.2 166.06,163.93 165.8,164.19 UV17.4 ; v2(176.22,14.64) 175.97,14.89 175.97,23.01 172.63,26.35 172.63,35.62 174.22,37.22 179.78,37.22 180.6,38.04 180.6,41.57 v2(180.42,41.75)
EQA0: length 6.5
  BOTTOM w0.107: RM84.2 125.54,151.14 RM81.2 126.43,152.7 125.76,153.36 v1(125.76,153.63) 125.76,154.54 125.91,154.68 UM8.20
EQA1: length 5.1
  BOTTOM w0.107: UM8.19 126.3,154.18 126.11,153.99 126.11,153.52 126.88,152.75 v1(126.88,152.1) 126.88,151.63 RM76.2 RM70.2
EQB0: length 3.4
  BOTTOM w0.102: v1(137.48,160.06) 137.76,160.06 RM82.2
  BOTTOM w0.107: UM8.46 137.33,158.18 138,158.85 RM85.2 RM82.2
EQB1: length 5.4
  TOP w0.107: v2(137.74,160.75) 137.97,160.52 137.97,158.48 v1(137.74,158.25) v2(137.74,157.65)
  BOTTOM w0.107: RM23.2 RM26.2 v2(137.74,160.75) ; UM8.47 137.71,157.68 v2(137.74,157.65)
FB_1.0VS_VGAP: length 4
  BOTTOM w0.254: PU800.14 v1(239.07,41.5) 238.2,41.5 PR805.1 PR804.2 PC809.2
FB_3V: length 5.3
  BOTTOM w0.102: PR101.2 56.8,50.07 v1(58.11,50.07)
  BOTTOM w0.203: PU100.4 54.26,47.75 54.65,48.14 54.77,48.14 55.16,48.53 PR103.2
  BOTTOM w0.254: PR103.2 55.22,48.53 56.16,49.47 PR101.2
FB_5V: length 5
  BOTTOM w0.102: v1(50.39,50.36) 50.88,49.87 PR102.1
  BOTTOM w0.203: PR104.1 52.72,48.53 53.46,47.79 PU100.2
  BOTTOM w0.254: PR104.1 51.9,48.53 51.01,49.42 PR102.1
FB_+1.8VGS: length 11.7
  IN3 w0.254: v2(226.91,40.98) 224.84,40.98 223.92,41.89 v2(220.66,41.89)
  BOTTOM w0.102: v1(223.47,40.62) PR811.1
  BOTTOM w0.254: PR811.1 PC819.2 PR810.2 220.91,41.61 220.66,41.87 v2(220.66,41.89) ; v2(226.91,40.98) 226.95,40.93 PU802.14
FB_+1VALWP: length 4.3
  TOP w0.254: PU300.4 242.7,17.49 242.39,17.18 242.39,15.53 242.01,15.15 PR308.1 PR307.1
FB_VDDQ_SENSE: length 88.3
  TOP w0.254: v2(247.63,48) 247.63,48 247.85,48 248.49,47.36 248.49,42.7 245.12,39.32 245.12,38.5 245.47,38.14 v1(245.47,37.37) 245.47,36.73 244.28,35.53 v2(244.23,35.53) ; v2(261.08,85.01) 262.72,85.01 263.17,84.57 263.17,78.85 260.1,75.79 v2(260.1,74.33)
  IN1 w0.254: v2(260.1,74.33) 263.93,74.33 268.65,69.61 268.65,53.58 264.25,49.18 248.8,49.18 v2(247.63,48)
  BOTTOM w0.2: UG9.E52 256.32,83.55 256.92,82.95 258.37,82.95 260.43,85.01 v2(261.08,85.01)
  BOTTOM w0.203: PU8200.12 244.33,35.43 v2(244.23,35.53) 244.23,36.28 PR8209.1
FBA_CLK0: length 35.3
  TOP w0.102: v2(274.34,99.5) 274.69,99.5 274.87,99.68 274.87,100.13 RG102.1
  IN6 w0.102: 249.88,98.84 v2(249.47,99.25)
  IN6 w0.107: 249.88,98.84 250.31,98.84 250.65,98.5 253.18,98.5 253.98,99.29 255.25,99.29 255.47,99.51 257.16,99.51 257.26,99.41 257.26,99.25 257.5,99 257.94,99 258.16,99.22 258.16,99.39 258.27,99.49 263.07,99.49 263.3,99.72 272.57,99.72 272.93,100.09 274.9,100.09 275.02,99.96 275.02,99.61 274.92,99.5 v2(274.34,99.5) 274.91,98.93 274.91,98.78 275.15,98.54 275.31,98.54 276.53,97.32 276.53,96.99 276.36,96.81 276.36,96.57 v2(276.15,96.36)
  BOTTOM w0.102: UG9.AG45 v2(249.47,99.25)
  BOTTOM w0.119: v2(276.15,96.36) 276.15,96.09 276.28,95.96 UG1.J12
FBA_CLK0#: length 35.1
  TOP w0.102: v2(275.64,99.5) 275.29,99.5 275.15,99.65
  TOP w0.119: 275.15,99.65 275.15,100.22 RG523.1
  IN6 w0.107: v2(276.15,95.56) 276.55,95.96 276.55,96.73 276.73,96.91 276.73,97.4 275.63,98.5 275.39,98.74 275.23,98.74 275.11,98.86 275.11,98.97 v2(275.64,99.5) 275.46,99.5 275.22,99.74 275.22,100.04 274.98,100.28 272.85,100.28 272.49,99.92 263.22,99.92 262.99,99.69 258.19,99.69 257.97,99.47 257.97,99.3 257.86,99.2 257.59,99.2 257.45,99.33 257.45,99.49 257.24,99.71 255.39,99.71 255.17,99.48 253.89,99.48 253.1,98.69 250.73,98.69 v2(250.17,99.25)
  BOTTOM w0.102: UG9.AG46 v2(250.17,99.25)
  BOTTOM w0.119: v2(276.15,95.56) UG1.J11
FBA_CLK1: length 39.1
  TOP w0.119: v2(273.45,104.41) 273.57,104.41 273.93,104.05 273.93,103.79 RG103.1
  IN1 w0.102: 254.45,101.89 254.37,101.89 253.86,101.38 253.69,101.38 253.25,100.93 250.29,100.93 250.1,101.12 250.1,101.27 v2(250.17,101.35)
  IN1 w0.107: 254.45,101.89 259.39,101.89 259.39,101.89 259.47,101.89 261.4,103.82 262.93,103.82 263.03,103.92 263.03,104.59 263.26,104.81 263.74,104.81 263.96,104.59 263.96,103.92 264.07,103.82 264.44,103.82 264.55,103.92 264.55,104.52 264.77,104.74 265.25,104.74 265.47,104.52 265.47,103.92 265.58,103.82 265.9,103.82 266.01,103.92 266.01,104.52 266.23,104.74 266.71,104.74 266.93,104.52 266.93,103.92 267.04,103.82 273.8,103.82 274.09,104.11 274.09,104.31 273.98,104.41 v2(273.45,104.41) 273.84,104.81 274.62,104.81 274.95,105.13 275.89,105.13 276.54,105.79 276.54,106.82 276.35,107.01 276.35,107.16 v2(276.15,107.36)
  BOTTOM w0.102: v2(250.17,101.35) 250.11,101.29 250.11,101.07 250.19,100.99 250.41,100.99 UG9.AK46
  BOTTOM w0.119: UG2.J12 v2(276.15,107.36)
FBA_CLK1#: length 39.2
  TOP w0.119: v2(274.75,104.41) 274.71,104.41 274.24,103.94 274.24,103.77 RG524.1
  IN1 w0.102: v2(249.47,101.35) 250.08,100.74 253.33,100.74 253.77,101.18 253.94,101.18 254.45,101.7
  IN1 w0.107: 254.45,101.7 259.31,101.7 259.56,101.7 261.48,103.62 263.01,103.62 263.12,103.74 263.23,103.84 263.23,104.5 263.34,104.61 263.66,104.61 263.76,104.5 263.76,103.84 263.98,103.62 264.52,103.62 264.74,103.84 264.74,104.44 264.85,104.55 265.17,104.55 265.28,104.44 265.28,103.84 265.39,103.73 265.5,103.62 265.98,103.62 266.2,103.84 266.2,104.44 266.31,104.55 266.63,104.55 266.74,104.44 266.74,103.84 266.96,103.62 273.88,103.62 274.5,104.24 274.57,104.24 v2(274.75,104.41) 274.75,104.66 275.03,104.93 275.97,104.93 276.74,105.71 276.74,106.91 276.55,107.09 276.55,107.52 276.52,107.55 276.17,108.15 v2(276.15,108.16)
  BOTTOM w0.102: UG9.AK45 v2(249.47,101.35)
  BOTTOM w0.119: UG2.J11 v2(276.15,108.16)
FBA_CMD0: length 34.9
  BOTTOM w0.102: 260.54,88.05 260.54,92.33 260.75,92.54 260.75,93.17 259.92,94 258.39,94 258.27,93.88 255,93.88 254.84,93.72 254.45,93.72 254.12,94.05 UG9.Y51
  BOTTOM w0.185: UG1.G3 277.75,88.36 277.75,86.97 277.95,86.77 277.95,86.46 277.12,85.63 276.2,85.63 275.42,84.84 269.16,84.84 268.77,84.45 264.14,84.45 260.54,88.05
FBA_CMD1: length 32.6
  TOP w0.102: v2(276.95,88.36) 276.95,87.88 RG47.2
  BOTTOM w0.102: UG9.Y52 254.75,94.13 257.94,94.13 258.16,94.35 259.87,94.35 260.95,93.27 260.95,92.28 260.84,92.17 260.84,90.89 261.26,90.47 ; UG1.J3 v2(276.95,88.36)
  BOTTOM w0.185: 261.26,90.47 261.26,89.24 261.76,88.74 261.76,88.04 264.52,85.28 275.32,85.28 276.14,86.09 276.68,86.09 276.97,86.39 276.97,86.74 276.95,86.76 276.95,86.95 276.95,86.96 v2(276.95,88.36)
FBA_CMD2: length 32.2
  TOP w0.102: v2(276.15,87.56) 275.58,87.56 RG54.1
  BOTTOM w0.102: 261.7,90.54 261.17,91.07 261.17,91.9 261.15,91.91 261.15,93.47 259.97,94.65 257.93,94.65 257.68,94.4 252.92,94.4 UG9.Y49 ; v2(276.15,87.56) 276.4,87.81 276.4,87.81 UG1.J2
  BOTTOM w0.185: v2(276.15,87.56) 276.15,86.76 276.05,86.66 276.05,86.46 275.41,85.82 265.26,85.82 261.7,89.38 261.7,90.54
FBA_CMD3: length 27.9
  BOTTOM w0.102: UG9.AA52 257.49,94.75 257.71,94.97 259.98,94.97 261.45,93.5 261.45,92.11 261.44,92.1 261.44,91.31
  BOTTOM w0.185: 261.44,91.31 262.82,89.93 263.55,89.93 267.15,86.33 274.72,86.33 275.35,86.96 275.35,88.36 UG1.L3
FBA_CMD4: length 26.2
  BOTTOM w0.102: UG9.AA51 254.17,94.75 254.5,95.08 254.82,95.08 254.88,95.02 257.24,95.02 257.58,95.36 259.88,95.36 261.76,93.48 261.76,91.72
  BOTTOM w0.185: 261.76,91.72 262.52,90.96 263.98,90.96 265.34,89.6 268.84,89.6 270.01,90.77 275.34,90.77 UG1.K5
FBA_CMD5: length 27.8
  BOTTOM w0.102: UG9.AA50 253.42,94.75 253.77,95.1 254.17,95.1 254.37,95.3 256.98,95.3 257.36,95.68 259.86,95.68 262.07,93.47 262.07,92.51
  BOTTOM w0.185: UG1.K4 276.15,89.96 276.15,90.51 275.6,91.06 269.85,91.06 268.93,90.14 265.95,90.14 264.16,91.93 262.65,91.93 262.07,92.51
FBA_CMD6: length 26.8
  BOTTOM w0.102: 262.44,93.5 259.9,96.04 257.22,96.04 256.73,95.55 254.37,95.55 254.12,95.8 253.62,95.8 UG9.AC50
  BOTTOM w0.185: UG1.J5 276.55,90.71 275.91,91.35 269.54,91.35 268.9,90.72 266.7,90.72 263.92,93.5 262.44,93.5
FBA_CMD7: length 27.4
  BOTTOM w0.102: 262.24,94.04 259.94,96.34 256.98,96.34 256.44,95.8 254.47,95.8 254.12,96.15 UG9.AC51
  BOTTOM w0.185: 262.24,94.04 264.27,94.04 266.99,91.32 269.01,91.32 269.32,91.63 276.33,91.63 276.95,91.01 276.95,89.96 UG1.J4
FBA_CMD8: length 25.9
  BOTTOM w0.102: 262.07,94.58 260,96.65 256.79,96.65 256.29,96.15 UG9.AC52
  BOTTOM w0.185: UG1.H5 277.35,91.06 276.49,91.92 267.28,91.92 264.61,94.58 262.07,94.58
FBA_CMD9: length 29.7
  BOTTOM w0.102: UG9.AC49 252.92,96.5 256.17,96.5 256.63,96.96 260.22,96.96 261.71,95.47
  BOTTOM w0.185: UG1.H4 277.75,89.96 277.75,91.16 276.7,92.21 267.87,92.21 264.61,95.47 261.71,95.47
FBA_CMD10: length 28.5
  BOTTOM w0.102: UG9.AD52 255.99,96.85 256.46,97.32 260.32,97.32 261.58,96.07
  BOTTOM w0.185: UG1.G12 277.75,95.56 277.75,93.26 276.98,92.5 268.35,92.5 264.78,96.07 261.58,96.07
FBA_CMD11: length 26.8
  BOTTOM w0.102: 261.56,96.61 260.59,97.57 256.24,97.57 255.81,97.14 254.9,97.14 254.86,97.18 254.5,97.18 254.17,96.85 UG9.AD51
  BOTTOM w0.185: 261.56,96.61 265,96.61 268.83,92.78 276.62,92.78 277.35,93.51 UG1.H10
FBA_CMD12: length 28.4
  BOTTOM w0.102: UG9.AD50 253.42,96.85 253.77,97.2 254.17,97.2 254.37,97.4 255.59,97.4 256.06,97.87 260.88,97.87 261.31,97.44
  BOTTOM w0.185: UG1.H11 276.95,94.76 276.95,93.61 276.41,93.07 269.05,93.07 267.69,94.43 267.69,95 265.25,97.44 261.31,97.44
FBA_CMD13: length 27.6
  BOTTOM w0.102: UG9.AF50 253.62,97.9 254.12,97.9 254.38,97.64 255.5,97.64 256.01,98.15 262.82,98.15
  BOTTOM w0.185: 262.82,98.15 265.36,98.15 267.98,95.54 267.98,94.58 269.2,93.36 275.8,93.36 276.05,93.61 276.05,94.01 276.15,94.11 276.15,94.76 UG1.K11
FBA_CMD14: length 26
  BOTTOM w0.102: 261.34,99.09 260.82,98.57 256.08,98.57 255.42,97.9 254.47,97.9 254.12,98.25 UG9.AF51
  BOTTOM w0.185: UG1.K10 275.75,93.96 275.45,93.66 269.45,93.66 268.33,94.78 268.33,96.2 265.44,99.09 261.34,99.09
FBA_CMD15: length 26.9
  BOTTOM w0.102: 261.45,99.92 260.45,98.92 256.11,98.92 255.73,98.55 255.73,98.53 255.45,98.25 UG9.AF52
  BOTTOM w0.185: UG1.L12 275.35,95.56 275.35,94.21 275.1,93.96 269.8,93.96 268.61,95.15 268.61,96.87 265.57,99.92 261.45,99.92
FBA_CMD16: length 40.2
  BOTTOM w0.102: UG9.AN50 253.27,103.4 253.37,103.5 254.17,103.5 254.37,103.7 254.95,103.7 255,103.65 257.24,103.65 257.93,104.34 257.93,107.4
  BOTTOM w0.185: UG2.L3 277.72,115.39 277.72,116.73 277.85,116.86 277.85,117.41 275.47,119.79 267.73,119.79 265.95,118.02 263.28,118.02 259.53,114.27 259.53,113.13 259.09,112.68 259.09,108.56 257.93,107.4
FBA_CMD17: length 38.4
  TOP w0.102: v2(276.95,115.36) 276.98,115.34 RG48.2
  BOTTOM w0.102: UG9.AN51 254.17,103.15 254.52,103.5 254.82,103.5 254.92,103.4 257.39,103.4 258.35,104.35 258.35,107.15 ; UG2.J3 v2(276.95,115.36)
  BOTTOM w0.185: v2(276.95,115.36) 276.95,117.49 275.44,119 268.08,119 266.26,117.19 263.22,117.19 260.43,114.41 260.43,113.11 259.58,112.26 259.58,108.39 258.35,107.15
FBA_CMD18: length 34.8
  TOP w0.102: RG53.1 276.12,116.19 v2(276.15,116.16)
  BOTTOM w0.102: v2(276.15,116.16) 276.37,115.94 276.37,115.94 UG2.J2 ; UG9.AN52 257.51,103.15 258.63,104.27 258.63,106.77 ; 266.75,116.44 266.78,116.44
  BOTTOM w0.185: 266.78,116.44 268.58,118.23 275.13,118.23 276.05,117.31 276.05,117.06 276.15,116.96 v2(276.15,116.16) ; 258.63,106.77 260.08,108.22 260.08,112.06 261.39,113.37 261.39,114.34 263.48,116.44 266.75,116.44
FBA_CMD19: length 34.9
  BOTTOM w0.102: UG9.AM49 252.92,102.8 257.63,102.8 258.96,104.13 258.96,106.49
  BOTTOM w0.185: UG2.G3 275.35,115.36 275.35,116.74 275,117.09 275,117.15 274.68,117.46 269.08,117.46 267.28,115.67 264.39,115.67 260.54,111.82 260.54,108.08 258.96,106.49
FBA_CMD20: length 30.6
  BOTTOM w0.102: 259.31,106.13 259.31,104.16 259.12,103.98 259.12,103.78 257.79,102.45 UG9.AM52
  BOTTOM w0.185: UG2.H5 275.32,112.94 269.98,112.94 268.02,114.9 264.47,114.9 261.14,111.57 261.14,107.96 259.31,106.13
FBA_CMD21: length 32
  BOTTOM w0.102: UG9.AM51 254.12,102.45 254.45,102.12 257.88,102.12 259.42,103.66 259.42,103.81 259.65,104.04 259.65,105.93
  BOTTOM w0.185: UG2.H4 276.15,113.76 276.15,113.21 275.59,112.65 269.76,112.65 268.29,114.12 265.23,114.12 261.77,110.66 261.77,108.05 259.65,105.93
FBA_CMD22: length 31.4
  BOTTOM w0.102: 259.99,105.67 259.99,103.97 259.75,103.73 259.75,103.52 258.11,101.88 254.34,101.88 254.12,102.1 253.84,102.1 253.49,102.45 UG9.AM50
  BOTTOM w0.185: UG2.J5 276.55,112.96 275.95,112.36 269.55,112.36 268.56,113.35 266.05,113.35 262.47,109.78 262.47,108.15 259.99,105.67
FBA_CMD23: length 32.2
  BOTTOM w0.102: UG9.AK50 253.42,101.05 253.77,101.4 254.17,101.4 254.41,101.64 258.27,101.64 260.08,103.45 260.33,103.7 260.33,105.29
  BOTTOM w0.185: UG2.J4 276.95,113.76 276.95,112.66 276.36,112.07 269.34,112.07 268.83,112.58 266.36,112.58 264.06,110.29 264.06,109.02 260.33,105.29
FBA_CMD24: length 30.4
  BOTTOM w0.102: UG9.AK51 254.17,101.05 254.52,101.4 258.47,101.4 260.65,103.58 260.65,104.94
  BOTTOM w0.185: 260.65,104.94 262.42,106.71 262.77,106.71 264.83,108.77 264.83,109.92 266.7,111.79 276.57,111.79 277.35,112.56 UG2.K5
FBA_CMD25: length 31.1
  BOTTOM w0.102: 261.01,104.58 261.01,103.48 260.87,103.34 258.58,101.05 UG9.AK52
  BOTTOM w0.185: 261.01,104.58 262.38,105.94 263.08,105.94 265.61,108.47 265.61,109.8 267.31,111.5 276.84,111.5 277.75,112.41 277.75,113.76 UG2.K4
FBA_CMD26: length 34.5
  BOTTOM w0.102: 261.44,104.26 261.44,103.44 261.21,103.21 258.7,100.7 252.92,100.7 UG9.AJ49
  BOTTOM w0.185: 261.44,104.26 262.35,105.17 263.71,105.17 266.77,108.24 266.77,110.43 267.56,111.21 276.8,111.21 277.75,110.26 277.75,108.16 UG2.L12
FBA_CMD27: length 29.8
  BOTTOM w0.102: UG9.AJ52 254.77,100.45 258.88,100.45 261.91,103.48 261.91,103.49
  BOTTOM w0.185: UG2.K10 277.35,110.16 276.6,110.91 267.93,110.91 267.38,110.35 267.38,107.63 264.14,104.4 262.82,104.4 261.91,103.49
FBA_CMD28: length 31.1
  BOTTOM w0.102: UG9.AJ51 254.12,100.35 254.47,100 254.83,100 254.98,100.15 259.19,100.15 262.67,103.63 262.82,103.63
  BOTTOM w0.185: UG2.K11 276.95,108.96 276.95,110.11 276.44,110.62 268.4,110.62 267.85,110.08 267.85,107.34 264.14,103.63 262.82,103.63
FBA_CMD29: length 31
  BOTTOM w0.102: UG9.AJ50 253.5,100.35 253.85,100 254.12,100 254.37,99.75 254.97,99.75 255.08,99.86 259.44,99.86 262.44,102.86 262.82,102.86
  BOTTOM w0.185: 262.82,102.86 264.13,102.86 268.23,106.96 268.23,109.9 268.67,110.33 275.78,110.33 276.05,110.06 276.05,109.66 276.17,109.54 276.17,108.98 UG2.H11
FBA_CMD30: length 29.5
  BOTTOM w0.102: UG9.AG50 253.51,98.95 253.86,99.3 254.17,99.3 254.37,99.5 255.15,99.5 255.27,99.63 256.43,99.63 256.56,99.5 259.55,99.5 262.14,102.09
  BOTTOM w0.185: 262.14,102.09 264.43,102.09 268.68,106.33 268.68,109.49 269.23,110.05 275.4,110.05 275.75,109.7 UG2.H10
FBA_CMD31: length 29.9
  BOTTOM w0.102: 262.15,101.31 260.06,99.22 256.45,99.22 256.25,99.42 255.37,99.42 255.23,99.28 254.5,99.28 254.17,98.95 UG9.AG51
  BOTTOM w0.185: UG2.G12 275.35,108.16 275.35,109.51 275.1,109.76 269.7,109.76 269.19,109.25 269.19,106.07 264.43,101.31 262.15,101.31
FBA_D0: length 18.9
  IN6 w0.102: v2(256.97,92.65) 257.39,92.23 262.71,92.23 262.77,92.17
  IN6 w0.13: v2(269.75,89.16) 269.58,89 265.95,89 262.77,92.17
  BOTTOM w0.102: UG9.U51 254.12,91.95 254.46,91.61 256.63,91.61 257.02,92 257.02,92.6 v2(256.97,92.65) ; UG1.U4 269.98,89.39 v2(269.75,89.16)
FBA_D1: length 20.3
  IN6 w0.102: v2(252.97,91.55) 254.62,91.55 254.87,91.3 261.67,91.3 262.77,90.2
  IN6 w0.13: 262.77,90.2 265.41,87.56 v2(269.75,87.56)
  BOTTOM w0.102: v2(252.97,91.55) 252.92,91.6 252.45,91.6 252.1,91.95 UG9.U48 ; UG1.U2 269.96,87.77 v2(269.75,87.56)
FBA_D2: length 21.1
  IN6 w0.102: 258.49,93.57 v2(257.57,92.65)
  IN6 w0.13: 258.49,93.57 262.45,93.57 266.45,89.57 270.14,89.57 v2(270.55,89.16)
  BOTTOM w0.102: UG1.T4 270.95,89.56 v2(270.55,89.16) ; UG9.U50 253.48,91.95 253.83,91.6 254.12,91.6 254.34,91.38 256.8,91.38 257.44,92.02 257.57,92.15 v2(257.57,92.65)
FBA_D3: length 23.8
  IN6 w0.102: v2(255.62,92.3) 255.63,92.31 255.63,92.82 256.69,93.89
  IN6 w0.13: v2(270.55,88.36) 270.94,88.76 270.94,90.16 270.71,90.39 269.63,90.39 269.44,90.2 267.53,90.2 263.85,93.89 256.69,93.89
  BOTTOM w0.102: v2(255.62,92.3) 255.53,92.21 254.96,92.21 254.87,92.3 252.92,92.3 UG9.U49 ; v2(270.55,88.36) 270.95,87.96 UG1.T2
FBA_D4: length 26.4
  IN6 w0.102: 261.44,89.95 262.77,88.61 ; v2(258.57,90.55) 259.17,89.95
  IN6 w0.13: 262.77,88.61 265.85,85.54 273.23,85.54 274.15,86.46 274.15,88.76 v2(273.75,89.16) ; 259.17,89.95 261.44,89.95
  BOTTOM w0.102: UG1.N4 v2(273.75,89.16) ; v2(258.57,90.55) 258.19,90.93 254.55,90.93 254.17,90.55 UG9.R51
FBA_D5: length 22.7
  IN6 w0.102: 262.77,89.41 261.34,90.84 259.51,90.84 v2(259.22,90.55)
  IN6 w0.13: v2(272.95,87.56) 272.54,87.16 268.76,87.16 268.6,87 265.18,87 262.77,89.41
  BOTTOM w0.102: v2(259.22,90.55) 259.22,90.6 258.68,91.14 254.41,91.14 254.17,90.9 253.77,90.9 253.42,90.55 UG9.R50 ; UG1.N2 v2(272.95,87.56)
FBA_D6: length 31.7
  IN6 w0.102: 251.28,90.44 v2(250.87,90.85) ; 262.77,87.82 261.09,89.5
  IN6 w0.13: 261.09,89.5 258.38,89.5 257.87,90.01 254.96,90.01 254.53,90.44 251.28,90.44 ; v2(274.55,89.16) 275.01,88.7 275.01,85.56 274.3,84.86 265.74,84.86 262.77,87.82
  BOTTOM w0.102: UG9.R47 v2(250.87,90.85) ; v2(274.55,89.16) 274.33,89.38 274.33,89.38 UG1.M4
FBA_D7: length 26
  IN6 w0.102: 262.77,91.28 262.32,91.73 255.01,91.73 254.63,92.11 251.23,92.11 v2(250.77,91.65)
  IN6 w0.13: 262.77,91.28 265.81,88.24 268.44,88.24 268.72,87.96 273.35,87.96 v2(273.75,87.56)
  BOTTOM w0.102: UG9.U46 v2(250.77,91.65) ; UG1.M2 274.15,87.96 v2(273.75,87.56)
FBA_D8: length 23.5
  IN1 w0.13: v2(269.5,95.81) 269.1,95.81 268.5,96.42 262.64,96.42 262.2,95.98 258.71,95.98 257.77,95.04 254.48,95.04 253.72,94.27 250.08,94.27 249.81,94 249.81,93.33 v2(250.18,92.96)
  BOTTOM w0.102: v2(250.18,92.96) 250.47,92.67 UG9.V46 ; UG1.U11 v2(269.5,95.81)
FBA_D9: length 23.3
  IN1 w0.13: v2(249.37,93.64) 249.37,94.13 249.84,94.61 253.45,94.61 254.51,95.67 257.51,95.67 258.33,96.49 261.76,96.49 262.43,97.16 v2(269.75,97.16)
  BOTTOM w0.102: UG1.U13 v2(269.75,97.16) ; UG9.Y45 v2(249.37,93.64)
FBA_D10: length 21.3
  IN1 w0.13: v2(270.55,95.56) 270.33,95.35 268.81,95.35 268.3,95.85 262.77,95.85 262.2,95.28 258.79,95.28 257.9,94.39 254.61,94.39 254.17,93.95 251.88,93.95 v2(251.57,93.64)
  BOTTOM w0.102: UG1.T11 v2(270.55,95.56) ; UG9.Y47 v2(251.57,93.64)
FBA_D11: length 26.1
  IN1 w0.13: v2(270.55,97.16) 270.95,96.76 270.95,94.46 270.82,94.33 268.27,94.33 267.76,94.84 259.22,94.84 258.19,93.81 254.75,93.81 253.48,92.54 251.42,92.54 251.15,92.81 251.15,93.33 v2(250.8,93.69)
  BOTTOM w0.102: UG9.Y46 250.47,94.02 v2(250.8,93.69) ; UG1.T13 v2(270.55,97.16)
FBA_D12: length 23.1
  IN1 w0.13: v2(272.95,95.56) 272.95,95.36 272.55,94.96 272.55,94.46 271.21,93.12 268.26,93.12 267.82,93.57 259.85,93.57 259.48,93.2 259.48,92.74 v2(259.51,92.71)
  BOTTOM w0.102: v2(259.51,92.71) 258.91,93.31 254.48,93.31 254.17,93 253.84,93 253.49,92.65 UG9.V50 ; UG1.N11 v2(272.95,95.56)
FBA_D13: length 26.9
  IN1 w0.13: v2(250.77,93.05) 250.87,92.95 250.87,92.39 251.22,92.04 253.85,92.04 254.92,93.11 258.32,93.11 259.47,94.27 267.73,94.27 268.17,93.82 271.13,93.82 271.75,94.44 271.75,94.96 271.95,95.16 272.35,95.16 272.55,95.36 272.55,95.96 v2(272.95,96.36)
  BOTTOM w0.102: UG1.N13 v2(272.95,96.36) ; UG9.V47 v2(250.77,93.05)
FBA_D14: length 22.9
  IN1 w0.13: v2(256.47,92.25) 256.55,92.17 258.58,92.17 258.77,91.98 260.83,91.98 261.1,91.7 271.39,91.7 274.15,94.46 UG1.M11 v2(273.75,95.56)
  BOTTOM w0.102: v2(256.47,92.25) 256.1,91.88 254.74,91.88 UG9.U52 ; UG1.M11 v2(273.75,95.56)
FBA_D15: length 24.2
  IN1 w0.13: v2(258.77,92.7) 259.17,92.3 262.73,92.3 262.77,92.34 271.2,92.34 273.35,94.49 273.35,96.76 v2(273.75,97.16)
  BOTTOM w0.102: v2(258.77,92.7) 258.41,93.06 254.58,93.06 254.17,92.65 UG9.V51 ; v2(273.75,97.16) UG1.M13
FBA_D16: length 46
  IN1 w0.13: v2(284.01,94.87) 285.33,96.19 285.33,99.46 281.95,102.84 261.63,102.84 259.95,101.16 255.07,101.16 254.35,100.44 249.16,100.44 248.77,100.05 v2(248.77,100)
  BOTTOM w0.102: v2(284.01,94.87) 283.67,95.21 283,95.21 UG1.A11 ; UG9.AJ44 248.77,100.05 v2(248.77,100)
FBA_D17: length 35.7
  IN1 w0.13: v2(283.3,97.16) 282.98,97.48 282.98,98.69 280.52,101.15 262.54,101.15 262.5,101.2 260.9,99.6 256.83,99.6 255.81,98.58 255.3,98.58 v2(255.17,98.7)
  BOTTOM w0.102: v2(283.3,97.16) 283.3,97.11 UG1.A13 ; v2(255.17,98.7) 255.08,98.61 252.21,98.61 UG9.AG48
FBA_D18: length 45.9
  IN1 w0.13: v2(282.55,94.76) 283.32,95.53 283.59,95.53 284.43,96.37 284.43,99.57 281.71,102.28 262.08,102.28 260.36,100.55 255.35,100.55 254.76,99.96 253.01,99.96 252.16,99.11 251.92,99.11 251.63,98.82 249.3,98.82 249.08,99.04 249.08,99.66 v2(249.47,100.05)
  BOTTOM w0.102: UG9.AJ45 v2(249.47,100.05) ; UG1.B11 v2(282.55,94.76)
FBA_D19: length 37.8
  IN1 w0.13: v2(282.55,96.36) 282.8,96.61 283.47,96.61 283.83,96.97 283.83,99.18 281.3,101.72 262.41,101.72 260.77,100.07 255.75,100.07 254.83,99.15 253.02,99.15 252.92,99.25 v2(252.87,99.25)
  BOTTOM w0.102: UG1.B13 v2(282.55,96.36) ; v2(252.87,99.25) UG9.AG49
FBA_D20: length 34.5
  IN1 w0.13: v2(280.15,95.56) 279.74,95.16 279.51,95.16 279.19,95.16 279.18,95.16 278.86,95.16 277.98,96.04 277.98,96.13 275.72,98.39 269.01,98.39 268.6,97.98 262.42,97.98 261.63,97.19 258.09,97.19 257.15,96.25 251.17,96.25 v2(250.17,97.25)
  BOTTOM w0.102: UG9.AF46 250.47,97.55 v2(250.17,97.25) ; v2(280.15,95.56) UG1.E11
FBA_D21: length 34.3
  IN1 w0.13: v2(279.35,97.16) 279.35,97.19 279.75,97.6 279.75,99.08 278.24,100.59 262.62,100.59 260.97,98.94 257.35,98.94 256.42,98.01 254.45,98.01 253.86,98.6 252.36,98.6 252.11,98.35 251.11,98.35 250.87,98.11 v2(250.87,97.95)
  BOTTOM w0.102: UG1.E13 279.75,96.76 v2(279.35,97.16) ; v2(250.87,97.95) UG9.AF47
FBA_D22: length 33.2
  IN1 w0.13: v2(252.06,97.87) 252.14,97.95 253.72,97.95 254.24,97.43 256.61,97.43 257.51,98.33 261.51,98.33 263.2,100.03 277.45,100.03 277.99,99.49 277.99,97.96 278.39,97.57 278.71,97.57 278.95,97.33 278.95,95.96 v2(279.35,95.56)
  BOTTOM w0.102: v2(279.35,95.56) UG1.F11 ; v2(252.06,97.87) UG9.AF48
FBA_D23: length 30.8
  IN1 w0.13: v2(278.55,97.16) 278.35,97.16 277.92,97.6 277.22,97.6 276.81,98.01 276.81,98.47 276.61,98.66 276.25,98.66 275.95,98.95 268.78,98.95 268.44,98.62 262.3,98.62 261.41,97.73 257.68,97.73 256.78,96.83 253.32,96.83 253.22,96.73 251.29,96.73 v2(250.87,97.15)
  BOTTOM w0.102: UG1.F13 v2(278.55,97.16) ; v2(250.87,97.15) UG9.AD47
FBA_D24: length 35.9
  IN6 w0.102: v2(252.87,97.15) 253.03,96.99 253.58,96.99 254.37,97.78
  IN6 w0.13: v2(283.35,89.96) 283.35,90.74 280.71,93.38 277.71,93.38 276.78,94.31 269.58,94.31 265.68,98.21 262.87,98.21 262.44,97.78 254.37,97.78
  BOTTOM w0.102: UG9.AD49 v2(252.87,97.15) ; UG1.A4 v2(283.35,89.96)
FBA_D25: length 39.6
  IN6 w0.102: v2(252.07,97.23) 252.09,97.25 252.27,97.25 253.03,98.01 253.62,98.01 253.88,98.27 ; 262.77,98.77 262.52,98.77
  IN6 w0.13: 262.52,98.77 262.01,98.27 253.88,98.27 ; v2(283.35,88.36) 283.8,88.81 283.8,91.26 280.75,94.31 278.35,94.31 277.5,95.16 269.59,95.16 265.98,98.77 262.77,98.77
  BOTTOM w0.102: v2(283.35,88.36) 282.95,87.96 UG1.A2 ; v2(252.07,97.23) UG9.AD48
FBA_D26: length 37
  IN6 w0.102: 254.73,97.32 254.02,96.61 251.65,96.61 250.89,95.85 v2(250.77,95.85)
  IN6 w0.13: v2(282.55,89.96) 282.15,90.36 282.15,90.97 280.34,92.78 276.93,92.78 275.98,93.73 269.37,93.73 265.53,97.57 262.92,97.57 262.67,97.32 254.73,97.32
  BOTTOM w0.102: v2(250.77,95.85) UG9.AC46 ; v2(282.55,89.96) 282.31,89.72 282.31,89.72 UG1.B4
FBA_D27: length 36.7
  IN6 w0.102: 254.93,96.76 254.43,96.26 251.88,96.26 v2(251.47,95.85)
  IN6 w0.13: 254.93,96.76 265.54,96.76 269.12,93.19 275.44,93.19 276.41,92.22 279.55,92.22 281.2,90.57 281.2,89.93 281.57,89.56 281.95,89.56 282.15,89.36 282.15,88.76 v2(282.55,88.36)
  BOTTOM w0.102: v2(251.47,95.85) UG9.AC47 ; UG1.B2 282.15,87.96 v2(282.55,88.36)
FBA_D28: length 34.8
  IN6 w0.102: 255.16,96.15 253.69,94.68 251.24,94.68 v2(250.87,95.05)
  IN6 w0.13: v2(279.35,89.16) UG1.E4 279.75,91.06 279.1,91.71 275.97,91.71 275.04,92.64 268.87,92.64 265.31,96.2 262.42,96.2 262.37,96.15 255.16,96.15
  BOTTOM w0.102: UG1.E4 279.59,89.4 v2(279.35,89.16) ; UG9.AA47 v2(250.87,95.05)
FBA_D29: length 35.4
  IN6 w0.102: v2(250.17,95.05) 250.17,94.87 250.65,94.39 254.48,94.39 255.68,95.59
  IN6 w0.13: v2(279.35,88.36) 278.95,88.76 278.95,91.01 278.78,91.18 275.63,91.18 274.77,92.04 268.68,92.04 265.08,95.64 262.3,95.64 262.25,95.59 255.68,95.59
  BOTTOM w0.102: UG1.E2 279.6,88.11 279.6,88.11 v2(279.35,88.36) ; UG9.AA46 v2(250.17,95.05)
FBA_D30: length 33.3
  IN6 w0.102: 255.94,95.02 254.88,93.96 251.86,93.96 251.71,94.11 250.06,94.11 249.47,94.7 v2(249.47,95.05)
  IN6 w0.13: v2(278.55,89.96) 278.09,90.42 275.59,90.42 274.58,91.43 268.49,91.43 264.85,95.08 262.18,95.08 262.13,95.02 255.94,95.02
  BOTTOM w0.102: UG1.F4 v2(278.55,89.96) ; UG9.AA45 v2(249.47,95.05)
FBA_D31: length 35.4
  IN6 w0.102: 256.41,94.6 254.35,92.54 249.36,92.54 249.06,92.84 249.06,93.39 248.77,93.68 v2(248.77,93.75)
  IN6 w0.13: v2(278.55,88.36) 278.15,88.76 278.15,89.36 277.7,89.81 275.39,89.81 274.39,90.81 268.32,90.81 264.68,94.46 262.2,94.46 262.06,94.6 256.41,94.6
  BOTTOM w0.102: UG1.F2 278.76,88.15 278.76,88.15 v2(278.55,88.36) ; UG9.Y44 v2(248.77,93.75)
FBA_D32: length 20.2
  IN1 w0.13: v2(254.27,107.65) 254.7,107.22 255.11,107.22 256.54,108.65 256.54,109.53 257.28,110.27 257.77,110.27 262.08,114.58 269.73,114.58 v2(269.75,114.56)
  BOTTOM w0.102: UG2.A4 269.96,114.35 v2(269.75,114.56) ; UG9.AW51 v2(254.27,107.65)
FBA_D33: length 20
  IN1 w0.13: v2(269.75,116.16) 269.6,116.31 266.99,116.31 266.98,116.32 266.04,116.32 266.03,116.31 260.49,116.31 255.6,111.42 255.6,109.5 255.58,109.48 255.58,109.47 255.17,109.05 v2(254.97,109.05)
  BOTTOM w0.102: v2(269.75,116.16) 269.98,115.93 UG2.A2 ; UG9.BA52 v2(254.97,109.05)
FBA_D34: length 21.6
  IN1 w0.13: v2(270.55,114.56) 270.01,114.02 262.97,114.02 257.42,108.47 257.09,108.47 255.45,106.83 254.28,106.83 253.57,107.55 v2(253.57,107.65)
  BOTTOM w0.102: UG9.AW50 v2(253.57,107.65) ; UG2.B4 270.78,114.33 270.78,114.34 v2(270.55,114.56)
FBA_D35: length 21.4
  IN1 w0.13: v2(254.27,108.45) 254.46,108.64 255.7,108.64 256.03,108.97 256.03,109.71 256.41,110.09 256.41,110.87 256.83,111.29 257.27,111.29 261.74,115.76 262.53,115.76 262.54,115.75 266.26,115.75 266.27,115.76 270.14,115.76 v2(270.55,116.16)
  BOTTOM w0.102: UG9.BA51 v2(254.27,108.45) ; UG2.B2 v2(270.55,116.16)
FBA_D36: length 29.9
  IN1 w0.13: v2(273.75,114.56) 273.34,114.97 273.34,117.27 272.24,118.37 260.29,118.37 253.62,111.7 253.62,110.48 253.12,109.98 253.12,109.5 v2(253.57,109.05)
  BOTTOM w0.102: UG9.BA50 v2(253.57,109.05) ; v2(273.75,114.56) 273.51,114.32 273.51,114.32 UG2.E4
FBA_D37: length 25.1
  IN1 w0.13: v2(253.57,109.75) 254.4,110.58 254.4,111.39 260.69,117.68 272.05,117.68 272.55,117.18 272.55,116.56 v2(272.95,116.16)
  BOTTOM w0.102: v2(272.95,116.16) 273.35,115.76 UG2.E2 ; UG9.BB50 v2(253.57,109.75)
FBA_D38: length 34.6
  IN1 w0.13: v2(274.55,114.56) 275.03,115.04 275.03,117.44 272.54,119.93 259.85,119.93 252.03,112.11 252.03,111.06 251.87,110.9 251.87,109.45 v2(252.27,109.05)
  BOTTOM w0.102: UG9.BA49 v2(252.27,109.05) ; UG2.F4 274.32,114.34 v2(274.55,114.56)
FBA_D39: length 31.8
  IN1 w0.13: v2(252.27,107.65) 252.27,108.4 252.73,108.86 252.73,111.18 252.9,111.35 252.9,112.01 259.91,119.02 272.49,119.02 274.14,117.37 274.14,117.13 274.14,116.56 v2(273.75,116.16)
  BOTTOM w0.102: UG9.AW49 v2(252.27,107.65) ; v2(273.75,116.16) UG2.F2
FBA_D40: length 20.5
  IN6 w0.102: 258.4,109.59 256.02,107.21 253.03,107.21 v2(252.17,106.35)
  IN6 w0.13: v2(269.75,108.16) 268.32,109.59 258.4,109.59
  BOTTOM w0.102: v2(269.75,108.16) 269.95,108.36 UG2.A11 ; UG9.AV48 v2(252.17,106.35)
FBA_D41: length 19.6
  IN6 w0.102: 258.73,108.1 257.01,106.37 254.45,106.37 253.55,105.47 252.95,105.47 v2(252.87,105.55)
  IN6 w0.13: v2(269.75,106.56) 269.34,106.56 267.8,108.1 258.73,108.1
  BOTTOM w0.102: UG2.A13 269.99,106.8 v2(269.75,106.56) ; UG9.AT49 v2(252.87,105.55)
FBA_D42: length 24.9
  IN6 w0.102: v2(250.87,105.55) 251.36,105.06 254.37,105.06 255.25,105.94 257.47,105.94 259.04,107.51
  IN6 w0.13: 259.04,107.51 267.63,107.51 269,106.14 269.84,106.14 269.89,106.19 270.36,106.19 270.39,106.17 270.71,106.17 270.94,106.4 270.94,107.77 v2(270.55,108.16)
  BOTTOM w0.102: UG9.AT47 v2(250.87,105.55) ; v2(270.55,108.16) 270.95,108.56 UG2.B11
FBA_D43: length 22
  IN6 w0.102: v2(252.17,105.55) 253.49,106.87 256.72,106.87 258.61,108.76
  IN6 w0.13: v2(270.55,106.56) 270.14,106.97 270.14,107.19 270.14,107.2 270.14,107.53 270.14,107.53 270.14,107.56 269.94,107.77 269.45,107.77 268.46,108.76 258.61,108.76
  BOTTOM w0.102: UG9.AT48 v2(252.17,105.55) ; v2(270.55,106.56) 270.95,106.96 UG2.B13
FBA_D44: length 27
  IN6 w0.102: v2(250.17,105.55) 251.02,104.7 255.31,104.7 255.65,105.04 258.15,105.04 260.03,106.92
  IN6 w0.13: v2(272.95,108.16) 272.55,107.76 272.55,107.21 272.54,107.21 272.54,107.2 272.31,106.97 272.3,106.97 272.29,106.96 271.99,106.96 271.75,106.73 271.75,106.3 271.41,105.96 270.83,105.96 270.81,105.94 270.29,105.94 270.27,105.96 269.99,105.96 269.94,105.91 268.45,105.91 267.44,106.92 260.03,106.92
  BOTTOM w0.102: UG2.E11 v2(272.95,108.16) ; UG9.AT46 v2(250.17,105.55)
FBA_D45: length 28.7
  IN6 w0.13: v2(273.75,106.56) UG2.E13 273.35,109.31 272.21,110.45 270.96,110.45 269.81,111.6 257.66,111.6 v2(257.14,112.12)
  BOTTOM w0.102: UG9.AV51 254.12,106.65 254.47,106.3 254.87,106.3 255.92,107.35 255.92,108.5 256.26,108.83 256.26,110.59 256.8,111.13 257.14,111.47 v2(257.14,112.12) ; UG2.E13 v2(273.75,106.56)
FBA_D46: length 27.8
  IN6 w0.13: v2(257.92,112.88) 258.1,112.7 262.92,112.7 262.94,112.68 269.66,112.68 271.23,111.11 272.35,111.11 274.14,109.32 274.14,108.56 v2(273.75,108.16)
  BOTTOM w0.102: UG2.F11 273.95,108.36 v2(273.75,108.16) ; UG9.AV52 254.87,106.65 255.62,107.4 255.62,108.62 255.99,108.98 255.99,111.77 257.1,112.88 v2(257.92,112.88)
FBA_D47: length 33
  IN6 w0.13: v2(274.55,106.56) 274.95,106.96 274.95,109.31 272.24,112.02 271.28,112.02 269.73,113.57 258.91,113.57 v2(258.76,113.72)
  BOTTOM w0.102: v2(258.76,113.72) 257.49,113.72 255.63,111.86 255.63,109.36 255.37,109.09 255.37,107.5 254.87,107 252.92,107 UG9.AV49 ; UG2.F13 274.3,106.81 v2(274.55,106.56)
FBA_D48: length 41.3
  IN6 w0.102: v2(252.17,100.05) 252.33,100.21 258.4,100.21 258.44,100.17 260.29,100.17 260.72,100.59 262.77,100.59
  IN6 w0.13: 262.77,100.59 272.27,100.59 272.59,100.91 280.34,100.91 281.77,102.34 284.12,102.34 284.98,103.2 284.98,107.49 284.31,108.16 v2(283.35,108.16)
  BOTTOM w0.102: v2(252.17,100.05) UG9.AJ48 ; UG2.U11 283.12,108.39 283.12,108.39 v2(283.35,108.16)
FBA_D49: length 37.9
  IN6 w0.102: 262.77,102.03 260.57,102.03 259.77,101.24 254.44,101.24 254.14,100.93 251.65,100.93 v2(250.77,100.05)
  IN6 w0.13: 262.77,102.03 279.68,102.03 281.98,104.33 281.99,104.33 282.04,104.38 283.25,104.38 283.8,104.93 283.8,106.11 v2(283.35,106.56)
  BOTTOM w0.102: v2(250.77,100.05) UG9.AJ46 ; UG2.U13 v2(283.35,106.56)
FBA_D50: length 41
  IN6 w0.102: 262.77,101.47 260.9,101.47 260.03,100.6 252.02,100.6 v2(251.47,100.05)
  IN6 w0.13: 262.77,101.47 280.01,101.47 281.51,102.97 283.67,102.97 284.42,103.72 284.42,106.84 283.74,107.52 283.74,107.53 283.51,107.76 283.51,107.76 283.5,107.77 282.94,107.77 v2(282.55,108.16)
  BOTTOM w0.102: v2(282.55,108.16) 282.34,108.37 UG2.T11 ; v2(251.47,100.05) UG9.AJ47
FBA_D51: length 33.6
  IN6 w0.102: 262.77,102.59 260.43,102.59 259.54,101.7 254.38,101.7 254.15,101.47 253.13,101.47 253.1,101.5 v2(253.02,101.5)
  IN6 w0.13: 262.77,102.59 279.39,102.59 281.35,104.56 281.89,104.56 282.15,104.82 282.15,106.17 v2(282.55,106.56)
  BOTTOM w0.102: v2(282.55,106.56) UG2.T13 ; UG9.AK49 v2(253.02,101.5)
FBA_D52: length 35.2
  IN6 w0.102: v2(251.47,102.15) 251.77,102.45 253.96,102.45 254.28,102.13 259.27,102.13 260.57,103.43 262.77,103.43
  IN6 w0.13: v2(280.15,108.16) 280.55,107.76 280.55,104.77 278.93,103.15 263.05,103.15 262.77,103.43
  BOTTOM w0.102: UG9.AM47 v2(251.47,102.15) ; UG2.N11 v2(280.15,108.16)
FBA_D53: length 33.2
  IN6 w0.102: v2(250.72,102.05) 250.72,102.1 251.38,102.76 259.2,102.76 260.43,103.99 262.77,103.99
  IN6 w0.13: v2(279.35,106.56) 279.75,106.16 279.75,104.77 278.97,103.99 262.77,103.99
  BOTTOM w0.102: UG2.N13 279.63,106.84 279.63,106.84 v2(279.35,106.56) ; UG9.AM46 250.72,102.2 v2(250.72,102.05)
FBA_D54: length 31.6
  IN6 w0.102: v2(252.17,103.45) 252.56,103.06 253.03,103.06 253.09,103.11 253.88,103.11 254.01,103.25 258.67,103.25 260.05,104.63 262.77,104.63
  IN6 w0.13: v2(279.35,108.16) 278.95,107.76 278.95,106.32 278.79,106.16 277.62,106.16 276.3,104.84 273.09,104.84 272.51,104.26 269.92,104.26 269.9,104.29 269.89,104.29 269.55,104.63 262.77,104.63
  BOTTOM w0.102: UG2.M11 v2(279.35,108.16) ; v2(252.17,103.45) UG9.AN48
FBA_D55: length 29.6
  IN6 w0.102: 262.77,105.19 259.91,105.19 258.43,103.71 253.98,103.71 253.72,103.45 v2(252.87,103.45)
  IN6 w0.13: v2(278.55,106.56) 278.02,107.09 277.38,107.09 276.36,106.08 272.51,106.08 272.39,105.96 272.39,105.96 272.15,105.73 272.15,104.75 272.16,104.75 271.9,104.49 270.02,104.49 269.99,104.52 269.99,104.52 269.75,104.75 269.75,104.75 269.32,105.19 262.77,105.19
  BOTTOM w0.102: UG2.M13 v2(278.55,106.56) ; v2(252.87,103.45) UG9.AN49
FBA_D56: length 41.9
  IN1 w0.102: v2(248.77,102.15) 248.81,102.15 249.37,102.71 251.85,102.71 251.91,102.65 253.82,102.65 254.01,102.84
  IN1 w0.13: v2(282.55,114.56) 283.11,114 283.11,112.56 281.31,110.76 277.98,110.76 276.72,109.5 265.05,109.5 258.39,102.84 254.01,102.84
  BOTTOM w0.102: UG9.AM44 v2(248.77,102.15) ; UG2.U4 v2(282.55,114.56)
FBA_D57: length 43.7
  IN1 w0.102: 253.72,102.43 253.69,102.46 251.83,102.46 251.77,102.52 249.82,102.52 249.47,102.17 v2(249.47,102.15)
  IN1 w0.13: 253.72,102.43 258.78,102.43 264.91,108.56 274.8,108.56 274.9,108.66 276.73,108.66 278.28,110.21 281.65,110.21 283.55,112.11 283.55,114.51 282.95,115.11 UG2.U2 v2(282.55,116.16)
  BOTTOM w0.102: UG2.U2 282.95,115.76 v2(282.55,116.16) ; UG9.AM45 v2(249.47,102.15)
