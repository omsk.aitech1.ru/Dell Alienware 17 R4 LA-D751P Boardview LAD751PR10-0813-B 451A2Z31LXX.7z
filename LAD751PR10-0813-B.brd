# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBD_CMD19: length 36.2
  BOTTOM w0.102: 214.54,77.72 214.54,86.55 216.11,88.12 220.74,88.12 UG9.M4
  BOTTOM w0.185: 214.54,77.72 211.95,75.13 211.95,74.73 207.05,69.83 200.78,69.83 200.41,70.2 200.41,70.35 200.26,70.5 200.26,71.89 UG8.G3
FBD_CMD20: length 30.6
  BOTTOM w0.102: 214.29,78.16 214.29,86.68 216.06,88.45 UG9.M1
  BOTTOM w0.185: UG8.H5 200.24,74.26 205.88,74.26 206.42,73.72 209.85,73.72 214.29,78.16
FBD_CMD21: length 32.5
  BOTTOM w0.102: 214.05,79.01 214.05,86.82 216.04,88.81 219.16,88.81 219.52,88.45 UG9.M2
  BOTTOM w0.185: 214.05,79.01 209.3,74.26 206.77,74.26 206.48,74.55 199.96,74.55 199.4,73.99 199.4,73.48 UG8.H4
FBD_CMD22: length 32.2
  BOTTOM w0.102: UG9.M3 220.02,88.8 219.52,88.8 219.26,89.06 215.97,89.06 213.77,86.86 213.77,79.82
  BOTTOM w0.185: UG8.J5 199.03,74.25 199.61,74.84 208.79,74.84 213.77,79.82
FBD_CMD23: length 33.6
  BOTTOM w0.102: 213.5,80.64 213.5,87.23 215.57,89.3 219.27,89.3 219.47,89.5 219.82,89.5 220.17,89.85 UG9.P3
  BOTTOM w0.185: UG8.J4 198.64,73.44 198.64,74.56 199.2,75.12 207.98,75.12 213.5,80.64
FBD_CMD24: length 32
  BOTTOM w0.102: UG9.P2 219.47,89.85 219.12,89.5 215.4,89.5 213.24,87.33 213.24,81.47
  BOTTOM w0.185: 213.24,81.47 207.18,75.41 198.98,75.41 198.23,74.65 UG8.K5
FBD_CMD25: length 32.5
  BOTTOM w0.102: UG9.P1 215.34,89.85 212.9,87.41 212.9,81.99
  BOTTOM w0.185: UG8.K4 197.81,73.47 197.81,74.79 198.73,75.7 206.62,75.7 206.63,75.72 206.64,75.72 208.33,77.4 208.33,77.41 212.9,81.99
FBD_CMD26: length 35.4
  BOTTOM w0.102: UG9.R4 220.72,90.2 215.21,90.2 212.59,87.58 212.59,84.35
  BOTTOM w0.185: 212.59,84.35 210.82,82.57 210.82,81.23 208.29,78.7 208.29,77.88 206.41,76 198.97,76 197.83,77.14 197.83,79.05 UG8.L12
FBD_CMD27: length 30.8
  BOTTOM w0.102: 212.33,85.41 212.33,87.8 215.08,90.55 UG9.R1
  BOTTOM w0.185: UG8.K10 198.23,77.15 199.09,76.29 206.18,76.29 207.78,77.89 207.78,79.28 209.62,81.13 209.62,82.7 212.33,85.41
FBD_CMD28: length 32.2
  BOTTOM w0.102: 212.07,86.23 212.07,88.05 214.92,90.9 219.17,90.9 219.52,90.55 UG9.R2
  BOTTOM w0.185: 212.07,86.23 208.94,83.11 208.94,81.53 207.49,80.08 207.49,78.01 206.06,76.58 199.21,76.58 198.64,77.15 198.64,78.24 UG8.K11
FBD_CMD29: length 32
  BOTTOM w0.102: 211.67,87.04 211.67,88.06 214.82,91.2 219.22,91.2 219.52,90.9 220.02,90.9 UG9.R3
  BOTTOM w0.185: UG8.H11 199.46,78.29 199.46,78.01 199.46,77.7 199.53,77.64 199.53,77.18 199.85,76.86 205.94,76.86 207.2,78.13 207.2,80.89 208.17,81.85 208.17,83.54 211.67,87.04
FBD_CMD30: length 30.5
  BOTTOM w0.102: UG9.U3 220.13,91.95 219.78,91.6 219.47,91.6 219.26,91.39 218.49,91.39 218.29,91.6 214.78,91.6 211.41,88.23 211.41,87.44
  BOTTOM w0.185: UG8.H10 199.94,77.74 199.94,77.5 200.29,77.15 205.82,77.15 206.91,78.25 206.91,81.38 207.34,81.8 207.34,83.47 210.72,86.85 210.82,86.85 211.41,87.44
FBD_CMD31: length 31.3
  BOTTOM w0.102: 211.15,87.95 211.15,88.35 211.79,88.99 211.79,89.52 214.19,91.93 218.36,91.93 218.67,91.62 219.14,91.62 219.47,91.95 UG9.U2
  BOTTOM w0.185: UG8.G12 200.22,79.05 200.22,77.62 200.41,77.44 205.62,77.44 206.63,78.44 206.63,83.53 210.72,87.62 210.82,87.62 211.15,87.95
FBD_D0: length 20.4
  IN1 w0.13: v2(205.83,97.25) 206.52,97.95 207.34,97.95 209.11,99.73 216.61,99.73 216.86,99.98 220.11,99.98 220.64,100.51 222.73,100.51 v2(223.57,101.35)
  BOTTOM w0.102: UG9.AK8 v2(223.57,101.35) ; v2(205.83,97.25) 205.43,97.65 UG7.U4
FBD_D1: length 17.4
  IN1 w0.13: v2(220.67,101.45) 220.38,101.17 219.04,101.17 218.18,102.03 208.21,102.03 v2(205.83,99.65)
  BOTTOM w0.102: UG7.U2 v2(205.83,99.65) ; UG9.AK4 v2(220.67,101.45)
FBD_D2: length 16.8
  IN1 w0.13: v2(205.03,98.05) 205.37,98.39 206.89,98.39 208.91,100.41 216.83,100.41 217.39,100.97 v2(217.39,101.07)
  BOTTOM w0.102: UG7.T4 v2(205.03,98.05) ; v2(217.39,101.07) 217.77,101.45 219.1,101.45 219.5,101.05 UG9.AK2
FBD_D3: length 17.7
  IN1 w0.13: v2(205.03,99.65) 205.43,99.25 206.28,99.25 208.15,101.12 213.31,101.12 213.65,101.47 215.85,101.47 v2(216.27,101.05)
  BOTTOM w0.102: UG7.T2 v2(205.03,99.65) ; v2(216.27,101.05) 216.92,101.7 218.56,101.7 218.58,101.68 218.64,101.68 218.65,101.67 219.25,101.67 219.54,101.38 219.8,101.38 220.13,101.05 UG9.AK3
FBD_D4: length 24.5
  IN1 w0.13: v2(201.83,98.05) 202.22,98.45 202.22,100.01 202.62,100.41 202.62,100.92 204.61,102.9 218.45,102.9 219.22,102.13 220.69,102.13 v2(221.47,101.35)
  BOTTOM w0.102: UG9.AK5 v2(221.47,101.35) ; UG7.N4 202.23,97.65 v2(201.83,98.05)
FBD_D5: length 23.3
  IN2 w0.117: v2(202.63,99.65) 203.42,100.44 203.42,100.48 203.42,100.49 203.42,100.82 203.42,100.83 203.42,101.2 204.66,102.45 212.84,102.45 213.2,102.81 216.43,102.81 217.97,101.27 v2(217.97,101.05)
  BOTTOM w0.102: UG7.N2 v2(202.63,99.65) ; v2(217.97,101.05) 218.37,100.65 218.77,100.65 218.82,100.7 222.12,100.7 UG9.AK6
FBD_D6: length 30.9
  IN1 w0.102: 224.37,102.58 224.55,102.4 224.55,101.67 v2(224.87,101.35)
  IN1 w0.13: v2(201.03,98.05) 200.43,98.65 200.43,100.82 200.46,100.85 203.07,103.46 218.84,103.46 219.72,102.58 224.37,102.58
  BOTTOM w0.102: UG9.AK9 v2(224.87,101.35) ; v2(201.03,98.05) 201.07,98.05 201.43,97.7 UG7.M4
FBD_D7: length 25.4
  IN2 w0.117: v2(222.87,101.35) 222.48,100.96 221.31,100.96 221.05,101.22 221.05,101.63 220.53,102.15 219.78,102.15 218.58,103.35 212.97,103.35 212.77,103.16 204.53,103.16 204.09,102.71 204.09,102.71 202.62,101.25 202.62,100.49 202.23,100.09 202.23,100.05 v2(201.83,99.65)
  BOTTOM w0.102: UG7.M2 v2(201.83,99.65) ; UG9.AK7 v2(222.87,101.35)
FBD_D8: length 19.9
  IN6 w0.102: 217.22,97.81 217.66,98.25 v2(217.92,98.25)
  IN6 w0.13: v2(205.83,91.65) 206.32,92.15 206.32,93.95 210.18,97.81 217.22,97.81
  BOTTOM w0.102: v2(205.83,91.65) 205.59,91.89 UG7.U11 ; UG9.AG4 220.72,98.6 218.72,98.6 218.67,98.65 218.32,98.65 v2(217.92,98.25)
FBD_D9: length 23.8
  IN6 w0.089: v2(224.87,97.95) 224.87,97.89 224.49,97.51 223.92,97.51
  IN6 w0.102: 223.92,97.51 223.08,96.67 221.46,96.67 221.27,96.87 218.2,96.87 217.46,96.12
  IN6 w0.13: v2(205.83,90.05) 206.68,90.05 207.65,91.03 207.65,91.59 212.19,96.12 217.46,96.12
  BOTTOM w0.102: UG9.AF9 v2(224.87,97.95) ; UG7.U13 205.62,90.26 v2(205.83,90.05)
FBD_D10: length 23.2
  IN6 w0.102: 217.25,97.25 217.72,97.71 218.69,97.71 219.71,98.73 222.25,98.73 v2(222.77,99.25)
  IN6 w0.13: v2(205.03,91.65) 205.43,91.25 206.1,91.25 206.7,91.85 206.7,93.53 210.41,97.25 217.25,97.25
  BOTTOM w0.102: UG9.AG6 v2(222.77,99.25) ; UG7.T11 204.81,91.87 204.81,91.87 v2(205.03,91.65)
FBD_D11: length 26
  IN6 w0.102: v2(224.29,99.37) 223.27,98.35 220.11,98.35 219.04,97.29 217.89,97.29 217.77,97.16 217.29,96.69
  IN6 w0.13: v2(205.03,90.05) 205.43,90.45 206.64,90.45 207.15,90.96 207.15,91.88 211.96,96.69 217.29,96.69
  BOTTOM w0.102: v2(224.29,99.37) 224.21,99.29 224.21,98.83 224,98.62 223.49,98.62 UG9.AG7 ; v2(205.03,90.05) UG7.T13
FBD_D12: length 23
  IN6 w0.102: 219.35,99.41 219.99,100.05 v2(220.77,100.05)
  IN6 w0.13: v2(202.63,91.65) 202.63,91.84 203.03,92.24 203.03,92.69 204.19,93.85 204.64,93.85 210.19,99.41 219.35,99.41
  BOTTOM w0.102: v2(220.77,100.05) UG9.AJ4 ; UG7.N11 v2(202.63,91.65)
FBD_D13: length 26.5
  IN6 w0.102: 219.33,100.06 219.76,100.49 221.03,100.49 v2(221.47,100.05)
  IN6 w0.13: v2(202.63,90.05) 202.23,90.45 202.23,92.71 204.1,94.58 204.57,94.58 210.05,100.06 219.33,100.06
  BOTTOM w0.102: v2(202.63,90.05) 202.4,90.28 202.4,90.28 UG7.N13 ; UG9.AJ5 v2(221.47,100.05)
FBD_D14: length 27.4
  IN6 w0.102: v2(222.77,100.05) 222.15,100.67 221.45,100.67 221.17,100.95 219.56,100.95 219.23,100.62
  IN6 w0.13: v2(201.83,91.65) 201.44,92.04 201.44,92.28 201.43,92.29 201.43,92.62 201.44,92.62 201.44,92.75 203.97,95.28 204.48,95.28 209.82,100.62 219.23,100.62
  BOTTOM w0.102: UG7.M11 v2(201.83,91.65) ; UG9.AJ6 v2(222.77,100.05)
FBD_D15: length 26.2
  IN6 w0.102: v2(221.47,99.25) 221.25,99.03 218.83,99.03 218.65,98.85
  IN6 w0.13: v2(201.83,90.05) 202.23,89.65 202.83,89.65 203.03,89.85 203.03,91.8 203.03,91.8 203.03,91.82 203.26,92.05 203.28,92.05 203.28,92.05 203.63,92.05 203.83,92.25 203.83,92.66 204.35,93.19 204.77,93.19 210.43,98.85 218.65,98.85
  BOTTOM w0.102: v2(201.83,90.05) 201.62,90.27 UG7.M13 ; UG9.AG5 v2(221.47,99.25)
FBD_D16: length 43.2
  IN6 w0.102: v2(222.91,93.61) 222.46,93.16 222.46,92.88 221.63,92.05 220.03,92.05 219.13,91.15
  IN6 w0.13: v2(192.23,92.45) 191.27,91.5 191.27,87.75 194.21,84.81 194.54,84.48 207.49,84.48 207.82,84.81 214.17,91.15 219.13,91.15
  BOTTOM w0.102: UG7.A11 192.43,92.25 v2(192.23,92.45) ; UG9.Y6 v2(222.91,93.61)
FBD_D17: length 35.7
  IN6 w0.102: 218.43,93.06 219.52,94.15 221.07,94.15 v2(221.47,93.75)
  IN6 w0.13: v2(193.03,90.85) 193.43,90.45 193.43,89.09 196.35,86.16 205.26,86.16 206.46,86.16 213.36,93.06 218.43,93.06
  BOTTOM w0.102: UG7.A13 v2(193.03,90.85) ; UG9.Y5 v2(221.47,93.75)
FBD_D18: length 40.1
  IN6 w0.102: v2(221.46,92.98) 221.09,92.61 219.7,92.61 218.88,91.79
  IN6 w0.13: v2(193.03,92.45) 191.83,91.26 191.83,87.98 194.78,85.04 204.8,85.04 204.8,85.04 207.26,85.04 214.01,91.79 218.88,91.79
  BOTTOM w0.102: UG9.V5 221.46,92.95 v2(221.46,92.98) ; v2(193.03,92.45) 193.24,92.24 193.24,92.24 UG7.B11
FBD_D19: length 35.1
  IN6 w0.102: v2(220.77,93.75) 219.97,93.75 218.64,92.42
  IN6 w0.13: 218.64,92.42 213.52,92.42 206.69,85.6 205.03,85.6 196.12,85.6 192.62,89.1 192.62,89.65 v2(193.03,90.05)
  BOTTOM w0.102: UG9.Y4 v2(220.77,93.75) ; UG7.B13 v2(193.03,90.05)
FBD_D20: length 34.7
  IN6 w0.102: v2(222.06,95.16) 221.36,94.45 220.5,94.45 220.41,94.55 219.16,94.55 218.5,93.88
  IN6 w0.13: 218.5,93.88 213.39,93.88 206.23,86.72 205.5,86.72 205.5,86.72 198.16,86.72 195.83,89.06 195.83,91.25 v2(196.23,91.65)
  BOTTOM w0.102: UG7.E11 195.83,92.05 v2(196.23,91.65) ; UG9.AA6 v2(222.06,95.16)
FBD_D21: length 31.2
  IN6 w0.102: 218.31,94.44 218.81,94.94 220.44,94.94 220.61,94.77 221.1,94.77 v2(221.46,95.13)
  IN6 w0.13: 218.31,94.44 213.15,94.44 206,87.28 198.4,87.28 196.63,89.05 196.63,89.65 v2(196.23,90.05)
  BOTTOM w0.102: UG7.E13 195.83,90.45 v2(196.23,90.05) ; v2(221.46,95.13) 221.47,95.12 221.47,95.05 UG9.AA5
FBD_D22: length 30.3
  IN6 w0.102: v2(221.5,95.74) 220.81,96.43 218.75,96.43 217.89,95.56
  IN6 w0.13: 217.89,95.56 212.42,95.56 208.01,91.15 208.01,90.88 206.22,89.1 206.22,89.09 205.99,88.86 205.98,88.86 205.93,88.81 200.8,88.81 200.19,89.41 199.44,89.41 197.2,91.65 v2(197.03,91.65)
  BOTTOM w0.102: UG7.F11 196.78,91.9 196.78,91.9 v2(197.03,91.65) ; v2(221.5,95.74) 221.5,95.88 UG9.AC5
FBD_D23: length 28.9
  IN6 w0.102: v2(220.63,95.72) 220.41,95.94 218.96,95.94 218.43,95.41 218.42,95.41 218.01,95
  IN6 w0.13: v2(197.03,90.05) 197.73,90.05 199.66,88.12 206.04,88.12 212.92,95 218.01,95
  BOTTOM w0.102: UG7.F13 196.8,90.28 196.81,90.28 v2(197.03,90.05) ; UG9.AC4 v2(220.63,95.72)
FBD_D24: length 35.8
  IN1 w0.13: v2(192.23,97.3) 192.23,96.48 194.7,94.01 209.56,94.01 210.44,94.89 215.02,94.89 215.35,95.22 218.47,95.22 219.75,96.5 222.06,96.5 222.31,96.75 222.95,96.75 223.32,97.13 v2(223.32,97.45)
  BOTTOM w0.102: UG7.A4 192.28,97.3 v2(192.23,97.3) ; UG9.AD7 223.17,96.95 223.32,97.1 v2(223.32,97.45)
FBD_D25: length 37.7
  IN1 w0.13: v2(222.77,95.85) 222.45,96.17 220.14,96.17 218.55,94.58 215.28,94.58 215.02,94.33 210.83,94.33 209.41,92.91 194.91,92.91 191.8,96.02 191.8,98.43 v2(192.23,98.85)
  BOTTOM w0.102: UG9.AC6 v2(222.77,95.85) ; UG7.A2 v2(192.23,98.85)
FBD_D26: length 32.6
  IN1 w0.13: v2(222.17,97.95) 221.88,98.24 221.07,98.24 220.96,98.35 220.47,98.35 220.24,98.12 219.78,98.12 218.07,96.4 215.31,96.4 214.91,96.01 209.72,96.01 209.11,95.41 207.97,95.41 207.59,95.03 195.87,95.03 194.05,96.85 193.64,96.85 193.24,97.25 v2(193.03,97.25)
  BOTTOM w0.102: UG9.AF6 v2(222.17,97.95) ; UG7.B4 v2(193.03,97.25)
FBD_D27: length 35
  IN1 w0.13: v2(193.03,98.85) 192.63,98.45 192.63,97.04 192.81,96.86 193.25,96.86 193.43,96.68 193.43,96.23 193.99,95.67 194.31,95.67 195.37,94.61 209.2,94.61 210.04,95.45 215.01,95.45 215.31,95.75 218.17,95.75 219.28,96.85 221.28,96.85 221.29,96.84 221.63,96.84 222.02,97.23 v2(222.02,97.3)
  BOTTOM w0.102: UG7.B2 v2(193.03,98.85) ; UG9.AD6 v2(222.02,97.3)
FBD_D28: length 32
  IN1 w0.13: v2(222.87,97.95) 222.28,98.54 221.19,98.54 221.13,98.6 219.43,98.6 217.85,97.02 215.14,97.02 214.69,96.57 209.39,96.57 208.86,96.04 207.23,96.04 206.64,95.46 196.53,95.46 195.83,96.15 195.83,97.66 v2(196.23,98.05)
  BOTTOM w0.102: UG9.AF7 v2(222.87,97.95) ; UG7.E4 195.98,97.81 v2(196.23,98.05)
FBD_D29: length 33.6
  IN1 w0.13: v2(196.23,99.65) 196.63,99.25 196.63,96.25 197,95.88 206.35,95.88 207.08,96.62 208.54,96.62 209.06,97.13 214.46,97.13 214.9,97.57 217.07,97.57 217.52,98.02 217.52,98.45 218.07,99 221.14,99 221.29,98.85 222.67,98.85 v2(223.57,97.95)
  BOTTOM w0.102: UG9.AF8 v2(223.57,97.95) ; UG7.E2 196.01,99.43 v2(196.23,99.65)
FBD_D30: length 24.7
  IN1 w0.13: v2(197.03,97.25) 197.98,96.3 206.14,96.3 207.02,97.19 208.29,97.19 208.8,97.7 214.23,97.7 214.77,98.24 v2(214.77,98.25)
  BOTTOM w0.102: UG9.AF2 219.47,98.25 219.08,97.86 215.16,97.86 v2(214.77,98.25) ; v2(197.03,97.25) UG7.F4
FBD_D31: length 26.7
  IN1 w0.13: v2(213.57,98.25) 213.57,98.27 213.07,98.77 208.99,98.77 207.78,97.57 206.83,97.57 206.07,96.8 198.78,96.8 197.97,97.61 197.64,97.61 197.43,97.83 197.43,98.45 v2(197.03,98.85)
  BOTTOM w0.102: v2(213.57,98.25) 214.22,97.6 219.17,97.6 219.47,97.9 219.78,97.9 220.13,98.25 UG9.AF3 ; v2(197.03,98.85) UG7.F2
FBD_D32: length 24.5
  IN6 w0.102: 215.2,83.27 215.97,84.04 220.5,84.04 221.26,84.8 v2(221.58,84.8)
  IN6 w0.13: 215.2,83.27 215.2,82.83 213.43,81.06 211.81,79.45 211.81,76.13 208.15,72.46 206.02,72.46 v2(205.83,72.65)
  BOTTOM w0.102: UG9.F4 221.57,84.75 221.57,84.79 v2(221.58,84.8) ; UG8.A4 v2(205.83,72.65)
FBD_D33: length 20.8
  IN6 w0.102: v2(218.22,83.24) 217.37,82.4 216.35,82.4
  IN6 w0.13: 216.35,82.4 212.94,78.98 212.94,75.66 208.33,71.05 v2(205.83,71.05)
  BOTTOM w0.102: v2(218.22,83.24) 218.53,83.55 UG9.E1 ; UG8.A2 v2(205.83,71.05)
FBD_D34: length 23
  IN6 w0.102: v2(220.07,84.63) 219.8,84.36 215.93,84.36
  IN6 w0.13: v2(205.03,72.65) 205.55,73.18 206.08,73.18 206.08,73.18 208,73.18 211.25,76.44 211.25,79.68 214.64,83.07 214.64,83.07 215.93,84.36
  BOTTOM w0.102: v2(220.07,84.63) 220.07,84.55 UG9.F3 ; UG8.B4 204.63,73.05 v2(205.03,72.65)
FBD_D35: length 25.8
  IN6 w0.102: 216,82.83 216.4,82.83 216.67,83.1 216.67,83.47 216.94,83.74 220.66,83.74 221.22,84.3 221.82,84.3 v2(222.07,84.55)
  IN6 w0.13: v2(205.03,71.05) 205.43,71.45 206.67,71.45 207.07,71.85 208.33,71.85 212.38,75.89 212.38,79.22 216,82.83
  BOTTOM w0.102: v2(222.07,84.55) UG9.F5 ; UG8.B2 v2(205.03,71.05)
FBD_D36: length 28.4
  IN6 w0.102: 217.8,81.85 v2(218.07,81.85)
  IN6 w0.13: v2(201.83,72.65) 202.23,72.25 202.23,70.09 203.1,69.22 208.09,69.22 214.06,75.19 214.06,78.11 217.8,81.85
  BOTTOM w0.102: UG8.E4 202,72.83 202,72.83 v2(201.83,72.65) ; v2(218.07,81.85) 218.72,82.5 219.32,82.5 UG9.D2
FBD_D37: length 25.1
  IN6 w0.102: v2(217.23,81.82) 216.85,81.44 216.19,81.44
  IN6 w0.13: 216.19,81.44 213.5,78.75 213.5,75.43 207.86,69.78 203.34,69.78 203.08,70.04 203.02,70.1 203.02,70.66 v2(202.63,71.05)
  BOTTOM w0.102: v2(217.23,81.82) 217.76,82.35 218.22,82.35 218.72,82.85 UG9.D1 ; UG8.E2 v2(202.63,71.05)
FBD_D38: length 31.5
  IN6 w0.102: 218.87,80.65 219.44,80.65 219.73,80.94 219.73,81.51 v2(220.07,81.85)
  IN6 w0.13: v2(201.03,72.65) 200.58,72.2 200.58,70.01 202.53,68.05 208.5,68.05 208.83,68.38 215.08,74.63 215.08,76.87 218.87,80.65
  BOTTOM w0.102: UG9.C3 v2(220.07,81.85) ; UG8.F4 201.43,73.05 v2(201.03,72.65)
FBD_D39: length 27.7
  IN6 w0.102: v2(219.36,81.84) 218.98,81.46 218.59,81.46
  IN6 w0.13: 218.59,81.46 214.62,77.49 214.62,74.96 208.27,68.61 202.76,68.61 201.43,69.95 201.43,70.65 v2(201.83,71.05)
  BOTTOM w0.102: UG9.C2 v2(219.36,81.84) ; UG8.F2 v2(201.83,71.05)
FBD_D40: length 20.5
  IN1 w0.13: v2(205.83,79.05) 205.98,78.9 210.09,78.9 215.7,84.52 216.24,84.52 216.97,85.25 218.21,85.25 219.21,86.25 221.67,86.25 v2(222.07,86.65)
  BOTTOM w0.102: v2(205.83,79.05) 205.62,78.84 UG8.A11 ; UG9.J5 v2(222.07,86.65)
FBD_D41: length 18.8
  IN1 w0.13: v2(216.85,86.34) 216.81,86.34 216.4,85.93 215.53,85.93 209.89,80.3 206.18,80.3 v2(205.83,80.65)
  BOTTOM w0.102: UG9.J4 221.06,86.34 220.72,86 218.77,86 218.67,85.9 217.29,85.9 v2(216.85,86.34) ; v2(205.83,80.65) 205.6,80.42 UG8.A13
FBD_D42: length 27.1
  IN1 w0.13: v2(205.03,79.05) 204.62,79.46 204.62,81.01 204.8,81.19 206.13,81.19 206.42,80.9 209.7,80.9 216.08,87.28 219.66,87.28 220.22,87.85 224.27,87.85 224.72,87.4 v2(224.72,87.35)
  BOTTOM w0.102: UG8.B11 204.8,78.83 204.8,78.83 v2(205.03,79.05) ; v2(224.72,87.35) 224.32,87.75 UG9.L8
FBD_D43: length 18.6
  IN1 w0.13: v2(205.03,79.85) 205.43,79.45 206.04,79.45 206.1,79.51 209.9,79.51 215.72,85.33 216.41,85.33 216.82,85.74 217.48,85.74 217.97,86.23 v2(217.97,86.36)
  BOTTOM w0.102: UG9.J2 219.5,86.35 219.1,86.75 218.36,86.75 v2(217.97,86.36) ; v2(205.03,79.85) 204.83,80.06 UG8.B13
FBD_D44: length 21
  IN1 w0.13: v2(202.63,79.05) 203.03,78.65 203.03,78.06 203.5,77.59 209.57,77.59 215.21,83.23 215.21,83.34 215.53,83.66 215.91,83.66 v2(216.29,83.28)
  BOTTOM w0.102: UG9.F1 218.84,84.12 217.12,84.12 v2(216.29,83.28) ; UG8.E11 v2(202.63,79.05)
FBD_D45: length 24.3
  IN1 w0.13: v2(217.06,83.29) 216.61,82.84 216.16,82.84 210.31,76.98 203.15,76.98 202.23,77.9 UG8.E13 v2(201.83,80.65)
  BOTTOM w0.102: v2(217.06,83.29) 217.67,83.9 219.32,83.9 UG9.F2 ; v2(201.83,80.65) 202.06,80.42 UG8.E13
FBD_D46: length 27.1
  IN1 w0.13: v2(201.83,79.05) 201.43,78.66 201.43,77.95 203.02,76.35 211.11,76.35 215.91,81.15 215.91,81.69 216.51,82.3 217.21,82.3 217.56,82.65 218.26,82.65 218.64,83.03 218.64,83.81 219.67,84.84 219.67,85.2 220.01,85.54 220.58,85.54 v2(220.77,85.35)
  BOTTOM w0.102: UG9.H4 v2(220.77,85.35) ; v2(201.83,79.05) UG8.F11
FBD_D47: length 30.3
  IN1 w0.13: v2(201.03,80.65) 200.62,80.25 200.62,78.11 200.63,78.1 200.63,78.09 200.86,77.86 200.87,77.86 203.07,75.66 211.74,75.66 217.66,81.58 217.66,82.05 217.85,82.24 218.23,82.24 218.92,82.93 218.92,83.37 219.35,83.8 220.3,83.8 221.17,84.67 221.17,85.05 v2(221.47,85.35)
  BOTTOM w0.102: v2(221.47,85.35) UG9.H5 ; v2(201.03,80.65) 201.28,80.4 201.28,80.4 UG8.F13
FBD_D48: length 43.9
  IN1 w0.13: v2(192.23,79.05) 191.58,79.05 190.49,80.14 190.49,83.09 193.43,86.03 206.59,86.03 213.29,92.73 216.91,92.73 217.6,93.42 219.54,93.42 220.28,94.16 222.13,94.16 222.51,93.78 222.51,93.43 222.9,93.04 v2(222.93,93.04)
  BOTTOM w0.102: v2(192.23,79.05) 192.49,78.79 UG8.U11 ; v2(222.93,93.04) 223.17,92.8 UG9.V7
FBD_D49: length 39.8
  IN1 w0.13: v2(192.23,80.65) 191.78,81.1 191.78,82.66 194.02,84.91 207.95,84.91 214.45,91.41 217.56,91.41 218.43,92.28 221.95,92.28 222.32,92.65 UG9.V8 v2(224.17,92.95)
  BOTTOM w0.102: UG9.V8 v2(224.17,92.95) ; UG8.U13 192.44,80.44 v2(192.23,80.65)
FBD_D50: length 41.6
  IN1 w0.13: v2(193.03,79.05) 192.63,79.45 191.98,79.45 191.19,80.24 191.19,82.99 193.66,85.47 207.05,85.47 213.69,92.11 217.51,92.11 218.33,92.93 220.21,92.93 220.54,92.6 221.29,92.6 221.3,92.59 221.63,92.59 221.64,92.6 221.67,92.6 222.06,92.99 v2(222.06,93.06)
  BOTTOM w0.102: v2(193.03,79.05) 193.24,78.84 UG8.T11 ; UG9.V6 v2(222.06,93.06)
FBD_D51: length 39.6
  IN1 w0.13: v2(193.03,80.65) 192.63,81.05 192.63,82.45 193.44,83.27 194.3,83.27 195.38,84.35 208.55,84.35 215.02,90.82 218.01,90.82 218.98,91.79 220.35,91.79 220.5,91.94 221.25,91.94 221.31,92 221.63,92 221.65,91.98 222.54,91.98 222.63,92.07 223.99,92.07 v2(224.87,92.95)
  BOTTOM w0.102: v2(193.03,80.65) 193.25,80.43 UG8.T13 ; UG9.V9 v2(224.87,92.95)
FBD_D52: length 35.7
  IN1 w0.13: v2(220.67,91.55) 220.67,91.34 220.29,90.96 218.83,90.96 217.86,89.99 215.51,89.99 209.3,83.79 195.61,83.79 194.23,82.4 194.23,79.68 194.46,79.45 195.03,79.45 v2(195.43,79.05)
  BOTTOM w0.102: UG9.U4 v2(220.67,91.55) ; v2(195.43,79.05) UG8.N11
FBD_D53: length 32.3
  IN1 w0.13: v2(221.57,91.05) 221.17,90.65 219.28,90.65 217.81,89.19 215.61,89.19 209.64,83.22 199.53,83.22 198.95,82.64 196.14,82.64 195.83,82.33 195.83,81.05 v2(196.23,80.65)
  BOTTOM w0.102: UG8.N13 196.23,80.65 v2(196.23,80.65) ; UG9.R5 221.77,90.67 221.76,90.68 221.76,90.86 v2(221.57,91.05)
FBD_D54: length 32.6
  IN1 w0.13: v2(196.23,79.05) 196.63,79.45 196.63,80.83 196.86,81.06 198.26,81.06 199.43,82.23 202.86,82.23 203.24,82.61 209.82,82.61 215.7,88.49 217.94,88.49 219.72,90.27 221.59,90.27 v2(222.17,90.85)
  BOTTOM w0.102: UG9.R6 v2(222.17,90.85) ; UG8.M11 v2(196.23,79.05)
FBD_D55: length 33.4
  IN1 w0.13: v2(224.17,91.65) 223.87,91.35 223.87,90.59 223.22,89.94 221.3,89.94 221.21,89.85 219.77,89.85 217.84,87.92 215.92,87.92 210.06,82.05 203.63,82.05 203.44,81.85 203.44,81.82 203.43,81.82 203.43,81.37 203.26,81.19 198.77,81.19 198.23,80.65 v2(197.03,80.65)
  BOTTOM w0.102: UG8.M13 196.8,80.42 v2(197.03,80.65) ; UG9.U8 v2(224.17,91.65)
FBD_D56: length 42.3
  IN6 w0.102: v2(222.87,89.45) 222.52,89.8 221.75,89.8 221.61,89.94 219.66,89.94 218.59,88.87 ; 207.87,81.85 207.34,81.32
  IN6 w0.13: 218.59,88.87 214.88,88.87 207.87,81.85 ; v2(193.03,72.65) 192.49,73.19 192.49,74.48 194.49,76.48 197.57,76.48 198.89,77.8 199.53,77.8 200.03,77.3 206.31,77.3 207.34,78.33 207.34,81.32
  BOTTOM w0.102: UG8.U4 193.03,72.65 v2(193.03,72.65) ; UG9.P6 v2(222.87,89.45)
FBD_D57: length 47
  IN6 w0.102: 207.07,81.85 206.7,81.48 206.7,78.58 205.97,77.84 200.75,77.84 ; v2(224.87,90.85) 224.05,90.03 221.86,90.03 221.66,90.23 219.33,90.23 218.54,89.44 ; 197.28,77 198.57,78.29
  IN6 w0.13: 198.57,78.29 200.3,78.29 200.75,77.84 ; v2(193.03,71.05) 192.63,71.45 192.63,72.13 191.99,72.77 191.99,74.84 194.15,77 197.28,77 ; 207.07,81.85 214.66,89.44 218.54,89.44
  BOTTOM w0.102: UG8.U2 193.03,71.05 v2(193.03,71.05) ; UG9.R9 v2(224.87,90.85)
FBD_D58: length 37.7
  IN6 w0.102: 218.52,88.3 219.86,89.64 220.48,89.64 v2(220.67,89.45) ; 208.66,81.85 207.97,81.16
  IN6 w0.13: 218.52,88.3 215.1,88.3 208.66,81.85 ; v2(193.03,73.45) 193.43,73.85 193.43,74.45 194.99,76.01 198.49,76.01 199.25,76.77 206.63,76.77 207.97,78.12 207.97,81.16
  BOTTOM w0.102: v2(193.03,73.45) 193.03,73.45 UG8.T4 ; UG9.P4 v2(220.67,89.45)
FBD_D59: length 39.9
  IN6 w0.102: 218.43,87.73 219.42,88.72 220.64,88.72 v2(221.47,89.55) ; 208.67,81.07 208.54,80.94
  IN6 w0.13: 208.67,81.07 215.33,87.73 218.43,87.73 ; 208.54,80.94 208.54,80.23 208.54,80.23 208.54,80.17 208.54,80.17 208.54,78.32 208.54,77.82 207.03,76.31 199.65,76.31 198.96,75.62 195.38,75.62 194.23,74.47 194.23,71.45 v2(193.83,71.05)
  BOTTOM w0.102: v2(193.83,71.05) 193.83,71.05 UG8.T2 ; v2(221.47,89.55) UG9.P5
FBD_D60: length 38.7
  IN6 w0.102: v2(223.47,87.45) 222.62,88.3 219.68,88.3 218.53,87.15
  IN6 w0.13: 218.53,87.15 215.55,87.15 209.01,80.61 209.01,77.42 207.66,76.07 207.65,76.07 207.33,75.75 200.49,75.75 199.83,75.09 196.39,75.09 195.75,74.45 195.75,73.13 v2(196.23,72.65)
  BOTTOM w0.102: UG8.N4 195.99,72.89 v2(196.23,72.65) ; UG9.L7 v2(223.47,87.45)
FBD_D61: length 36.6
  IN6 w0.102: v2(222.17,87.45) 222.17,87.74 222.07,87.84 219.93,87.84 218.93,86.84
  IN6 w0.13: 218.93,86.84 216.03,86.84 209.57,80.38 209.57,77.14 207.65,75.21 200.64,75.21 199.96,74.53 198.16,74.53 197.48,73.85 196.82,73.85 196.63,73.66 196.63,72.25 v2(196.23,71.85)
  BOTTOM w0.102: v2(196.23,71.85) 196.01,71.63 UG8.N2 ; v2(222.17,87.45) UG9.L6
FBD_D62: length 32.8
  IN6 w0.102: 218.7,85.82 220.39,87.51 220.71,87.51 v2(220.77,87.45)
  IN6 w0.13: v2(197.03,72.65) 198.48,74.1 200.22,74.1 200.65,74.53 207.76,74.53 210.13,76.9 210.13,80.15 215.8,85.82 218.7,85.82
  BOTTOM w0.102: v2(197.03,72.65) UG8.M4 ; UG9.L4 v2(220.77,87.45)
FBD_D63: length 35.5
  IN6 w0.102: v2(221.47,87.45) 220.97,86.95 220.97,86.6 219.68,85.31
  IN6 w0.13: 219.68,85.31 216.09,85.31 214.07,83.29 210.69,79.91 210.69,76.67 207.92,73.9 200.78,73.9 200.36,73.48 198.76,73.48 198.23,72.95 198.23,72.3 197.37,71.45 196.62,71.45 v2(196.23,71.05)
  BOTTOM w0.102: v2(221.47,87.45) UG9.L5 ; UG8.M2 v2(196.23,71.05)
FBD_DBI0: length 18.1
  IN2 w0.117: v2(203.43,99.65) 204.23,100.46 204.23,100.85 205.07,101.7 213.04,101.7 213.48,102.13 214.58,102.13 215.02,101.69 215.03,101.69 v2(215.67,101.05)
  BOTTOM w0.102: UG7.P2 v2(203.43,99.65) ; v2(215.67,101.05) 216.37,100.35 UG9.AJ1
FBD_DBI1: length 20
  IN2 w0.117: v2(203.43,90.05) 203.83,90.46 207.52,90.46 211.52,94.46 213.62,94.46 217.12,97.95 v2(217.12,98.3)
  BOTTOM w0.102: v2(217.12,98.3) 217.77,98.95 UG9.AG1 ; UG7.P13 v2(203.43,90.05)
FBD_DBI2: length 34.6
  IN2 w0.117: v2(222.87,95.05) 222.53,94.71 218.13,94.71 215.02,91.6 212.35,91.6 207.97,87.22 196.8,87.22 195.84,88.17 195.84,90.52 195.51,90.85 v2(195.43,90.85)
  BOTTOM w0.102: UG9.AA7 v2(222.87,95.05) ; UG7.D13 195.03,90.45 v2(195.43,90.85)
FBD_DBI3: length 32.1
  IN2 w0.117: v2(194.63,98.85) 195.03,98.45 196.43,98.45 196.63,98.25 196.63,97.85 196.83,97.65 197.23,97.65 199.93,94.95 207.28,94.95 211.07,98.75 218.6,98.75 220.35,97 221.23,97 v2(221.46,97.23)
  BOTTOM w0.102: UG7.D2 v2(194.63,98.85) ; UG9.AD5 221.46,97.16 v2(221.46,97.23)
FBD_DBI4: length 24.1
  IN2 w0.117: v2(220.67,82.55) 220.37,82.25 216.4,82.25 209.69,75.53 209.69,74.37 206.22,70.9 206.22,70.89 205.99,70.67 205.98,70.67 205.96,70.64 203.78,70.64 203.43,71 v2(203.43,71.05)
  BOTTOM w0.102: UG8.D2 v2(203.43,71.05) ; v2(220.67,82.55) UG9.D3
FBD_DBI5: length 20.3
  IN2 w0.117: v2(203.43,79.85) 203.81,79.47 204.06,79.47 204.07,79.47 204.39,79.47 204.39,79.47 204.86,79.47 204.87,79.47 205.19,79.47 205.19,79.47 205.66,79.47 205.67,79.47 205.99,79.47 205.99,79.47 209.64,79.47 214.63,84.47 218.74,84.47 219.08,84.81 v2(219.08,84.86)
  BOTTOM w0.102: UG8.D13 v2(203.43,79.85) ; UG9.H3 220.17,85.65 219.82,85.3 219.52,85.3 v2(219.08,84.86)
FBD_DBI6: length 33.3
  IN2 w0.117: v2(194.63,80.65) 195.03,81.05 195.03,82.5 197.03,84.5 209,84.5 213.13,88.64 216.63,88.64 218.91,90.91 220.78,90.91 v2(221.47,91.6)
  BOTTOM w0.102: v2(221.47,91.6) 221.47,91.65 UG9.U5 ; UG8.P13 v2(194.63,80.65)
FBD_DBI7: length 40.6
  IN2 w0.117: v2(195.43,71.05) 195.84,71.46 195.84,72.01 196.07,72.24 196.07,72.24 196.08,72.25 197.21,72.25 197.43,72.47 197.43,73.05 202.23,77.85 202.23,80.98 202.45,81.2 209.2,81.2 213.88,85.88 215.15,85.88 215.27,85.76 218.73,85.76 219.34,86.37 219.34,86.7 220.6,87.96 224.08,87.96 v2(224.87,88.75)
  BOTTOM w0.102: UG8.P2 195.03,71.45 v2(195.43,71.05) ; UG9.M9 v2(224.87,88.75)
FBD_EDC0: length 18.7
  IN2 w0.117: v2(214.52,101.05) 214.12,101.45 213.76,101.45 213.3,101 209.05,101 207.31,99.25 204.63,99.25 v2(204.23,98.86)
  BOTTOM w0.102: UG7.R2 204.23,98.86 v2(204.23,98.86) ; v2(214.52,101.05) 215.4,100.17 215.8,99.77 219.26,99.77 219.51,100.02 220.04,100.02 UG9.AJ3
FBD_EDC1: length 19.6
  IN2 w0.117: v2(215.97,98.3) 212.8,95.13 209.99,95.13 206.11,91.25 204.63,91.25 v2(204.23,90.85)
  BOTTOM w0.102: UG9.AG2 219.34,99.28 216.95,99.28 v2(215.97,98.3) ; v2(204.23,90.85) 204.23,90.85 UG7.R13
FBD_EDC2: length 37.4
  IN2 w0.117: v2(224.87,95.05) 223.96,94.14 219.51,94.14 215.89,90.52 212.29,90.52 208.03,86.26 196.72,86.26 195.03,87.95 195.03,89.65 v2(194.63,90.05)
  BOTTOM w0.102: UG9.AA9 v2(224.87,95.05) ; v2(194.63,90.05) 194.4,90.28 UG7.C13
FBD_EDC3: length 32
  IN2 w0.117: v2(220.77,97.95) 219.5,99.22 215.51,99.22 215.3,99.43 210.58,99.43 206.96,95.8 200.28,95.8 198.23,97.85 198.23,98.4 197.38,99.25 194.23,99.25 v2(193.83,99.65)
  BOTTOM w0.102: UG9.AF4 v2(220.77,97.95) ; UG7.C2 v2(193.83,99.65)
FBD_EDC4: length 22
  IN2 w0.117: v2(220.07,83.25) 219.63,82.81 215.7,82.81 208.16,75.28 208.16,74.44 206.22,72.5 206.22,72.49 205.99,72.27 204.73,72.27 204.32,71.85 v2(204.23,71.85)
  BOTTOM w0.102: UG9.E3 v2(220.07,83.25) ; v2(204.23,71.85) 204.23,71.85 UG8.C2
FBD_EDC5: length 18.8
  IN2 w0.117: v2(204.23,80.65) 204.63,80.25 209.26,80.25 214.19,85.19 216.85,85.19 216.99,85.33 217.39,85.33 v2(217.87,84.85)
  BOTTOM w0.102: v2(217.87,84.85) 218.32,85.3 219.08,85.3 219.43,85.65 UG9.H2 ; UG8.C13 v2(204.23,80.65)
FBD_EDC6: length 37.2
  IN2 w0.117: v2(193.83,79.85) 193.43,80.25 193.43,82.35 196.48,85.4 208.62,85.4 212.85,89.63 216.29,89.63 218.7,92.04 222.38,92.04 v2(222.77,91.65)
  BOTTOM w0.102: UG8.R13 194.05,80.07 194.05,80.07 v2(193.83,79.85) ; UG9.U6 v2(222.77,91.65)
FBD_EDC7: length 38.2
  IN2 w0.117: v2(194.63,71.85) 195.02,72.24 195.02,73.59 195.84,74.41 195.84,74.41 196.07,74.64 196.07,74.64 196.13,74.71 198.03,74.71 201.18,77.86 201.19,77.86 201.42,78.09 201.42,78.1 201.43,78.11 201.43,81.11 201.58,81.27 201.59,81.27 201.82,81.49 201.82,81.5 201.83,81.51 201.83,81.8 201.88,81.85 202.42,82.39 209.37,82.39 213.93,86.95 218.27,86.95 219.87,88.55 221.87,88.55 v2(222.07,88.75)
  BOTTOM w0.102: UG8.R2 v2(194.63,71.85) ; UG9.M5 v2(222.07,88.75)
FBD_WCK01: length 25.2
  IN2 w0.089: v2(203.42,98.05) 203.42,97.8 203.84,97.38 203.84,96.94 203.98,96.8 206.11,96.8 209.59,100.29 215.36,100.29 215.63,100.02 219.56,100.02 220.13,100.59 222.87,100.59 223.2,100.93 223.8,100.93 224.1,100.63 224.1,100.28 224.1,100.28 224.1,100.12 v2(224.17,100.05)
  BOTTOM w0.102: UG9.AJ8 v2(224.17,100.05)
  BOTTOM w0.119: UG7.P4 203.03,97.65 v2(203.42,98.05)
FBD_WCK01#: length 25.5
  IN2 w0.089: v2(223.47,100.05) 223.6,100.05 223.91,100.36 223.91,100.55 223.71,100.75 223.28,100.75 222.95,100.41 220.26,100.41 219.69,99.84 215.55,99.84 215.29,100.11 209.67,100.11 206.18,96.62 203.84,96.62 203.62,96.84 203.62,97.15 203.51,97.25 v2(203.43,97.25)
  BOTTOM w0.102: v2(223.47,100.05) 223.53,100.11 223.53,100.59 223.44,100.68 223.28,100.68 223.17,100.57 UG9.AJ7
  BOTTOM w0.119: v2(203.43,97.25) 203.19,97.01 UG7.P5
FBD_WCK23: length 39.7
  IN2 w0.089: v2(195.43,97.29) 195.43,97.03 195.85,96.61 195.85,95.95 197.99,93.8 197.99,90.43 199.86,88.57 208.05,88.57 212.73,93.25 214.81,93.25 218.04,96.48 224.06,96.48 224.16,96.57 224.16,96.89 224.17,96.91 v2(224.17,97.15)
  BOTTOM w0.102: UG7.D4 195.39,97.29 v2(195.43,97.29) ; UG9.AD8 v2(224.17,97.15)
FBD_WCK23#: length 39.8
  IN2 w0.089: v2(195.42,96.48) 195.49,96.48 195.62,96.35 195.62,95.86 197.44,94.03 197.51,93.96 197.76,93.71 197.76,90.41 199.78,88.39 208.12,88.39 212.81,93.07 214.89,93.07 218.11,96.3 224.15,96.3 224.35,96.5 224.35,96.81 224.68,97.15 v2(224.87,97.15)
  BOTTOM w0.102: UG9.AD9 v2(224.87,97.15) ; v2(195.42,96.48) 195.4,96.48 UG7.D5
FBD_WCK45: length 28.8
  IN2 w0.089: v2(222.77,86.65) 222.77,86.51 222.66,86.39 222.48,86.39 222.18,86.1 220.38,86.1 219.74,85.45 219.74,85.43 219.73,85.43 219.72,85.43 219.7,85.41 219.69,85.41 219.51,85.23 219.51,84.47 218.87,83.83 215.09,83.83 206.46,75.2 203.4,75.2 202.26,74.05 202.26,73.31 202.65,72.92 v2(202.65,72.68)
  BOTTOM w0.102: UG9.J6 v2(222.77,86.65)
  BOTTOM w0.119: v2(202.65,72.68) 203.03,73.05 UG8.D4
FBD_WCK45#: length 29
  IN2 w0.089: v2(202.65,73.48) 202.51,73.62 202.51,74.06 203.48,75.02 206.54,75.02 215.17,83.65 218.95,83.65 219.69,84.4 219.69,85.16 219.77,85.23 219.77,85.23 219.79,85.25 219.8,85.25 219.91,85.36 219.91,85.37 220.46,85.92 222.27,85.92 222.55,86.2 223.02,86.2 v2(223.47,86.65)
  BOTTOM w0.102: UG9.J7 v2(223.47,86.65)
  BOTTOM w0.119: UG8.D5 203.23,73.85 203.37,73.71 203.37,73.61 203.23,73.48 v2(202.65,73.48)
FBD_WCK67: length 41.5
  IN2 w0.089: v2(194.63,73.45) 194.63,73.58 194.23,73.98 194.23,74.68 195.17,75.62 195.86,75.62 195.86,75.62 195.94,75.62 197.98,77.66 197.98,80.65 199.02,81.69 199.02,82.71 200.01,83.7 209.17,83.7 213.33,87.86 217.65,87.86 220,90.21 223.77,90.21 223.97,90.01 223.97,89.81 223.99,89.8 223.99,89.73 v2(224.17,89.55)
  BOTTOM w0.102: UG9.P8 v2(224.17,89.55) ; UG8.P4 v2(194.63,73.45)
FBD_WCK67#: length 41.6
  IN2 w0.089: v2(223.47,89.55) 223.71,89.55 223.8,89.64 223.8,89.94 223.7,90.04 220.07,90.04 217.72,87.69 213.42,87.69 211,85.26 210.98,85.26 209.24,83.52 200.09,83.52 199.2,82.63 199.2,81.6 198.15,80.56 198.15,77.59 195.97,75.41 195.21,75.41 194.4,74.6 194.4,74.05 194.51,73.95 194.74,73.95 194.83,74.03 v2(194.83,74.33)
  BOTTOM w0.102: UG9.P7 223.37,89.85 223.47,89.75 v2(223.47,89.55)
  BOTTOM w0.119: UG8.P5 194.76,73.85 194.64,73.97 194.64,74.14 v2(194.83,74.33)
FBRTN: length 66.3
  TOP w0.203: v2(244.55,123.67) 244.92,123.3 v1(244.92,122.79) PR6025.1 PR6029.1
  IN2 w0.254: v2(280.98,142.65) 280.11,142.65 279.22,141.76 274.46,141.76 274.02,142.2 274.02,142.68 273.45,143.25 v2(273.14,143.25) 272.37,142.49 269.78,142.49 v2(267.92,140.62) 269.06,139.48 269.06,131.92 264.74,127.6 264.18,127.6 263.42,126.85 263.42,126.24 262.06,124.88 258.99,124.88 258.16,124.05 244.93,124.05 v2(244.55,123.67)
  BOTTOM w0.203: PC6010.1 PC6012.2 274.2,143.48 273.97,143.25 v2(273.14,143.25) 273.08,143.2 273.08,142.17 274.01,141.25 PU6000.32
  BOTTOM w0.254: v2(280.98,142.65) 282.41,142.65 282.72,142.34 PR6061.2 PC6015.2 ; PC6002.1 v2(267.92,140.62)
FBVDD/Q_EN: length 14.4
  TOP w0.102: v2(311.97,56.08) 311.97,56.33 312.89,57.25 PR8216.1 312.89,58.25 RG557.1 312.42,58.72 312.42,59.11 312.58,59.28 UG27.4 ; v1(316.64,61.16) 316.96,60.84 v2(316.96,60.76) 317.26,60.47 UE10.16
  IN1 w0.102: v2(316.96,60.76) 315.77,59.57 315.77,57.28 314.57,56.08 v2(311.97,56.08)
FBVDD/Q_ENP: length 91.1
  TOP w0.254: v2(311.18,57.37) 311.19,57.39 PR8216.2 ; v2(244.73,30.46) 244.73,31.01 v1(245.44,31.72) 245.83,32.11 245.83,33.17 244.86,34.13 244.86,35.57 245.88,36.59 245.88,38.27 245.56,38.59 245.56,39.23 248.97,42.64 v2(248.97,46.76)
  IN3 w0.254: v2(248.97,46.76) 254.21,46.76 255.88,45.09 271.29,45.09 273,46.8 293.68,46.8 299.16,52.28 299.16,54.68 301.55,57.07 308.4,57.07 308.69,57.37 v2(311.18,57.37)
  BOTTOM w0.203: v2(244.73,30.46) PU8200.3
  BOTTOM w0.254: v2(244.73,30.46) 244.14,29.88 PC8211.1
FBVDD_PSI: length 3.4
  TOP w0.102: v1(245.73,29.76) PR8219.2
  TOP w0.254: PR8219.2 244.04,30.5 v2(244.06,30.52)
  BOTTOM w0.203: PU8200.4 244.33,30.79 v2(244.06,30.52)
FCCM_GT: length 37.2
  IN1 w0.254: v2(122.06,144.24) 122.59,144.77 122.59,145.72 123.73,146.87 128.61,146.87 129.57,147.83 129.57,148.85 130.16,149.43 130.16,149.85 131.85,151.54 142.25,151.54 v2(142.47,151.32) 143.14,151.99 149.55,151.99 v2(150.37,151.17)
  BOTTOM w0.203: PU500.11 123.01,142.88 122.06,143.84 v2(122.06,144.24)
  BOTTOM w0.254: PR585.1 v2(142.47,151.32) ; PR594.1 150.8,150.74 v2(150.37,151.17)
FCCM_SA: length 85.2
  IN4 w0.254: v2(180.79,146.78) 180.79,147.1 179.47,148.42 177.21,148.42 176.23,147.45 174.3,147.45 173.78,147.96 169.06,147.96 168.44,147.35 165.92,147.35 165.49,147.79 165.49,149.51 163.99,151.01 155.37,151.01 152.04,154.34 143.15,154.34 139.72,150.91 126.12,150.91 124.91,149.7 124.91,147.86 122.56,145.51 122.56,143.86 124.09,142.34 124.91,142.34 125.36,141.89 125.36,140.65 126.22,139.8 129.61,139.8 130.12,139.29 v2(131.2,139.29)
  BOTTOM w0.102: v2(180.79,146.78) v1(180.79,147.29)
  BOTTOM w0.203: v2(131.2,139.29) 130.88,139.29 130.48,139.68 PU500.34
  BOTTOM w0.254: PR5006.1 181.49,146.21 180.92,146.78 v2(180.79,146.78)
FCCM_VCORE: length 60.8
  IN6 w0.254: v2(175.16,147.93) 173.2,149.89 168.4,149.89 v2(166.38,147.86) 165.42,147.86 164.44,148.85 158.46,148.85 v2(158.04,148.43) 157.7,148.77 157.7,149.61 152.15,155.16 144.34,155.16 141.1,151.92 135.22,151.92 131.64,148.34 v2(131.64,147.36)
  BOTTOM w0.102: v2(166.38,147.86) v1(166.38,148.4)
  BOTTOM w0.203: v2(131.64,147.36) 130.54,146.27 130.54,145.3 129.8,144.56 128.8,144.56 128.67,144.43 PU500.24
  BOTTOM w0.254: v2(158.04,148.43) 158.04,147.8 PR556.1 ; PR566.1 166.82,147.42 v2(166.38,147.86) ; PR576.1 v2(175.16,147.93)
FFS_INT1: length 81.6
  TOP w0.102: US1.11 185.24,68.87 v1(185.42,69.05) 185.75,69.37 188.13,69.37 188.54,68.97 188.54,67.56 188.81,67.29 188.81,67.29 189.2,66.91 189.2,66.14 190.1,65.24 190.1,60.32 190.86,59.56 193.14,59.56 193.24,59.46 v2(193.24,59.45)
  IN3 w0.089: 199.13,42.08 199.39,41.82 200.96,41.82 203.46,39.32 203.46,32.61 202.74,31.88 202.74,30.73 202.32,30.32 202.32,25.66 203.21,24.78 203.93,24.78 204.42,24.29 204.46,24.29 205.03,23.72 206.13,23.72 206.67,24.25 206.88,24.25 207.52,24.89 208.27,24.89 208.67,24.49 209.29,24.49 209.69,24.1 209.69,22.77 210.83,21.62 v2(211.15,21.62)
  IN3 w0.102: 199.13,42.08 199.04,42.18 199.04,47.68 196.49,50.23 196.49,51.17 193.26,54.39 193.26,57.74 193.65,58.13 193.65,59.06 193.25,59.45 v2(193.24,59.45)
  IN6 w0.097: v2(211.15,21.62) 211.97,21.62 213.5,23.15 214.57,23.15 216.4,24.98 217.68,24.98 218.37,25.67 218.94,25.67 219.18,25.43
  IN6 w0.102: 219.18,25.43 v2(219.3,25.3)
  BOTTOM w0.089: v2(211.15,21.62) 210.89,21.37 UH1.AN38
  BOTTOM w0.107: RP5.8 219.64,24.97 v2(219.3,25.3)
FFS_INT2: length 81.5
  TOP w0.102: v2(193.24,58.87) 193.21,58.87 192.73,58.39 190.95,58.39 v1(190.12,59.23) 189.88,59.47 189.88,65.14 188.97,66.05 188.97,66.81 188.72,67.07 188.72,67.07 187.89,67.89 QS3.3 187.89,68.93 187.68,69.15 186.44,69.15 186.24,68.94 US1.9
  IN3 w0.089: 198.57,42.08 198.57,42.01 199.21,41.37 200.48,41.37 200.77,41.08 200.77,40.18 202.54,38.41 202.54,36.61 202.93,36.22 202.93,32.58 201.16,30.81 201.16,28.93 201.96,28.12 201.96,25.52 203.06,24.42 203.78,24.42 204.87,23.33 204.87,23.14 205.41,22.6 208.07,22.6 208.69,21.97 208.69,21.82 208.69,21.4 209.05,21.04 209.55,21.04 209.8,21.29 210.34,21.29 210.97,20.67 v2(211.15,20.67)
  IN3 w0.102: 198.57,42.08 198.57,47.5 196.03,50.04 196.03,50.98 192.81,54.2 192.81,58.46 193.21,58.87 v2(193.24,58.87)
  IN6 w0.097: v2(218.7,25.3) 218.13,24.73 216.42,24.73 214.64,22.96 213.57,22.96 211.28,20.67 v2(211.15,20.67)
  BOTTOM w0.089: UH1.AN41 210.66,19.99 211.15,20.48 v2(211.15,20.67)
  BOTTOM w0.107: v2(218.7,25.3) 219.14,24.87 219.23,24.87 219.63,24.47 RP5.7
FFS_INT2_CONN: length 112
  TOP w0.102: 189.49,63.56 188.45,62.52 187.29,62.52 183.21,58.44 183.21,55.73 ; RS1.2 189.49,64.86 DS1.2
  TOP w0.107: v2(181.27,20.26) 181.27,26.67 182.04,27.44 182.04,28.98 183.21,30.16 v1(183.21,31.03) 183.21,55.73 ; RS1.2 189.49,63.56
  IN6 w0.102: v2(181.27,20.26) 180.87,19.86 160.04,19.86 157.04,16.86 129.27,16.86 123.47,11.06 v2(122.92,11.06)
  BOTTOM w0.102: v2(122.92,11.06) JHDD.20
FRAME_LOCK#: length 27.2
  IN1 w0.102: v2(215.02,119.6) 217.77,119.6 219.16,118.21 220.88,118.21 222.58,116.51 222.58,113.08 222.89,112.76 222.89,111.59 222.59,111.28 220.37,111.28 219.24,112.41 v2(219.24,112.53)
  BOTTOM w0.102: v2(215.02,119.6) 213.96,120.66 212.58,120.66 212.05,121.19 212.05,122.46 v1(212.09,122.5) 212.48,122.89 212.48,123.92 212.38,124.02 RG502.2 211.91,124.4 QG506.3
  BOTTOM w0.109: UG9.BG2 v2(219.24,112.53)
G-SYNC#: length 100.9
  TOP w0.107: v2(161.69,178.95) 161.62,179.02 JEDP.21
  IN1 w0.102: v2(161.69,178.95) 163.5,177.15 171.26,177.15 171.76,176.64 174.85,176.64 175.47,176.03 180.59,176.03 181.17,175.46 182.7,175.46 183.03,175.13 187.08,175.13 188.39,173.82 190.81,173.82 193.62,171.01 197.06,171.01 198.16,169.91 198.87,169.91 199.97,171.01 201.72,171.01 204.1,168.63 204.1,166.72 203.2,165.82 203.2,159.98 204.03,159.14 204.03,155.87 206.93,152.97 207.44,152.97 208.09,152.32 208.09,150.27 204.53,146.71 204.53,142.66 205.37,141.83 205.37,129 207.6,126.77 v2(209.09,126.77)
  BOTTOM w0.102: RG517.2 209.02,125.62 QG506.1 209.47,125.66 209.47,126.38 v2(209.09,126.77) 209.01,126.77 v1(208.59,127.18)
GC6_EVENT#: length 122.8
  IN1 w0.089: 197.08,42.08 197.54,41.62 200.38,41.62 200.92,41.08 200.92,39.66 201.45,39.13 202.47,39.13 204,37.6 204.48,37.6 204.79,37.29 204.79,33.49 206.61,31.66 208.47,31.66 209.18,30.96 209.18,29.56 210,28.73 v2(211.12,28.73)
  IN1 w0.102: v2(192.22,63.41) 191.76,62.94 191.76,60.65 190.85,59.74 190.85,57.02 192.08,55.79 192.08,50.69 195.05,47.72 195.75,47.72 196.75,46.72 196.75,42.41 197.08,42.08
  IN2 w0.102: v2(189.86,102.52) 188.68,102.52 186.97,100.81 186.97,97.04 187.38,96.63 187.38,94.04 188.57,92.85 188.57,70.15 192.22,66.49 v2(192.22,63.41)
  IN6 w0.102: v2(215.82,110.75) 213.47,110.75 211.93,109.21 205.45,109.21 203.88,107.64 203.88,106.93 199.92,102.97 190.64,102.97 190.19,102.52 v2(189.86,102.52)
  BOTTOM w0.089: UH1.AR24 211.5,28.14 v2(211.12,28.73) ; DG2.1 215.79,110.78 v2(215.82,110.75)
GC6_EVENT#_D: length 5
  BOTTOM w0.089: DG2.2 216.61,111.64 RG8.1 216.58,111.68 216.12,112.13 v1(215.18,112.13) ; 217.7,110.83 217.52,111.01 217.16,111.01 216.92,110.78
  BOTTOM w0.1: 217.7,110.83 218.95,110.83 UG9.BD1 ; 216.92,110.78 DG2.2
GC6_FB_EN: length 184.1
  TOP w0.102: QG511.1 310.18,50.96 312.9,53.68 RG561.2 313.53,53.79 v2(313.69,53.64) 313.94,53.38 v1(314.3,53.38) 314.5,53.18 315.81,53.18 316.02,52.97 318.63,52.97 319.36,52.23 320.1,52.23 320.43,52.56 320.43,57.12 320.11,57.44 UE10.9
  IN3 w0.102: v2(305.74,14.08) 306.03,13.79 306.76,13.79 307.88,14.9 309.23,14.9 309.57,15.25 310.88,15.25 313.05,17.42 313.05,22.9 312.7,23.25 312.7,25.99 310.66,28.03 310.66,31.97 309.33,33.3 309.33,38.27 309.08,38.52 309.08,40.09 309.2,40.21 309.2,43.05 309.72,43.57 309.72,44.69 309.42,44.99 309.42,49.37 311.72,51.67 312.47,51.67 313.69,52.88 v2(313.69,53.64)
  IN4 w0.089: 219.18,28.06 217.99,28.06 217.23,27.3 215.87,27.3 215.55,26.98 213.9,26.98 v2(213.33,26.41)
  IN4 w0.102: v2(305.74,14.08) 305.51,13.85 302.4,13.85 301.68,14.57 301.19,14.57 300.75,15.01 298.42,15.01 297.91,15.51 292.66,15.51 290.03,18.15 280.34,18.15 278.22,16.03 269.28,16.03 268.16,17.16 266.9,17.16 265.83,18.23 262.95,18.23 258.75,14.03 254.96,14.03 254.73,13.8 247.16,13.8 246.64,14.32 246.64,14.55 245.04,16.15 242.76,16.15 239.78,19.13 239.78,21.4 235.06,26.13 234.7,26.13 234.45,26.39 234.45,29.07 232.47,31.05 230.85,31.05 229.3,32.59 228.55,32.59 227.92,31.97 227.92,28.82 225.89,26.78 225.89,26.37 224.23,24.72 223.38,24.72 220.93,27.17 220.39,27.17 219.5,28.06 219.18,28.06
  BOTTOM w0.089: v2(213.33,26.41) 213.75,26.82 UH1.AW27
GPIO3_OC_WARN#: length 80.4
  TOP w0.102: v2(194.35,118.38) 193.68,118.38 193.28,117.98 v1(188.48,117.98) 187.82,117.98 186.24,116.4 184.91,116.4 182.12,113.61 182.12,100.06 182.51,99.68 184.15,99.68 185.83,98 185.83,96.83 v2(186.61,96.05)
  IN6 w0.102: v2(217.43,108.11) 217.43,108.03 213.72,104.31 209.83,104.31 207.34,101.82 191.11,101.82 189.01,99.71 187.84,99.71 186.61,98.48 v2(186.61,96.05)
  BOTTOM w0.089: v2(217.43,108.11) 218.39,109.06 220.68,109.06 UG9.BB4
  BOTTOM w0.102: v2(194.35,118.38) 194.13,118.61 194.13,119.22 194.4,119.49 RG522.1 195.35,120.47 QG5.1
GPIO_1: length 13.6
  TOP w0.102: v2(37.66,22.96) 37.49,22.96 v1(37.04,23.4)
  IN1 w0.254: v2(37.66,22.96) 37.66,26.73 36.01,28.38 36.01,32.42 36.58,32.98 v2(36.6,32.98)
  BOTTOM w0.107: v2(36.6,32.98) 36.32,32.71 UA1.2
  BOTTOM w0.254: v2(37.66,22.96) 37.93,23.22 DA2.2
GPU_ALERT#: length 199.3
  TOP w0.102: v2(305.76,45.69) 306.21,46.14 v1(307.55,46.14) 308.09,46.14 311.13,49.18 311.13,49.77 311.87,50.51 311.87,51.07 312.16,51.37 312.16,51.72 312.36,51.91 313.06,51.91 314.1,52.95 315.64,52.95 315.86,52.74 318.51,52.74 319.25,52 320.2,52 320.66,52.46 320.66,57.4 320.12,57.94 UE10.10
  IN4 w0.102: v2(206.19,116.55) 208.06,114.69 208.33,114.69 209.64,113.38 209.64,56.26 212.16,53.73 212.16,51.08 213.68,49.57 215.93,49.57 216.33,49.16 216.33,49.16 216.44,49.06 225.63,49.06 226.48,49.91 230.19,49.91 230.64,49.46 232.46,49.46 233.31,48.62 233.31,47.45 234.18,46.58 235.95,46.58 238.19,48.81 240.64,48.81 240.93,49.1 250.28,49.1 250.58,48.81 258.08,48.81 261.23,45.66 271.63,45.66 272.95,46.99 286.97,46.99 292.18,41.78 298.07,41.78 301.7,45.41 305.48,45.41 v2(305.76,45.69)
  BOTTOM w0.102: RE644.1 206.51,116.87 v2(206.19,116.55) 205.89,116.86 QG501.3
GPU_AUXN/DDC: length 52.8
  IN1 w0.089: v2(225.67,111.95) 225.38,111.67 225.31,111.67 225.3,111.65 225.3,111.65 225.06,111.41 224.67,111.41 224.42,111.67 224.42,115.74 219.93,120.22 214.22,120.22 213.86,119.86 212.09,119.86 211.46,120.49 209.86,120.49 209.3,121.06 207.92,121.06 207.61,120.75 207.23,120.75 206.72,121.26 204.76,121.26 204.14,121.89 202.07,121.89 201.79,122.17 198.26,122.17 197.87,122.55 197.87,123.59 197.54,123.92 197.37,123.92 v2(197.18,124.11)
  BOTTOM w0.089: RV670.1 CV425.2 190.95,131.41 190.89,131.48 190.89,131.72 190.8,131.81 190.66,131.81 190.57,131.72 190.57,126.46 191.55,125.48 191.61,125.48 192.02,125.07 192.02,125.01 193.33,123.7 196.79,123.7 196.91,123.83 196.91,124.02 197,124.11 v2(197.18,124.11)
  BOTTOM w0.101: UG9.BF11 v2(225.67,111.95)
GPU_AUXN/DDC_C: length 3
  BOTTOM w0.089: CV425.1 192.01,131.6 192.22,131.6 192.59,131.97 192.59,132.27 v3(192.79,132.47) 193.02,132.7 193.42,132.7 193.53,132.58 UV21.27
GPU_AUXP/DDC: length 52.8
  IN1 w0.089: v2(197.18,123.53) 197.37,123.72 197.46,123.72 197.68,123.5 197.68,122.47 198.17,121.97 201.7,121.97 201.98,121.69 204.05,121.69 204.68,121.06 206.64,121.06 207.15,120.56 207.69,120.56 208,120.86 209.21,120.86 209.78,120.29 211.38,120.29 212.01,119.67 213.94,119.67 214.3,120.03 215.25,120.03 215.27,120.05 219.85,120.05 224.24,115.66 224.24,111.59 224.6,111.23 225.13,111.23 225.37,111.47 225.45,111.47 v2(225.67,111.25)
  BOTTOM w0.089: RV669.1 CV424.2 191.23,131.99 190.57,131.99 190.39,131.8 190.39,126.38 v3(191.66,125.12) 193.25,123.53 v2(197.18,123.53)
  BOTTOM w0.101: UG9.BE11 v2(225.67,111.25)
GPU_AUXP/DDC_C: length 3
  BOTTOM w0.089: CV424.1 192.02,131.78 192.15,131.78 192.41,132.05 192.41,132.42 192.87,132.87 193.43,132.87 193.54,132.98 UV21.28
GPU_B+: length 340.8
  IN2 w0.508: 155.2,12.73 152.83,15.1 128.21,15.1 127.37,14.26 119.71,14.26 119.13,13.68
  IN2 w1.524: 224.54,7.72 224.2,8.06 208.64,8.06 207.34,6.77 207.34,6.76 ; 207.02,5.11 223.94,5.11
  IN2 w2.54: 118.84,9.07 122.29,5.62 150.31,5.62 155.71,11.02 157.04,11.02
  IN2 w3.048: 184.79,8.29 187.21,5.87 204.42,5.87 204.48,5.81
  IN3 w1.524: 207.34,6.77 208.41,7.84 223.97,7.84 ; 207.02,5.11 223.94,5.11
  IN3 w3.048: 117.74,9.35 121.46,5.62 148.79,5.62 154.31,11.14 155.52,11.14 ; 205.18,5.81 187.27,5.81 184.79,8.29
  IN4 w1.524: 207.02,5.11 223.94,5.11 ; 224.23,7.81 208.42,7.81 207.46,6.86
  IN4 w2.54: 118.93,8.66 121.72,5.87 150.63,5.87 156.47,11.72 168.79,11.72
  IN4 w3.048: 184.79,8.29 187.18,5.9 204.96,5.9 204.99,5.87
  vias: v1(96.63,17.6) v2(102.37,73.06) v2(102.37,72.42) v2(102.37,71.79) v2(102.37,71.15) v2(102.37,70.52) v2(103.01,73.06) v2(103.01,72.42) v2(103.01,71.79) v2(103.01,71.15) v2(103.01,70.52) v2(103.64,73.06) v2(103.64,72.42) v2(103.64,71.79) v2(103.64,71.15) v2(103.64,70.52) v2(115.9,13.93) v2(115.9,13.34) v2(115.9,12.76) v2(116.53,13.93) v2(116.53,13.34) v2(116.53,12.76) v2(116.53,12.17) v2(116.53,11.59) v2(117.17,13.93) v2(117.17,13.34) v2(117.17,12.76) v2(117.17,12.17) v2(117.17,11.59) v2(117.8,13.93) v2(117.8,13.34) v2(117.8,12.76) v2(117.8,12.17) v2(117.8,11.59) v2(118.44,13.93) v2(118.44,13.34) v2(118.44,12.76) v2(118.44,12.17) v2(118.44,11.59) v2(159.66,150.53) v2(159.66,149.94) v2(160.24,150.53) v2(160.24,149.94) v2(160.83,150.53) v2(160.83,149.94) v2(161.41,150.53) v2(161.41,149.94) v2(162,150.53) v2(162,149.94) v2(162.58,150.53) v2(162.58,149.94) v2(163.17,150.53) v2(163.17,149.94) v2(182.19,147.61) v2(182.89,147.61) v2(198.51,146.59) v2(198.51,145.83) v2(198.51,145.19) v2(199.02,146.21) v2(199.14,145.19) v2(199.14,144.56) v2(199.53,145.76) v2(199.78,145.19) v2(199.78,144.56) v2(262.06,22.41) v2(262.07,23.02) v2(262.09,21.8) v2(262.7,23.04) v2(262.7,22.46) v2(262.72,21.8) v2(263.28,23.04) v2(263.31,22.46) v2(263.33,21.8) v2(263.86,23.03) v2(264.46,23.03) v2(269.5,32.24) v2(269.5,31.66) v2(269.5,31.07) v2(270.09,32.24) v2(270.09,31.66) v2(270.09,31.07) v2(270.67,32.24) v2(270.67,31.66) v2(270.67,31.07) v2(273,8.6) v2(273,8.02) v2(273.58,9.19) v2(273.58,8.6) v2(273.58,8.02) v2(274.16,9.19) v2(274.16,8.6) v2(274.16,8.02) v2(274.75,9.19) v2(274.75,8.6) v2(274.75,8.02) v2(275.33,9.19) v2(275.33,8.6) v2(275.33,8.02) v2(275.92,9.19) v2(275.92,8.6) v2(275.92,8.02) v2(276.55,8.6)
GPU_BUFRST#: length 1
  TOP w0.089: T6.1 224.52,112.2 v2(224.87,112.55)
  BOTTOM w0.125: UG9.BF9 v2(224.87,112.55)
GPU_DPC_AUX: length 1.9
  BOTTOM w0.089: RV619.1 225.61,159.01 225.61,159.18 225.7,159.26 226.02,159.26 226.22,159.47 226.22,159.65 CV24.2
GPU_DPC_AUX#: length 1.9
  BOTTOM w0.089: RV618.1 225.43,159.01 225.43,159.25 225.63,159.44 225.94,159.44 226.04,159.54 226.04,159.66 CV25.2
GPU_FAN_FB: length 66.6
  TOP w0.102: v2(291.15,72.99) 291.05,72.89 DF2.2 290.95,71.98 288.11,71.98 287.69,72.4 RF4.1
  TOP w0.107: UE5.29 294.34,24.89 294.66,25.22 294.66,27.63 293.19,29.1 293.19,32.87 292.49,33.57 292.49,37.79 v1(292.64,37.94) 292.87,38.17 v2(292.87,38.39)
  BOTTOM w0.102: v2(291.15,72.99) 294.48,69.66 295.85,69.66 297.82,67.68 297.82,63.68 298.76,62.75 298.76,62.31 299.36,61.71 299.36,57.05 299.49,56.92 299.49,46.27 298.97,45.75 298.97,40.16 297.7,38.89 295.6,38.89 295.35,38.64 295.35,38.13 295,37.78 293.48,37.78 v2(292.87,38.39)
GPU_FAN_PWM: length 66.9
  TOP w0.102: JFAN2.2 v2(289.62,75.03) 289.53,74.94 287.94,74.94 RF5.1
  TOP w0.107: UE5.27 295.14,24.86 295.33,25.05 295.33,27.75 294.84,28.24 294.84,30 294.06,30.78 v1(294.06,31.1) 294.06,32.33 292.72,33.66 292.72,37.55 293.51,38.33 v2(293.51,38.39)
  BOTTOM w0.102: v2(289.62,75.03) 289.62,73.95 294.13,69.43 295.75,69.43 297.6,67.59 297.6,63.59 298.53,62.65 298.53,62.21 299.13,61.61 299.13,56.95 299.26,56.83 299.26,46.37 298.74,45.85 298.74,40.26 297.6,39.12 295.51,39.12 295.12,38.73 295.12,38.22 294.9,38.01 293.89,38.01 v2(293.51,38.39)
GPU_GC6_FB_EN: length 306.3
  TOP w0.089: RG563.1 212.31,25.99 v2(211.86,26.45) 210.64,27.67 210.64,28.61 v1(210.27,28.98) 210,29.24 209.3,29.24 208.99,29.56 208.99,31.34 208.42,31.91 207.91,31.91 207.43,32.38 207.43,38.4 209.18,40.14 209.18,42.08
  TOP w0.102: RG553.1 212.11,154.69 211.91,154.49 211.09,154.49 v2(210.92,154.66) ; v2(204.97,54.32) 206.06,53.23 206.87,53.23 209.75,50.35 209.75,42.65 209.18,42.08 ; UG27.1 310.55,60.58 310.31,60.33 310.31,60.05 v2(309.75,59.49) ; v2(308.66,55) 308.66,53.74 308.92,53.47 309.28,53.47 309.53,53.22 QG511.3
  IN1 w0.102: v2(309.75,59.49) 309.75,57.97 310.35,57.37 310.35,56.27 309.08,55 v2(308.66,55)
  IN3 w0.102: v2(212.01,59.28) 207.06,54.32 v2(204.97,54.32)
  IN4 w0.102: v2(226.58,25.56) 226.13,25.11 224.95,25.11 224.33,24.49 223.29,24.49 221.39,26.38 218.19,26.38 217.62,26.96 216.1,26.96 215.03,25.89 212.42,25.89 v2(211.86,26.45) ; v2(309.75,59.49) 308.96,58.71 298.08,58.71 296.37,57 296.37,50.05 295.36,49.04 273.47,49.04 271.7,50.82 262.54,50.82 262.09,50.36 251.08,50.36 250.88,50.55 240.66,50.55 240.28,50.93 238.26,50.93 237.85,50.53 233.92,50.53 233.49,50.97 233.49,51.35 232.1,52.74 230.99,52.74 230.43,52.18 226.44,52.18 225.16,50.9 222.34,50.9 222.08,51.17 214.54,51.17 213.98,51.73 213.98,54.98 211.62,57.35 211.62,58.88 v2(212.01,59.28) 211.62,59.67 211.62,104.97 214.08,107.44 214.99,107.44 v2(215.21,107.66) 215.21,112.64 215.76,113.19 215.76,115.56 216.47,116.27 216.47,118.12 216.92,118.58 216.92,123.7 215.82,124.81 211.82,124.81 210.19,126.44 210.19,126.97 210.85,127.62 210.85,128.78 209.99,129.63 209.12,129.63 208.47,130.28 208.47,132.42 209.8,133.76 209.8,145.64 209.43,146.02 209.43,146.48 208.3,147.61 208.3,152.04 v2(210.92,154.66)
  BOTTOM w0.089: UG9.BB5 221.43,109.11 221.43,108.49 221.31,108.36 220.8,108.36 220.61,108.17 220.61,108.08 220.19,107.66 v2(215.21,107.66)
  BOTTOM w0.102: RG22.1 226.3,25.28 v2(226.58,25.56)
