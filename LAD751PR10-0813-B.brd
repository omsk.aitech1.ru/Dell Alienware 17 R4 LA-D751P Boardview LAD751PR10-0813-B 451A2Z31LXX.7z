# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D38: length 65.7
  IN1 w0.081: v2(156.46,43.78) 155.82,44.43 155.82,45.2 155.92,45.3 156.1,45.3 156.2,45.4 156.2,45.59 156.1,45.69 155.92,45.69 155.82,45.79 155.82,45.99 155.92,46.09 156.03,46.09 156.13,46.19 156.13,46.39 156.03,46.49 155.92,46.49 155.82,46.59 155.82,47.29 156.68,48.15 156.68,50.58 157.36,51.26 157.36,68.57 160.59,71.79 160.59,79.61 160.92,79.94 160.92,81.45 160.82,81.55 160.69,81.55 160.59,81.65 160.59,81.84 160.69,81.94 160.82,81.94 160.92,82.04 160.92,82.24 160.82,82.34 160.69,82.34 160.59,82.44 160.59,82.64 160.69,82.74 160.82,82.74 160.92,82.83 160.92,83.03 160.82,83.13 160.69,83.13 160.59,83.23 160.59,83.43 160.69,83.53 160.82,83.53 160.92,83.63 160.92,88.14 158.2,90.85 158.2,97.04 157.61,97.63 157.61,98.1 v2(157.98,98.47)
  BOTTOM w0.076: v2(157.98,98.47) CPU1.AC8
  BOTTOM w0.114: v2(156.46,43.78) 155.84,43.78 155.46,44.16 155.46,45.91 155.69,46.14 JDIMM2.169
DDR_B_D39: length 65.6
  IN1 w0.081: v2(157.98,97.91) 157.98,97.55 158.41,97.13 158.41,90.9 161.22,88.09 161.22,79.49 161.12,79.39 160.99,79.39 160.89,79.29 160.89,79.09 160.99,78.99 161.12,78.99 161.22,78.89 161.22,78.69 161.12,78.59 160.99,78.59 160.89,78.5 160.89,78.3 160.99,78.2 161.12,78.2 161.22,78.1 161.22,77.9 161.12,77.8 160.99,77.8 160.89,77.7 160.89,77.5 160.99,77.41 161.12,77.41 161.22,77.31 161.22,77.11 161.12,77.01 160.99,77.01 160.89,76.91 160.89,76.71 160.99,76.61 161.12,76.61 161.22,76.51 161.22,76.32 161.12,76.22 160.99,76.22 160.89,76.12 160.89,75.92 160.99,75.82 161.12,75.82 161.22,75.72 161.22,75.52 161.12,75.42 160.99,75.42 160.89,75.33 160.89,75.13 160.99,75.03 161.12,75.03 161.22,74.93 161.22,74.73 161.12,74.63 160.99,74.63 160.89,74.53 160.89,74.33 160.99,74.24 161.12,74.24 161.22,74.14 161.22,73.94 161.12,73.84 160.99,73.84 160.89,73.74 160.89,73.54 160.99,73.44 161.12,73.44 161.22,73.34 161.22,73.15 161.12,73.05 160.99,73.05 160.89,72.95 160.89,72.75 160.99,72.65 161.12,72.65 161.22,72.55 161.22,72 157.67,68.44 157.67,55.23 157.77,55.13 157.92,55.13 158.02,55.03 158.02,54.83 157.92,54.73 157.77,54.73 157.67,54.64 157.67,54.44 157.77,54.34 157.92,54.34 158.02,54.24 158.02,54.04 157.92,53.94 157.77,53.94 157.67,53.84 157.67,51.65 157.77,51.55 157.92,51.55 158.02,51.45 158.02,51.26 157.92,51.16 157.77,51.16 157.67,51.06 157.67,50.42 156.98,49.74 156.98,48.02 156.41,47.45 156.41,46.61 156.51,46.51 156.69,46.51 156.79,46.42 156.79,46.23 156.69,46.13 156.49,46.13 156.39,46.03 156.39,45.83 156.49,45.73 156.82,45.73 156.92,45.64 156.92,45.43 156.82,45.34 156.56,45.34 156.46,45.24 v2(156.46,45.05)
  BOTTOM w0.114: JDIMM2.173 156.69,45.72 156.46,45.49 v2(156.46,45.05)
  BOTTOM w0.127: v2(157.98,97.91) 157.56,97.5 CPU1.AC7
DDR_B_D40: length 66.2
  IN1 w0.081: v2(160.72,97.93) 160.33,97.54 160.33,97.25 160.8,96.79 160.8,92 164.84,87.96 164.84,70.64 161.91,67.7 161.91,64.55 162.01,64.45 162.49,64.45 162.59,64.36 162.59,64.11 162.49,64.01 162.01,64.01 161.91,63.92 161.91,63.67 162.01,63.57 162.49,63.57 162.59,63.47 162.59,63.22 162.49,63.13 161.99,63.13 161.91,63.04 161.91,62.8 162.01,62.71 162.49,62.71 162.59,62.61 162.59,60.68 162.49,60.59 162.01,60.59 161.91,60.49 161.91,60.29 162.01,60.19 162.49,60.19 162.59,60.09 162.59,59.89 162.49,59.79 162.01,59.79 161.91,59.69 161.91,59.5 162.01,59.4 162.49,59.4 162.59,59.3 162.59,58.56 162.8,58.35 162.8,53.83 162.52,53.55 162.52,48.07 162.42,47.97 162.16,47.97 162.06,47.87 162.06,47.67 162.16,47.57 162.42,47.57 162.52,47.47 162.52,47.25 162.42,47.15 161.84,47.15 161.74,47.05 161.74,46.84 161.84,46.74 162.26,46.74 162.36,46.65 162.36,46.38 161.66,45.69 v2(161.66,45.13)
  BOTTOM w0.076: v2(160.72,97.93) 160.51,98.15 CPU1.W8
  BOTTOM w0.114: v2(161.66,45.13) 161.2,45.6 JDIMM2.191
DDR_B_D41: length 66
  IN1 w0.081: v2(161.66,43.86) 161.93,43.6 162.13,43.6 162.25,43.72 162.25,45.85 162.82,46.42 162.82,53.42 163.1,53.7 163.1,58.49 162.89,58.71 162.89,64.66 162.79,64.75 162.31,64.75 162.21,64.85 162.21,65.05 162.31,65.15 162.79,65.15 162.89,65.25 162.89,65.45 162.79,65.55 162.31,65.55 162.21,65.65 162.21,65.84 162.31,65.94 162.79,65.94 162.89,66.04 162.89,66.24 162.79,66.34 162.31,66.34 162.21,66.44 162.21,66.64 162.31,66.74 162.79,66.74 162.89,66.83 162.89,67.03 162.79,67.13 162.4,67.13 162.31,67.23 162.31,67.43 162.4,67.53 162.79,67.53 162.89,67.63 162.89,68.1 165.14,70.36 165.14,87.91 160.98,92.08 160.98,97.12 v2(160.72,97.37)
  BOTTOM w0.076: v2(160.72,97.37) 160.6,97.5 CPU1.W7
  BOTTOM w0.114: v2(161.66,43.86) 162.2,44.39 JDIMM2.195
DDR_B_D42: length 66.6
  IN1 w0.081: v2(165.34,43.8) 164.85,44.28 164.85,47.82 165.25,48.22 165.25,53.4 165.75,53.89 165.75,58.03 165.24,58.54 165.24,65.11 165.34,65.2 165.65,65.2 165.75,65.3 165.75,65.49 165.65,65.59 165.34,65.59 165.24,65.69 165.24,65.88 165.34,65.98 165.65,65.98 165.75,66.07 165.75,66.27 165.65,66.36 165.34,66.36 165.24,66.46 165.24,66.65 165.34,66.75 165.65,66.75 165.75,66.85 165.75,67.04 165.65,67.13 165.34,67.13 165.24,67.23 165.24,67.46 166.95,69.17 166.95,87.66 167.08,87.79 167.08,88.29 162.54,92.83 162.54,96.97 162.2,97.31 162.2,98.03 162,98.22 162,99.37 v2(161.6,99.77)
  BOTTOM w0.076: v2(161.6,99.77) 161.18,99.47 CPU1.V10
  BOTTOM w0.114: v2(165.34,43.8) 164.19,44.94 JDIMM2.203
DDR_B_D43: length 66.3
  IN1 w0.081: v2(161.61,100.42) 162.18,99.85 162.18,98.38 162.49,98.08 162.49,97.27 162.72,97.04 162.72,92.91 167.33,88.29 167.33,87.98 167.71,87.6 167.71,85.62 167.32,85.23 167.32,69.11 166.05,67.84 166.05,64.9 165.95,64.81 165.64,64.81 165.54,64.71 165.54,64.52 165.64,64.42 165.95,64.42 166.05,64.33 166.05,64.13 165.95,64.04 165.64,64.04 165.54,63.94 165.54,63.75 165.64,63.65 165.95,63.65 166.05,63.55 166.05,63.33 165.95,63.23 165.64,63.23 165.54,63.14 165.54,62.94 165.64,62.85 165.95,62.85 166.05,62.75 166.05,62.56 165.95,62.46 165.64,62.46 165.54,62.36 165.54,62.17 165.64,62.08 165.95,62.08 166.05,61.98 166.05,61.79 165.95,61.69 165.64,61.69 165.54,61.59 165.54,61.4 165.64,61.3 165.95,61.3 166.05,61.21 166.05,60.98 165.95,60.89 165.64,60.89 165.54,60.79 165.54,60.6 165.64,60.5 165.95,60.5 166.05,60.4 166.05,53.76 165.55,53.27 165.55,48.04 165.49,47.97 165.49,45.22 v2(165.34,45.07)
  BOTTOM w0.076: v2(161.61,100.42) 161.18,100.12 CPU1.V11
  BOTTOM w0.114: v2(165.34,45.07) 165.19,45.21 JDIMM2.207
DDR_B_D44: length 66.5
  IN1 w0.081: v2(160.72,99.77) 160.29,99.34 160.29,98.14 160.14,97.99 160.14,97.19 160.6,96.74 160.6,91.95 164.54,88.01 164.54,70.76 161.61,67.83 161.61,62.65 162.15,62.11 162.15,61.14 161.87,60.87 161.72,60.87 161.61,60.76 161.61,58.99 162.5,58.1 162.5,53.95 162.22,53.67 162.22,48.45 161.26,47.5 161.26,43 v2(161.66,42.59)
  BOTTOM w0.076: v2(160.72,99.77) 160.4,100.1 CPU1.W11
  BOTTOM w0.114: v2(161.66,42.59) 160.94,41.87 JDIMM2.190
DDR_B_D45: length 66.5
  IN1 w0.081: v2(161.66,41.32) 160.96,42.03 160.96,48.02 161.21,48.27 161.21,49.69 161.92,50.39 161.92,52.06 161.82,52.15 161.56,52.15 161.46,52.25 161.46,52.44 161.56,52.54 161.82,52.54 161.92,52.64 161.92,52.83 161.82,52.93 161.56,52.93 161.46,53.02 161.46,53.22 161.56,53.31 161.82,53.31 161.92,53.41 161.92,53.8 162.19,54.08 162.19,57.97 161.31,58.86 161.31,67.95 164.24,70.88 164.24,88.06 160.39,91.9 160.39,96.69 159.96,97.12 159.96,99.09 v2(159.82,99.23)
  BOTTOM w0.076: v2(159.82,99.23) 160.04,99.45 CPU1.W10
  BOTTOM w0.114: JDIMM2.194 161.94,41.04 v2(161.66,41.32)
DDR_B_D46: length 66.5
  IN1 w0.081: v2(165.34,41.26) 164.52,41.26 164.09,41.69 164.09,47.91 164.62,48.44 164.62,59.68 164.09,60.21 164.09,64.04 164.19,64.13 164.44,64.13 164.54,64.23 164.54,64.42 164.44,64.52 164.19,64.52 164.09,64.62 164.09,64.81 164.19,64.91 164.44,64.91 164.54,65 164.54,65.2 164.44,65.29 164.19,65.29 164.09,65.39 164.09,65.58 164.19,65.68 164.44,65.68 164.54,65.78 164.54,65.97 164.44,66.06 164.19,66.06 164.09,66.16 164.09,66.35 164.19,66.45 164.44,66.45 164.54,66.55 164.54,66.74 164.44,66.84 164.19,66.84 164.09,66.93 164.09,67.16 166.35,69.42 166.35,87.67 161.55,92.47 161.55,97.73 v2(161.64,97.82)
  BOTTOM w0.076: v2(161.64,97.82) CPU1.V7
  BOTTOM w0.114: JDIMM2.208 165.44,41.15 v2(165.34,41.26)
DDR_B_D47: length 66.5
  IN1 w0.081: v2(161.64,98.47) 161.64,98.34 162.02,97.96 162.02,97.22 162.35,96.9 162.35,92.77 166.89,88.23 166.89,87.85 166.65,87.61 166.65,69.29 164.94,67.58 164.94,63.93 164.85,63.84 164.49,63.84 164.39,63.74 164.39,63.55 164.49,63.45 164.85,63.45 164.94,63.35 164.94,63.16 164.85,63.07 164.49,63.07 164.39,62.97 164.39,62.78 164.49,62.68 164.85,62.68 164.94,62.58 164.94,60.91 164.85,60.81 164.51,60.81 164.41,60.71 164.41,60.52 164.51,60.42 164.82,60.42 164.92,60.33 164.92,48.31 164.47,47.87 164.47,43.39 v2(165.34,42.53)
  BOTTOM w0.076: v2(161.64,98.47) CPU1.V8
  BOTTOM w0.114: JDIMM2.204 164.44,41.63 v2(165.34,42.53)
DDR_B_D48: length 65.7
  IN1 w0.081: v2(163.47,100.42) 163.07,100.03 163.07,99.63 162.92,99.48 162.92,98.3 162.74,98.12 162.74,97.48 163.1,97.13 163.1,92.78 168.05,87.83 168.05,67.55 166.78,66.29 166.78,52.95 166.72,52.88 166.72,48.26 166.25,47.79 166.25,42.25 v2(167.18,41.32)
  BOTTOM w0.076: v2(163.47,100.42) CPU1.R11
  BOTTOM w0.114: v2(167.18,41.32) 167.44,41.06 JDIMM2.216
DDR_B_D49: length 66
  IN1 w0.081: v2(164.38,100.42) 164.93,99.88 164.93,98.82 165.1,98.64 165.1,96.61 165.66,96.05 165.66,93.4 170.63,88.42 170.63,88.28 171.12,87.8 171.12,84.92 171.86,84.18 171.86,59.23 171.81,59.19 171.81,53.62 171.17,52.97 171.17,46.69 171.51,46.35 171.51,41.96 v2(170.8,41.26)
  BOTTOM w0.076: v2(164.38,100.42) CPU1.P11
  BOTTOM w0.114: JDIMM2.228 170.44,40.9 v2(170.8,41.26)
DDR_B_D50: length 66.2
  IN1 w0.081: v2(170.8,43.8) 170.39,43.8 170.25,43.66 170.25,42.58 170.13,42.45 169.78,42.45 169.68,42.55 169.68,44.82 170.06,45.2 170.06,46.26 169.55,46.77 169.55,48.12 169.89,48.46 169.89,49.3 169.79,49.4 169.65,49.4 169.55,49.5 169.55,49.7 169.65,49.8 169.79,49.8 169.89,49.9 169.89,50.45 170.26,50.82 170.26,51.7 169.68,52.28 169.68,54.01 170.4,54.72 170.4,67.96 170.26,68.1 170.26,87.6 169.87,87.99 169.87,88.43 165.01,93.29 165.01,95.94 164.38,96.58 v2(164.38,97.82)
  BOTTOM w0.076: v2(164.38,97.82) CPU1.P7
  BOTTOM w0.114: v2(170.8,43.8) 169.69,44.9 JDIMM2.225
DDR_B_D51: length 65.4
  IN1 w0.081: v2(167.18,45.13) 166.89,45.43 166.89,46.22 167.05,46.39 167.87,46.39 167.97,46.49 167.97,46.7 167.87,46.8 167.27,46.8 167.17,46.9 167.17,47.09 167.27,47.19 167.87,47.19 167.97,47.29 167.97,47.49 167.87,47.59 167.52,47.59 167.42,47.69 167.42,47.89 167.52,47.98 167.87,47.98 167.97,48.08 167.97,48.83 167.87,48.93 167.52,48.93 167.42,49.03 167.42,49.23 167.52,49.33 167.71,49.33 167.97,49.59 167.97,57.56 168.09,57.68 168.09,62.66 168.19,62.76 168.36,62.76 168.46,62.85 168.46,63.04 168.36,63.14 168.19,63.14 168.09,63.24 168.09,63.43 168.19,63.53 168.36,63.53 168.46,63.62 168.46,63.82 168.36,63.91 168.19,63.91 168.09,64.01 168.09,64.24 168.19,64.34 168.35,64.34 168.45,64.43 168.45,64.62 168.35,64.72 168.19,64.72 168.09,64.82 168.09,65.01 168.19,65.11 168.35,65.11 168.45,65.2 168.45,65.4 168.35,65.49 168.19,65.49 168.09,65.59 168.09,65.78 168.19,65.88 168.35,65.88 168.45,65.98 168.45,66.17 168.35,66.27 168.19,66.27 168.09,66.36 168.09,66.56 168.19,66.65 168.35,66.65 168.45,66.75 168.45,67.11 168.76,67.41 168.76,87.62 163.45,92.92 163.45,97.27 163.1,97.63 163.1,97.97 163.47,98.34 v2(163.47,98.47)
  BOTTOM w0.076: v2(163.47,98.47) CPU1.R8
  BOTTOM w0.114: JDIMM2.215 167.19,46.07 v2(167.18,45.13)
DDR_B_D52: length 66.1
  IN1 w0.081: v2(167.18,43.86) 166.55,44.49 166.55,47.67 167.12,48.24 167.12,50.82 167.22,50.92 167.6,50.92 167.67,51 167.67,51.25 167.57,51.35 167.11,51.35 167.02,51.45 167.02,51.64 167.11,51.74 167.57,51.74 167.67,51.84 167.67,52.04 167.57,52.14 167.11,52.14 167.02,52.24 167.02,52.44 167.11,52.54 167.57,52.54 167.67,52.63 167.67,57.9 167.79,58.02 167.79,66.87 168.35,67.43 168.35,70.32 168.35,70.32 168.35,87.78 163.28,92.85 163.28,97.2 162.92,97.56 162.92,98.05 163.1,98.23 163.1,99.4 v2(163.47,99.77)
  BOTTOM w0.076: v2(163.47,99.77) CPU1.R10
  BOTTOM w0.114: JDIMM2.211 166.19,44.85 v2(167.18,43.86)
DDR_B_D53: length 65.8
  IN1 w0.081: v2(170.8,42.53) 171.21,42.93 171.21,46.22 170.87,46.56 170.87,53.1 171.51,53.74 171.51,58.46 171,58.97 171,67.33 171.51,67.84 171.51,84.13 170.83,84.8 170.83,87.68 170.25,88.26 170.25,88.55 165.42,93.38 165.42,96.04 164.93,96.53 164.93,98.57 164.75,98.75 164.75,99.4 v2(164.38,99.77)
  BOTTOM w0.076: v2(164.38,99.77) CPU1.P10
  BOTTOM w0.114: JDIMM2.224 169.44,41.17 v2(170.8,42.53)
DDR_B_D54: length 65.7
  IN1 w0.081: v2(163.47,97.82) 163.63,97.66 163.63,93 169.06,87.57 169.06,67.29 168.76,66.99 168.76,62.46 168.66,62.36 168.49,62.36 168.39,62.27 168.39,62.07 168.49,61.98 168.66,61.98 168.76,61.88 168.76,61.69 168.66,61.59 168.49,61.59 168.39,61.49 168.39,61.3 168.49,61.2 168.66,61.2 168.76,61.11 168.76,60.91 168.66,60.82 168.49,60.82 168.39,60.72 168.39,60.53 168.49,60.43 168.66,60.43 168.76,60.34 168.76,60.14 168.66,60.05 168.51,60.05 168.39,59.93 168.39,59.7 168.49,59.61 168.63,59.61 168.73,59.51 168.73,59.32 168.63,59.22 168.49,59.22 168.39,59.13 168.39,58.9 168.49,58.81 168.7,58.81 168.79,58.71 168.79,58.52 168.7,58.42 168.49,58.42 168.39,58.32 168.39,57.55 168.27,57.43 168.27,45.97 167.71,45.41 167.71,42.7 167.6,42.59 v2(167.18,42.59)
  BOTTOM w0.076: v2(163.47,97.82) CPU1.R7
  BOTTOM w0.114: JDIMM2.212 166.44,41.85 v2(167.18,42.59)
DDR_B_D55: length 65.4
  IN1 w0.081: v2(164.38,98.47) 164.75,98.1 164.75,96.46 165.22,95.99 165.22,93.34 170.05,88.5 170.05,88.06 170.55,87.56 170.55,68.23 170.7,68.08 170.7,58.83 171.21,58.32 171.21,53.89 170.97,53.65 170.09,53.65 170,53.56 170,53.29 170.09,53.2 170.47,53.2 170.56,53.1 170.56,52.84 170.47,52.74 170.16,52.74 170.06,52.64 170.06,52.39 170.16,52.29 170.44,52.29 170.56,52.16 170.56,49.81 170.47,49.71 170.29,49.71 170.19,49.62 170.19,49.42 170.29,49.32 170.47,49.32 170.56,49.22 170.56,49.02 170.47,48.92 170.29,48.92 170.19,48.82 170.19,48.62 170.29,48.53 170.47,48.53 170.56,48.43 170.56,48.14 170.47,48.04 169.95,48.04 169.85,47.94 169.85,47.74 169.95,47.64 170.47,47.64 170.56,47.54 170.56,47.35 170.47,47.25 169.95,47.25 169.85,47.15 169.85,46.95 169.95,46.85 170.33,46.85 170.51,46.67 170.51,46.11 170.67,45.95 170.81,45.95 170.91,45.85 170.91,45.66 170.81,45.56 170.54,45.56 170.44,45.46 170.44,45.18 170.56,45.07 v2(170.8,45.07)
  BOTTOM w0.076: v2(164.38,98.47) CPU1.P8
  BOTTOM w0.114: v2(170.8,45.07) 170.69,45.17 JDIMM2.229
DDR_B_D56: length 67.8
  IN1 w0.081: v2(176.83,43.8) 177.66,44.62 177.66,53.14 177.47,53.33 177.47,59.57 177.9,60 177.9,62.74 176.35,64.29 176.35,69.76 175.93,70.18 175.93,85.47 174.61,86.8 174.61,90.03 172.41,92.23 170.56,92.23 169.74,93.05 169.74,93.87 169.97,94.1 169.97,94.78 169.41,95.34 169.41,96.76 168.47,97.7 168.47,97.96 167.69,98.74 167.69,99.5 167.56,99.63 167.56,99.95 v2(167.09,100.42)
  BOTTOM w0.076: v2(167.09,100.42) CPU1.L11
  BOTTOM w0.114: v2(176.83,43.8) 174.69,45.94 JDIMM2.245
DDR_B_D57: length 67.7
  IN1 w0.081: v2(166.21,100.42) 165.66,99.87 165.66,98.9 165.55,98.79 165.55,96.51 166.01,96.05 166.01,93.45 169.44,90.01 169.6,90.01 171.61,88.01 171.61,85.12 172.59,84.14 172.59,61.13 172.85,60.88 173.11,60.88 173.21,60.78 173.21,60.59 173.11,60.49 172.85,60.49 172.75,60.39 172.75,60.2 172.85,60.1 173.11,60.1 173.21,60.01 173.21,59.81 173.11,59.72 172.85,59.72 172.75,59.62 172.75,58.6 172.75,58.6 172.75,53.51 172.16,52.92 172.16,46.69 172.4,46.45 172.4,43.86 172.67,43.59 172.67,41.74 v2(173.15,41.26)
  BOTTOM w0.076: v2(166.21,100.42) CPU1.M11
  BOTTOM w0.114: JDIMM2.236 172.44,40.55 v2(173.15,41.26)
DDR_B_D58: length 67.9
  IN1 w0.081: v2(167.08,97.91) 167.08,97.67 168.16,96.58 168.16,93.87 170.33,91.7 171.67,91.7 173.76,89.61 173.76,86.44 175.08,85.12 175.08,69.83 175.49,69.42 175.49,63.95 176.49,62.95 176.49,60.24 175.97,59.72 175.97,52.2 175.87,52.1 175.55,52.1 175.45,52 175.45,51.8 175.55,51.7 175.87,51.7 175.96,51.6 175.96,51.4 175.87,51.31 175.55,51.31 175.45,51.21 175.45,51.01 175.55,50.91 175.87,50.91 175.96,50.81 175.96,50.1 175.87,50 175.49,50 175.4,49.9 175.4,49.7 175.49,49.6 175.87,49.6 175.97,49.5 175.97,42.12 v2(176.83,41.26)
  BOTTOM w0.076: v2(167.08,97.91) 166.59,97.55 CPU1.L7
  BOTTOM w0.114: JDIMM2.250 175.95,39 175.95,40.69 176.51,41.26 v2(176.83,41.26)
DDR_B_D59: length 68.2
  IN1 w0.081: v2(173.15,42.53) 173.56,42.93 173.56,44.12 173.87,44.43 173.87,52.61 174.32,53.05 174.32,56.56 174.42,56.66 174.6,56.66 174.7,56.76 174.7,56.96 174.6,57.06 174.4,57.06 174.3,57.16 174.3,57.35 174.4,57.45 174.6,57.45 174.7,57.54 174.7,57.74 174.6,57.83 174.4,57.83 174.3,57.93 174.3,58.12 174.4,58.22 174.6,58.22 174.7,58.31 174.7,58.51 174.6,58.6 174.4,58.6 174.3,58.7 174.3,58.89 174.4,58.99 174.6,58.99 174.7,59.09 174.7,59.28 174.6,59.38 174.4,59.38 174.3,59.47 174.3,59.67 174.4,59.76 174.6,59.76 174.7,59.86 174.7,60.05 174.6,60.15 174.4,60.15 174.3,60.25 174.3,60.44 174.4,60.53 174.6,60.53 174.7,60.63 174.7,60.85 174.6,60.95 174.4,60.95 174.3,61.05 174.3,61.24 174.4,61.34 174.6,61.34 174.7,61.43 174.7,63.11 173.95,63.87 173.95,84.03 172.55,85.42 172.55,89.16 170.81,90.9 170.38,90.9 167.55,93.73 167.55,96.43 167.11,96.87 166.93,96.87 166.14,97.67 v2(166.14,97.79)
  BOTTOM w0.076: v2(166.14,97.79) 165.75,98.18 CPU1.M8
  BOTTOM w0.114: v2(173.15,42.53) 171.44,40.82 JDIMM2.232
DDR_B_D60: length 67.9
  IN1 w0.081: v2(176.83,45.07) 177.24,45.47 177.24,49.02 177.14,49.12 176.67,49.12 176.57,49.22 176.57,49.42 176.67,49.52 177.2,49.52 177.3,49.61 177.3,49.81 177.2,49.91 176.67,49.91 176.57,50.01 176.57,51.01 176.67,51.11 177.26,51.11 177.36,51.21 177.36,51.4 177.26,51.5 176.67,51.5 176.57,51.6 176.57,51.8 176.67,51.9 177.26,51.9 177.36,52 177.36,53.01 177.15,53.22 177.15,59.68 177.6,60.13 177.6,62.64 176.07,64.17 176.07,69.64 175.65,70.06 175.65,85.36 174.32,86.68 174.32,89.89 172.16,92.06 170.48,92.06 169.56,92.98 169.56,93.95 169.79,94.18 169.79,94.71 169.23,95.27 169.23,96.69 168.29,97.63 168.29,97.89 167.45,98.73 167.45,99.42 v2(167.09,99.77)
  BOTTOM w0.076: v2(167.09,99.77) CPU1.L10
  BOTTOM w0.114: JDIMM2.249 175.69,45.69 176.32,45.07 v2(176.83,45.07)
DDR_B_D61: length 67.5
  IN1 w0.081: v2(173.15,43.8) 172.7,44.25 172.7,46.58 172.49,46.79 172.49,52.37 173.7,53.58 173.7,61.93 173.53,62.09 173.01,62.09 172.89,62.21 172.89,62.7 172.99,62.8 173.33,62.8 173.43,62.89 173.43,63.08 173.33,63.18 172.99,63.18 172.89,63.28 172.89,63.5 172.99,63.6 173.2,63.6 173.3,63.69 173.3,63.89 173.2,63.98 172.99,63.98 172.89,64.08 172.89,64.27 172.99,64.37 173.2,64.37 173.3,64.47 173.3,64.66 173.2,64.76 172.99,64.76 172.89,64.85 172.89,84.26 171.89,85.26 171.89,88.12 168.99,91.03 168.73,91.03 168.25,91.51 168.19,91.51 166.24,93.46 166.24,96.18 165.75,96.67 165.75,98.74 165.83,98.82 165.83,99.4 v2(166.21,99.77)
  BOTTOM w0.076: v2(166.21,99.77) CPU1.M10
  BOTTOM w0.114: JDIMM2.233 171.69,46.29 171.46,46.05 171.46,45.49 v2(173.15,43.8)
DDR_B_D62: length 67.7
  IN1 w0.081: v2(166.15,97.15) 166.15,96.53 166.51,96.16 166.51,95.05 166.6,94.96 167.12,94.96 167.37,94.71 167.37,93.66 170.25,90.78 170.25,90.16 172.17,88.24 172.17,85.38 173.65,83.91 173.65,71.99 173.55,71.89 173.29,71.89 173.19,71.79 173.19,71.59 173.29,71.49 173.55,71.49 173.65,71.39 173.65,71.2 173.55,71.1 173.29,71.1 173.19,71 173.19,70.8 173.29,70.7 173.55,70.7 173.65,70.6 173.65,70.4 173.55,70.3 173.29,70.3 173.19,70.2 173.19,70.01 173.29,69.91 173.55,69.91 173.65,69.81 173.65,69.61 173.55,69.51 173.29,69.51 173.19,69.41 173.19,69.21 173.29,69.11 173.55,69.11 173.65,69.02 173.65,68.82 173.55,68.72 173.29,68.72 173.19,68.62 173.19,68.42 173.29,68.32 173.55,68.32 173.65,68.22 173.65,68.03 173.55,67.93 173.29,67.93 173.19,67.83 173.19,67.63 173.29,67.53 173.55,67.53 173.65,67.43 173.65,67.23 173.55,67.13 173.29,67.13 173.19,67.03 173.19,66.84 173.29,66.74 173.55,66.74 173.65,66.64 173.65,66.44 173.55,66.34 173.29,66.34 173.19,66.24 173.19,66.04 173.29,65.95 173.55,65.95 173.65,65.85 173.65,65.65 173.55,65.55 173.29,65.55 173.19,65.45 173.19,65.25 173.29,65.15 173.55,65.15 173.65,65.05 173.65,63.74 174,63.39 174,63.01 174.1,62.91 174.3,62.91 174.4,62.81 174.4,62.62 174.3,62.52 174.1,62.52 174,62.43 174,62.24 174.1,62.14 174.3,62.14 174.4,62.04 174.4,61.85 174.3,61.75 174.1,61.75 174,61.66 174,53.37 172.86,52.23 172.86,52 172.95,51.9 173.27,51.9 173.36,51.81 173.36,51.61 173.27,51.52 172.95,51.52 172.86,51.42 172.86,47.4 173.05,47.21 173.05,46.3 173.51,45.84 173.51,45.43 v2(173.15,45.07)
  BOTTOM w0.076: CPU1.M7 165.79,97.5 v2(166.15,97.15)
  BOTTOM w0.114: v2(173.15,45.07) 172.82,45.07 172.54,45.35 172.54,45.92 172.69,46.08 JDIMM2.237
DDR_B_D63: length 67.7
  IN1 w0.081: v2(176.83,42.53) 176.43,42.93 176.43,47.13 176.27,47.29 176.27,48.29 176.37,48.38 176.84,48.38 176.94,48.48 176.94,48.67 176.84,48.77 176.37,48.77 176.27,48.87 176.27,59.39 176.79,59.91 176.79,63.05 175.77,64.07 175.77,69.54 175.36,69.95 175.36,85.24 174.04,86.56 174.04,89.75 171.91,91.88 170.41,91.88 169.02,93.26 169.02,96.64 168.74,96.93 168.07,96.93 167.44,97.56 167.44,98.13 v2(167.09,98.47)
  BOTTOM w0.076: v2(167.09,98.47) CPU1.L8
  BOTTOM w0.114: v2(176.83,42.53) 176.18,41.88 176.18,41.4 174.95,40.16 174.95,39 JDIMM2.246
DDR_B_DQS0: length 73.2
  IN1 w0.081: v2(133.38,99.66) 133.52,99.52 133.52,99.27 133.43,99.19 132.86,99.19 132.36,99.69 131.06,99.69 130.73,99.36 130.73,98.88 129.63,97.77 129.63,97.64 129.36,97.38 129.36,96.6 128.61,95.86 128.61,90 119.93,81.33 119.93,68.38 114.58,63.02 114.58,51.48 113.96,50.86 113.96,49.72 114.2,49.48 114.2,48.49 113.56,47.86 113.56,47.56 113.76,47.37 114.08,47.37 114.25,47.2 114.25,46.78 114.14,46.67 113.58,46.67 113.35,46.45 113.35,43.9 113.58,43.67 113.76,43.67 v2(114.01,43.42)
  BOTTOM w0.076: CPU1.BR9 133.05,99.25 v2(133.38,99.66)
  BOTTOM w0.114: v2(114.01,43.42) 114.28,43.68 114.49,43.68 114.75,43.94 114.75,46.07 114.69,46.12 JDIMM2.13
DDR_B_DQS1: length 71.4
  IN1 w0.081: v2(119.04,42.79) 118.74,42.48 118.48,42.48 118.4,42.56 118.4,43.53 119.31,44.43 119.31,45.89 120.28,46.86 120.28,53.62 120.07,53.83 120.07,57.98 120.72,58.63 120.72,63.16 124.77,67.22 124.77,79.18 125.43,79.84 125.43,80.5 133.04,88.11 133.04,89.76 135.75,92.47 135.75,93.97 134.71,95 134.71,96.02 135.86,97.17 135.86,98.99 135.99,99.12 v2(136.1,99.12)
  BOTTOM w0.076: v2(136.1,99.12) 135.91,98.93 135.91,98.83 136.09,98.65 136.34,98.65 CPU1.BJ9
  BOTTOM w0.107: JDIMM2.34 119.94,40.03
  BOTTOM w0.114: v2(119.04,42.79) 119.28,42.54 119.67,42.54 119.95,42.26 119.95,41.4 119.83,41.28 119.83,40.14 119.94,40.03
DDR_B_DQS2: length 68.6
  IN1 w0.081: v2(124.63,43.42) 124.75,43.54 124.92,43.54 125.02,43.44 125.58,43.44 125.91,43.77 125.91,44.24 125.4,44.75 125.4,45.15 125.91,45.65 125.91,63.03 129.34,66.47 129.34,78 134.89,83.54 134.89,84.34 138.85,88.29 138.85,90.44 139.94,91.53 139.94,96.04 139.31,96.68 139.31,98.79 139.64,99.12 v2(139.67,99.12)
  BOTTOM w0.076: v2(139.67,99.12) CPU1.BF9
  BOTTOM w0.114: JDIMM2.55 125.19,46.22 125.05,46.08 125.05,45.57 125.48,45.14 125.48,44 125.05,43.57 124.78,43.57 124.74,43.53 v2(124.63,43.42)
DDR_B_DQS3: length 68
  IN1 w0.081: v2(130.8,42.15) 131.05,42.41 131.52,42.41 131.73,42.62 131.73,44.32 131.55,44.51 131.25,44.51 131.1,44.65 131.1,45.02 131.22,45.14 131.5,45.14 131.71,45.35 131.71,58.02 132.18,58.48 132.18,63.21 133.15,64.18 133.15,76.55 138.76,82.15 138.76,84.25 142.09,87.58 142.09,89.87 142.88,90.66 142.88,96.84 142.06,97.67 142.06,98.75 v2(142.43,99.12)
  BOTTOM w0.076: v2(142.43,99.12) CPU1.BB9
  BOTTOM w0.107: JDIMM2.76 130.45,40.01
  BOTTOM w0.114: v2(130.8,42.15) 130.62,42.33 130.46,42.33 130.31,42.18 130.31,40.15 130.45,40.01
DDR_B_DQS4: length 66
  IN1 w0.081: v2(158.89,99.12) 158.89,99.28 158.77,99.4 158.56,99.4 158.44,99.28 158.44,98.78 158.53,98.69 158.53,97.59 158.79,97.33 158.79,91.1 161.96,87.92 161.96,71.78 158.35,68.16 158.35,58.53 158.69,58.19 158.69,50.32 158.09,49.72 158.09,49.04 157.72,48.68 157.72,47.58 157.51,47.37 157.32,47.37 157.2,47.25 157.2,46.98 157.32,46.86 157.6,46.86 157.77,46.68 157.77,45.33 157.2,44.75 157.2,44 157.35,43.85 157.58,43.85 v2(157.84,44.1)
  BOTTOM w0.076: v2(158.89,99.12) CPU1.AA9
  BOTTOM w0.114: JDIMM2.179 158.2,46.2 158.06,46.07 158.06,45.61 157.23,44.79 157.23,44.16 157.49,43.91 157.65,43.91 v2(157.84,44.1)
DDR_B_DQS5: length 66.4
  IN1 w0.081: v2(163.51,42.27) 163.51,42.35 163.18,42.67 162.95,42.67 162.78,42.85 162.78,44.89 163.37,45.47 163.37,51.62 163.56,51.81 163.73,51.81 163.88,51.96 163.88,52.27 163.76,52.4 163.62,52.4 163.41,52.6 163.41,53.08 163.94,53.61 163.94,59.42 163.43,59.93 163.43,67.46 165.69,69.72 165.69,87.68 161.22,92.16 161.22,97.36 161.12,97.46 161.12,98.47 161,98.58 160.8,98.58 v2(160.71,98.49)
  BOTTOM w0.076: v2(160.71,98.49) 160.76,98.44 161.16,98.44 161.23,98.51 161.23,98.75 CPU1.V9
  BOTTOM w0.107: JDIMM2.200 163.44,40 163.35,40.1
  BOTTOM w0.114: v2(163.51,42.27) 163.32,42.46 163.04,42.46 162.89,42.3 162.89,41.12 163.32,40.68 163.32,40.12 163.35,40.1
DDR_B_DQS6: length 66
  IN1 w0.081: v2(164.38,99.12) 164.38,99.21 164.22,99.38 164.03,99.38 163.93,99.28 163.93,98.77 164.01,98.69 164.01,93.14 169.73,87.42 169.73,67.03 169.41,66.71 169.41,60.47 169.85,60.03 169.85,55.1 169.08,54.32 169.08,51.89 169.26,51.7 169.42,51.7 169.61,51.51 169.61,51.04 169.41,50.85 169.03,50.85 168.94,50.77 168.94,46.37 169.13,46.18 169.35,46.18 169.53,45.99 169.53,45.57 169.24,45.28 168.63,45.28 168.44,45.09 168.44,44.06 168.56,43.94 168.79,43.94 v2(169.02,44.18)
  BOTTOM w0.076: v2(164.38,99.12) CPU1.P9
  BOTTOM w0.114: JDIMM2.221 168.69,46.29 168.55,46.14 168.55,44.12 168.71,43.96 168.72,43.96 168.81,43.96 v2(169.02,44.18)
DDR_B_DQS7: length 67.9
  IN1 w0.081: v2(174.74,42.21) 174.74,42.28 174.41,42.61 174.28,42.61 174.15,42.75 174.15,43.88 174.35,44.08 174.81,44.08 175.22,44.49 175.22,44.78 175.06,44.94 174.6,44.94 174.41,45.13 174.41,52.04 175.22,52.85 175.22,63.28 174.43,64.07 174.43,84.37 173.11,85.69 173.11,89.3 171.25,91.17 170.38,91.17 167.8,93.74 167.8,96.45 167.19,97.06 167.09,97.06 166.54,97.61 166.54,98.33 166.45,98.41 v2(166.16,98.41)
  BOTTOM w0.076: CPU1.L9 166.54,98.8 v2(166.16,98.41)
  BOTTOM w0.114: v2(174.74,42.21) 174.35,42.6 174.23,42.6 174.12,42.48 174.12,41.03 173.69,40.61 173.69,40.09 173.94,39.84 JDIMM2.242
DDR_B_DQS#0: length 73.3
  IN1 w0.081: v2(114.01,44.06) 113.79,43.83 113.64,43.83 113.51,43.96 113.51,46.38 113.64,46.51 114.21,46.51 114.4,46.71 114.4,47.27 114.14,47.53 113.84,47.53 113.72,47.65 113.72,47.79 114.35,48.43 114.35,49.55 114.12,49.78 114.12,50.8 114.74,51.41 114.74,62.96 120.09,68.31 120.09,81.26 128.77,89.94 128.77,95.79 129.52,96.53 129.52,97.31 129.78,97.58 129.78,97.71 130.89,98.81 130.89,99.3 131.13,99.54 132.29,99.54 132.8,99.03 133.5,99.03 133.68,99.21 133.68,99.45 133.87,99.64 v2(133.98,99.64)
  BOTTOM w0.076: CPU1.BP9 133.66,99.04 133.75,98.95 133.89,98.95 133.98,99.04 v2(133.98,99.64)
  BOTTOM w0.107: 114.14,43.93 v2(114.01,44.06) ; JDIMM2.11 114.19,46.28
  BOTTOM w0.114: 114.19,46.28 114.5,45.97 114.5,44.05 114.39,43.93 114.14,43.93
DDR_B_DQS#1: length 71.4
  IN1 w0.081: v2(119.04,42.15) 118.87,42.32 118.42,42.32 118.25,42.5 118.25,43.59 119.15,44.5 119.15,45.96 120.12,46.93 120.12,53.56 119.91,53.77 119.91,58.04 120.56,58.69 120.56,63.22 124.62,67.28 124.62,79.24 125.28,79.9 125.28,80.56 132.88,88.17 132.88,89.83 135.59,92.54 135.59,93.9 134.56,94.94 134.56,96.08 135.71,97.23 135.71,99.24 136.06,99.59 v2(136.06,99.77)
  BOTTOM w0.076: v2(136.06,99.77) CPU1.BL9
  BOTTOM w0.107: JDIMM2.32 119.45,40.03
  BOTTOM w0.114: 119.45,40.03 119.59,40.17 119.59,41.38 119.71,41.5 119.71,42.15 119.56,42.3 119.19,42.3 v2(119.04,42.15)
DDR_B_DQS#2: length 68.5
  IN1 w0.081: v2(138.78,99.12) 138.93,99.27 139.08,99.27 139.2,99.16 139.2,98.91 139.15,98.86 139.15,96.61 139.78,95.97 139.78,91.6 138.69,90.51 138.69,88.36 134.73,84.4 134.73,83.61 129.19,78.06 129.19,66.53 125.75,63.1 125.75,45.72 125.24,45.22 125.24,44.68 125.76,44.17 125.76,43.84 125.51,43.6 125.09,43.6 v2(124.63,44.06)
  BOTTOM w0.076: v2(138.78,99.12) CPU1.BG9
  BOTTOM w0.114: v2(124.63,44.06) 124.86,43.82 124.95,43.82 125.23,44.1 125.23,45.04 124.8,45.47 124.8,46.12 124.69,46.22 JDIMM2.53
DDR_B_DQS#3: length 68.2
  IN1 w0.081: v2(141.52,99.12) 141.9,98.74 141.9,97.6 142.73,96.77 142.73,90.73 141.93,89.93 141.93,87.64 138.6,84.31 138.6,82.22 132.99,76.61 132.99,64.24 132.02,63.27 132.02,58.55 131.83,58.36 131.55,58.08 131.55,45.41 131.44,45.29 131.15,45.29 130.95,45.09 130.95,44.56 131.16,44.35 131.48,44.35 131.57,44.26 131.57,42.71 131.42,42.56 131.02,42.56 v2(130.8,42.79)
  BOTTOM w0.076: v2(141.52,99.12) CPU1.BC9
  BOTTOM w0.114: JDIMM2.74 129.94,40.01 130.06,40.13 130.06,42.29 130.35,42.57 130.59,42.57 v2(130.8,42.79)
DDR_B_DQS#4: length 66.1
  IN1 w0.081: v2(157.98,99.12) 158.16,99.12 158.28,99 158.28,98.71 158.37,98.62 158.37,97.52 158.63,97.27 158.63,91.04 161.81,87.86 161.81,71.84 158.19,68.23 158.19,58.47 158.53,58.13 158.53,50.38 157.93,49.79 157.93,49.11 157.57,48.74 157.57,47.65 157.45,47.53 157.25,47.53 157.04,47.32 157.04,46.92 157.25,46.7 157.53,46.7 157.62,46.62 157.62,45.39 157.04,44.82 157.04,43.93 157.28,43.69 157.61,43.69 v2(157.84,43.46)
  BOTTOM w0.076: v2(157.98,99.12) CPU1.AC9
  BOTTOM w0.107: JDIMM2.177 157.69,46.2
  BOTTOM w0.114: v2(157.84,43.46) 157.63,43.67 157.39,43.67 156.99,44.06 156.99,44.89 157.81,45.72 157.81,46.08 157.69,46.2
DDR_B_DQS#5: length 66.5
  IN1 w0.081: v2(160.71,99.13) 160.71,99.1 161.27,98.53 161.27,97.53 161.37,97.43 161.37,92.22 165.85,87.75 165.85,69.65 163.58,67.39 163.58,60 164.1,59.49 164.1,53.54 163.57,53.02 163.57,52.67 163.69,52.55 163.82,52.55 164.03,52.34 164.03,51.89 163.79,51.65 163.62,51.65 163.52,51.55 163.52,45.41 162.94,44.82 162.94,42.91 163.02,42.83 163.43,42.83 v2(163.51,42.91)
  BOTTOM w0.076: v2(160.71,99.13) 160.38,98.8 CPU1.W9
  BOTTOM w0.107: JDIMM2.198 162.94,39.96
  BOTTOM w0.114: 162.94,39.96 163.08,40.09 163.08,40.58 162.64,41.01 162.64,42.4 162.94,42.7 163.3,42.7 v2(163.51,42.91)
DDR_B_DQS#6: length 66
  IN1 w0.081: v2(163.47,99.12) 163.78,98.81 163.78,98.7 163.85,98.63 163.85,93.07 169.58,87.35 169.58,67.09 169.26,66.77 169.26,60.4 169.7,59.96 169.7,55.17 168.92,54.39 168.92,51.82 169.2,51.54 169.35,51.54 169.45,51.45 169.45,51.11 169.35,51 168.96,51 168.79,50.83 168.79,46.3 169.07,46.02 169.28,46.02 169.38,45.93 169.38,45.64 169.17,45.43 168.56,45.43 168.28,45.16 168.28,44 168.5,43.78 168.94,43.78 169.02,43.7 v2(169.02,43.54)
  BOTTOM w0.076: v2(163.47,99.12) CPU1.R9
  BOTTOM w0.107: 168.85,43.72 v2(169.02,43.54)
  BOTTOM w0.114: JDIMM2.219 168.19,46.22 168.3,46.12 168.3,44.02 168.61,43.72 168.71,43.72 168.72,43.72 168.85,43.72
DDR_B_DQS#7: length 68.1
  IN1 w0.081: v2(166.2,99.09) 166.2,98.92 166.46,98.66 166.46,98.63 166.7,98.39 166.7,97.68 167.16,97.22 167.26,97.22 167.96,96.51 167.96,93.81 170.44,91.32 171.31,91.32 173.27,89.37 173.27,85.76 174.59,84.44 174.59,64.13 175.38,63.35 175.38,52.78 174.57,51.98 174.57,45.19 174.66,45.1 175.13,45.1 175.38,44.85 175.38,44.43 174.88,43.92 174.41,43.92 174.3,43.81 174.3,42.85 174.38,42.77 174.66,42.77 v2(174.74,42.84)
  BOTTOM w0.076: CPU1.M9 165.91,98.8 v2(166.2,99.09)
  BOTTOM w0.114: v2(174.74,42.84) 174.13,42.84 173.87,42.59 173.87,41.14 173.44,40.71 JDIMM2.240
DDR_B_MA0: length 69.5
  IN1 w0.089: v2(152.49,99.12) 152.02,98.65 152.02,97.51 152.95,96.58 152.95,93.82 153.2,93.57 153.2,83.85
  IN1 w0.13: v2(148.47,42.65) 147.44,43.68 147.44,44.09 147.19,44.34 147.19,46.07 146.75,46.51 146.75,49.99 147.06,50.3 147.06,51.54 147.79,52.26 147.79,58.25 147.59,58.45 147.59,71.41 148.89,72.71 149.1,72.71 149.74,72.07 149.96,72.07 150.18,72.29 150.18,72.51 149.4,73.29 149.4,73.54 149.59,73.73 149.84,73.73 150.38,73.19 150.38,73.18 150.62,72.94 151,72.94 151.27,73.2 151.27,75.37 153.2,77.31 153.2,83.85
  BOTTOM w0.076: v2(152.49,99.12) 152.17,98.8 CPU1.AJ9
  BOTTOM w0.175: JDIMM2.144 147.44,41.62 v2(148.47,42.65)
DDR_B_MA1: length 66.3
  IN1 w0.089: 150.35,83.85 150.35,85.47 150.34,85.48 150.34,95.05 151.03,95.74 v2(151.03,96.53)
  IN1 w0.13: v2(143.98,45.07) 144,45.08 144,52.32 144.48,52.81 144.48,58.46 144.85,58.83 144.94,58.83 145.13,59.02 145.13,59.3 144.97,59.46 144.65,59.46 144.5,59.61 144.5,59.92 144.65,60.08 144.97,60.08 145.13,60.23 145.13,60.57 144.85,60.85 144.85,61.16 145.11,61.42 145.11,62.58 144.95,62.73 144.65,62.73 144.5,62.89 144.5,63.2 144.65,63.35 145.02,63.35 145.17,63.51 145.17,63.82 145.02,63.97 144.65,63.97 144.5,64.13 144.5,64.44 144.65,64.59 144.97,64.59 145.13,64.75 145.13,72.71 147.17,74.75 147.17,74.97 146.92,75.22 146.92,75.5 147.1,75.69 147.32,75.69 147.6,75.4 147.82,75.4 148.02,75.6 148.02,75.81 147.67,76.16 147.67,76.38 147.86,76.57 148.07,76.57 148.42,76.22 148.64,76.22 148.85,76.43 148.85,76.65 148.5,77 148.5,77.22 148.98,77.69 149.59,77.69 149.81,77.91 149.81,80.11 150,80.3 150.34,80.3 150.53,80.49 150.53,80.81 150.38,80.96 149.56,80.96 149.4,81.12 149.4,81.43 149.56,81.58 150.38,81.58 150.53,81.74 150.53,82.05 150.38,82.2 150.17,82.2 150.01,82.36 150.01,82.67 150.35,83.01 150.35,83.85
  BOTTOM w0.076: v2(151.03,96.53) 151.09,96.47 151.41,96.47 151.55,96.61 151.55,96.76 CPU1.AK6
  BOTTOM w0.175: v2(143.98,45.07) 143.98,45.28 144.69,46 JDIMM2.133
DDR_B_MA2: length 66.2
  IN1 w0.089: v2(151.8,95.85) 150.68,94.73 150.68,85.94 150.99,85.63 150.99,83.85
  IN1 w0.13: 150.99,83.85 150.99,80.21 150.26,79.48 150.26,77.2 145.63,72.56 145.63,58.74 145.19,58.3 145.19,52.75 144.45,52.02 144.45,43.74 144.64,43.55 145.01,43.55 145.17,43.4 145.17,43.09 145.01,42.93 144.63,42.93 144.47,42.78 144.47,41.11 144.63,40.96 144.95,40.96 145.11,41.11 145.11,42.31 145.32,42.53 v2(145.62,42.53)
  BOTTOM w0.076: CPU1.AK5 151.75,95.85 v2(151.8,95.85)
  BOTTOM w0.175: JDIMM2.132 144.44,39.95 144.63,40.13 144.63,41.55 145.61,42.53 v2(145.62,42.53)
DDR_B_MA3: length 66.5
  IN1 w0.089: 149.89,83.85 149.89,86.16 150.16,86.43 150.16,95.78 v2(150.24,95.86)
  IN1 w0.13: v2(143.98,43.8) 143.54,44.24 143.54,58.09 144.04,58.59 144.04,64.9 144.19,65.05 144.51,65.05 144.67,65.21 144.67,65.52 144.51,65.67 144.19,65.67 144.04,65.83 144.04,66.14 144.19,66.29 144.51,66.29 144.67,66.45 144.67,66.76 144.51,66.91 144.19,66.91 144.04,67.07 144.04,67.38 144.19,67.53 144.51,67.53 144.67,67.69 144.67,68 144.51,68.15 144.19,68.15 144.04,68.31 144.04,68.62 144.19,68.77 144.51,68.77 144.67,68.93 144.67,69.24 144.51,69.39 144.19,69.39 144.04,69.55 144.04,69.94 144.19,70.1 144.51,70.1 144.67,70.25 144.67,70.56 144.51,70.72 144.19,70.72 144.04,70.87 144.04,71.18 144.19,71.34 144.46,71.34 144.61,71.49 144.61,73.77 144.76,73.92 144.95,73.92 145.2,73.66 145.43,73.66 145.69,73.91 145.69,74.13 145.34,74.48 145.34,74.69 145.54,74.9 145.75,74.9 146.09,74.56 146.33,74.56 146.53,74.76 146.53,74.98 146.18,75.33 146.18,75.54 148.94,78.3 148.94,81.62 149.55,82.23 149.55,82.86 149.89,83.2 149.89,83.85
  BOTTOM w0.076: CPU1.AL5 150.57,96.19 v2(150.24,95.86)
  BOTTOM w0.175: v2(143.98,43.8) 143.45,44.33 143.45,45.48 144.19,46.22 JDIMM2.131
DDR_B_MA4: length 65.2
  IN1 w0.089: 148.63,83.85 148.63,84.65 148.99,85.01 148.99,96.61 149.25,96.87 149.88,96.87 v2(150.24,96.51)
  IN1 w0.13: v2(143.98,41.3) 143.64,41.3 143.46,41.12 143.46,40.61 143.3,40.46 142.91,40.46 142.76,40.61 142.76,42.01 142.62,42.14 142.62,58.48 143.12,58.97 143.12,74.54 148.02,79.44 148.02,82 148.63,82.61 148.63,83.85
  BOTTOM w0.076: CPU1.AL6 150.57,96.84 v2(150.24,96.51)
  BOTTOM w0.175: v2(143.98,41.3) 143.98,41.02 143.44,40.48 JDIMM2.128
DDR_B_MA5: length 64.6
  IN1 w0.089: v2(149.4,96.51) 149.77,96.15 149.77,94.73 149.43,94.4 149.43,83.85
  IN1 w0.13: v2(143.98,42.53) 143.74,42.28 143.37,42.28 143.08,42.57 143.08,58.28 143.58,58.78 143.58,71.64 143.73,71.8 144,71.8 144.15,71.95 144.15,72.26 144,72.42 143.73,72.42 143.58,72.57 143.58,72.94 143.73,73.09 144,73.09 144.15,73.25 144.15,73.55 144,73.7 143.73,73.7 143.58,73.86 143.58,74.35 148.48,79.25 148.48,81.81 149.09,82.42 149.09,83.05 149.43,83.39 149.43,83.85
  BOTTOM w0.076: CPU1.AM6 149.8,96.59 149.72,96.51 v2(149.4,96.51)
  BOTTOM w0.175: JDIMM2.126 142.94,42.19 143.28,42.53 v2(143.98,42.53)
DDR_B_MA6: length 66
  IN1 w0.089: v2(149.75,97.32) 149.35,97.32 148.77,96.74 148.77,85.16 148.17,84.57 148.17,83.85
  IN1 w0.13: v2(141.59,43.72) 141.79,43.72 142.14,44.07 142.14,47.21 141.68,47.67 141.68,50.91 141.84,51.07 141.99,51.07 142.14,51.22 142.14,51.6 141.99,51.75 141.84,51.75 141.68,51.91 141.68,52.2 141.84,52.36 142.03,52.36 142.14,52.47 142.14,52.8 142.01,52.93 141.81,52.93 141.68,53.05 141.68,53.42 141.81,53.55 142.01,53.55 142.17,53.71 142.17,59.38 142.32,59.53 142.51,59.53 142.66,59.68 142.66,60 142.5,60.15 142.32,60.15 142.17,60.31 142.17,60.62 142.32,60.77 142.5,60.77 142.66,60.92 142.66,63.05 142.5,63.21 142.32,63.21 142.17,63.36 142.17,63.67 142.32,63.82 142.5,63.82 142.66,63.98 142.66,64.29 142.5,64.44 142.32,64.44 142.17,64.6 142.17,64.91 142.32,65.06 142.5,65.06 142.66,65.22 142.66,74.72 147.56,79.63 147.56,82.19 148.17,82.8 148.17,83.85
  BOTTOM w0.076: v2(149.75,97.32) 149.55,97.12 149.37,97.12 149.29,97.2 CPU1.AN7
  BOTTOM w0.175: JDIMM2.127 143.19,46.07 142.94,45.82 142.94,45.06 v2(141.59,43.72)
DDR_B_MA7: length 67.8
  IN1 w0.089: 146.35,83.85 146.35,84.08 146.44,84.17 147.01,84.17 148.39,85.54 148.39,96.96 149,97.57 149,97.96 149.38,98.34 149.38,99.41 v2(149.75,99.77)
  IN1 w0.13: v2(141.59,42.37) 141.59,42.32 141.47,42.19 141.26,42.19 141.13,42.32 141.13,46.8 140.76,47.17 140.76,50.72 140.64,50.85 140.5,50.85 140.35,51.01 140.35,51.31 140.5,51.47 140.61,51.47 140.76,51.62 140.76,51.88 140.61,52.04 140.47,52.04 140.35,52.16 140.35,52.49 140.47,52.61 140.63,52.61 140.74,52.71 140.74,58.15 141.25,58.66 141.25,74.61 146.35,79.71 146.35,83.85
  BOTTOM w0.076: v2(149.75,99.77) CPU1.AN10
  BOTTOM w0.175: v2(141.59,42.37) 141.86,42.37 142.26,41.97 142.26,40.34 141.94,40.03 JDIMM2.122
DDR_B_MA8: length 65.7
  IN1 w0.089: 147.71,83.85 147.75,83.88 147.75,84.59 148.56,85.4 148.56,96.88 149.58,97.89 v2(149.73,97.89)
  IN1 w0.13: v2(141.61,45.08) 141.68,45.16 141.68,47.02 141.22,47.48 141.22,57.98 141.71,58.47 141.71,65.49 141.86,65.64 142.04,65.64 142.2,65.8 142.2,66.11 142.04,66.26 141.86,66.26 141.71,66.42 141.71,66.73 141.86,66.88 142.04,66.88 142.2,67.04 142.2,67.35 142.04,67.5 141.86,67.5 141.71,67.66 141.71,67.97 141.86,68.12 142.04,68.12 142.2,68.28 142.2,68.59 142.04,68.74 141.86,68.74 141.71,68.9 141.71,69.21 141.86,69.36 142.04,69.36 142.2,69.52 142.2,69.83 142.04,69.98 141.86,69.98 141.71,70.14 141.71,70.45 141.86,70.6 142.04,70.6 142.2,70.76 142.2,71.07 142.04,71.22 141.86,71.22 141.71,71.38 141.71,71.69 141.86,71.84 142.04,71.84 142.2,72 142.2,72.31 142.04,72.46 141.86,72.46 141.71,72.62 141.71,74.42 146.8,79.51 146.8,81.23 147.1,81.53 147.1,81.86 146.81,82.15 146.81,82.43 146.96,82.59 147.31,82.59 147.46,82.74 147.46,82.99 147.31,83.15 146.96,83.15 146.81,83.3 146.81,83.58 146.95,83.73 147.59,83.73 147.71,83.85
  BOTTOM w0.076: v2(149.73,97.89) 149.47,98.15 CPU1.AN8
  BOTTOM w0.175: JDIMM2.125 142.69,46.37 142.25,45.92 142.25,45.67 142.44,45.48 142.44,45.28 142.06,44.9 141.78,44.9 v2(141.61,45.08)
DDR_B_MA9: length 66.1
  IN1 w0.089: v2(147.91,99.72) 148.47,99.16 148.47,97.55 147.93,97.01 147.93,86.21 146.31,84.59 145.66,84.59 145.43,84.36 145.43,83.85
  IN1 w0.13: v2(139.72,43.59) 140.21,44.08 140.21,46.42 139.4,47.24 139.4,58.11 140.33,59.04 140.33,74.98 145.43,80.08 145.43,83.85
  BOTTOM w0.076: CPU1.AR11 147.53,100.1 v2(147.91,99.72)
  BOTTOM w0.175: v2(139.72,43.59) 140.36,44.23 140.36,44.79 141.69,46.13 JDIMM2.121
DDR_B_MA10: length 67.6
  IN1 w0.089: 154.78,83.85 154.78,85.61 153.88,86.51 153.88,93.66 153.49,94.06 153.49,97.74 v2(153.41,97.82)
  IN1 w0.13: v2(148.47,41.13) 147.99,40.64 147.99,40.2 148.15,40.04 149.23,40.04 149.49,40.29 149.49,40.88 148.91,41.46 148.91,45.95 148.82,46.04 148.82,51.07 149.75,52 149.75,59.17 149.25,59.66 149.25,68.96 154.78,74.49 154.78,83.85
  BOTTOM w0.076: v2(153.41,97.82) CPU1.AH7
  BOTTOM w0.175: v2(148.47,41.13) 148.86,41.13 149.95,40.04 149.95,39 JDIMM2.146
DDR_B_MA11: length 70.3
  IN1 w0.089: v2(149.75,100.42) 149.2,99.88 149.2,98.41 148.82,98.03 148.82,97.65 148.11,96.93 148.11,86.03 146.49,84.41 146.11,84.41 145.89,84.19 145.89,83.85
  IN1 w0.13: 145.89,83.85 145.89,79.9 140.79,74.8 140.79,58.85 140.28,58.34 140.28,53.49 139.89,53.1 139.89,47.4 140.67,46.61 140.67,40.49 140.83,40.33 142.15,40.33 142.28,40.46 142.28,40.99 142.14,41.13 141.63,41.13 v2(141.61,41.1)
  BOTTOM w0.076: v2(149.75,100.42) CPU1.AN11
  BOTTOM w0.185: JDIMM2.120 141.44,40.94 v2(141.61,41.1)
DDR_B_MA12: length 64.4
  IN1 w0.089: 144.97,83.85 144.97,84.47 145.8,85.31 145.8,88.28 146.01,88.49 146.44,88.49 147.04,87.89 147.45,87.89 147.7,88.14 147.7,97.03 147.75,97.08 147.91,97.24 147.91,97.28 147.99,97.35 147.99,97.92 148.3,98.22 148.3,98.99 148.18,99.11 v2(147.92,99.11)
  IN1 w0.13: 144.97,83.85 144.97,80.27 139.45,74.75 139.45,60.92 139.6,60.76 139.71,60.76 139.87,60.61 139.87,60.3 139.71,60.14 139.6,60.14 139.45,59.99 139.45,58.81 138.94,58.3 138.94,47.05 139.72,46.27 v2(139.72,44.94)
  BOTTOM w0.076: v2(147.92,99.11) 147.59,99.45 CPU1.AR10
  BOTTOM w0.175: v2(139.72,44.94) 139.82,44.94 141.19,46.31 JDIMM2.119
DDR_B_MA13: length 68
  IN1 w0.089: 157.28,83.85 157.28,86.09 155.77,87.6 155.77,93.8 154.98,94.58 154.98,97.3 154.65,97.63 154.65,98.54 v2(155.24,99.12)
  IN1 w0.13: v2(153.61,40.67) 152.41,40.67 151.73,41.35 151.73,48.57 152.65,49.49 152.65,51.23 153.94,52.51 153.94,54.87 153.32,55.48 153.32,59.12 152.37,60.06 152.37,61.9 151.75,62.52 151.75,67.91 157.28,73.44 157.28,83.85
  BOTTOM w0.076: v2(155.24,99.12) CPU1.AF9
  BOTTOM w0.175: v2(153.61,40.67) 153.38,40.67 152.95,40.24 152.95,39 JDIMM2.158
DDR_B_PAR: length 67.5
  IN1 w0.089: 153.76,83.85 153.48,84.12 153.48,93.56 153.13,93.91 153.13,96.66 152.49,97.29 v2(152.49,97.82)
  IN1 w0.13: 153.76,83.85 153.76,77.07 152.81,76.13 152.81,75.91 153.66,75.06 153.66,74.84 153.44,74.63 153.19,74.63 152.36,75.46 152.14,75.46 151.82,75.14 151.82,74.48 151.98,74.32 152.38,74.32 152.54,74.17 152.54,73.87 152.38,73.71 151.98,73.71 151.82,73.56 151.82,72.97 150.36,71.51 148.74,71.51 148.15,70.92 148.15,58.78 148.34,58.58 148.34,52.03 147.8,51.49 147.8,49.78 147.65,49.63 147.46,49.63 147.31,49.48 147.31,49.17 147.46,49.02 147.65,49.02 147.8,48.87 147.8,48.54 147.65,48.38 147.46,48.38 147.31,48.23 147.31,47.93 147.46,47.77 147.65,47.77 147.8,47.62 147.8,44.53 148.16,44.17 v2(148.47,44.17)
  BOTTOM w0.076: v2(152.49,97.82) CPU1.AJ7
  BOTTOM w0.175: v2(148.47,44.17) 148.07,44.17 147.42,44.83 147.42,46.05 147.2,46.27 JDIMM2.143
DDR_B_RAS#: length 67.8
  IN1 w0.089: 155.7,83.85 155.7,85.64 154.34,87 154.34,93.71 153.84,94.2 153.84,97.39 154.01,97.55 154.01,98.62 153.78,98.85 153.78,99.4 v2(153.41,99.77)
  IN1 w0.13: v2(150.99,42.65) 150.9,42.65 149.98,43.57 149.98,46.16 149.74,46.41 149.74,48.82 150.76,49.84 150.76,51.84 150.95,52.03 151.22,52.03 151.34,52.16 151.34,52.46 151.19,52.61 150.89,52.61 150.76,52.74 150.76,53.05 150.89,53.18 151.2,53.18 151.34,53.32 151.34,58.87 150.17,60.04 150.17,68.56 155.7,74.09 155.7,83.85
  BOTTOM w0.076: v2(153.41,99.77) CPU1.AH10
  BOTTOM w0.175: JDIMM2.152 151.44,40.08 151.64,40.28 151.64,41.99 v2(150.99,42.65)
DDR_B_WE#: length 65
  IN1 w0.089: v2(153.41,100.42) 153.95,99.88 153.95,99.08 154.21,98.82 154.21,97.5 154.02,97.31 154.02,94.62 155.26,93.38 155.26,86.84 156.16,85.94 156.16,83.85
  IN1 w0.13: 156.16,83.85 156.16,73.9 150.63,68.37 150.63,62.05 151.25,61.43 151.25,59.6 151.8,59.05 151.8,51.97 151.22,51.39 151.22,49.65 150.6,49.03 150.6,45.98 150.55,45.93 150.55,44.61 v2(150.99,44.17)
  BOTTOM w0.076: v2(153.41,100.42) CPU1.AH11
  BOTTOM w0.175: JDIMM2.151 151.2,46.26 151.58,45.87 151.58,44.77 v2(150.99,44.17)
DDR_CKE0_DIMMA: length 46
  IN6 w0.13: v2(137.61,58.07) 137.8,58.07 137.97,58.23 137.97,59.4 137.84,59.53 137.72,59.53 137.56,59.69 137.56,59.97 137.72,60.13 137.81,60.13 137.97,60.28 137.97,60.59 137.81,60.75 137.72,60.75 137.56,60.9 137.56,62.22 137.97,62.62 137.97,63.41 139.16,64.6 139.16,70.1 143.78,74.72 143.78,83.85
  IN6 w0.152: v2(144.44,88.74) 144.15,88.74 143.78,88.37 143.78,83.85
  BOTTOM w0.076: v2(144.44,88.74) 146.31,88.74 146.39,88.82 146.39,89.02 146.32,89.09 145.88,89.09 145.8,89.17 145.8,89.32 145.88,89.4 146.32,89.4 146.39,89.47 146.39,89.63 146.32,89.7 145.88,89.7 145.8,89.78 145.8,89.93 145.88,90.01 146.32,90.01 146.39,90.08 CPU1.AT1
  BOTTOM w0.175: v2(137.61,58.07) 137.99,58.07 138.69,58.78 JDIMM1.109
DDR_CKE1_DIMMA: length 46.6
  IN6 w0.13: v2(137.72,54.03) 138.43,54.74 138.43,63.22 139.62,64.41 139.62,69.91 144.24,74.53 144.24,83.85
  IN6 w0.152: v2(144.71,90.01) 144.83,89.89 144.83,86.95 144.24,86.35 144.24,83.85
  BOTTOM w0.076: CPU1.AT2 146.1,93.94 146.1,91.4 v2(144.71,90.01)
  BOTTOM w0.185: v2(137.72,54.03) 138.94,52.8 JDIMM1.110
DDR_CKE2_DIMMB: length 67
  IN1 w0.089: v2(147.01,97.86) 146.74,97.86 145.62,96.74 145.62,89.4 144.28,88.06 144.28,86.34 142.37,84.43 142.37,83.85
  IN1 w0.13: 142.37,83.85 142.37,81.34 136.75,75.72 136.75,62.85 136.54,62.64 136.54,59.79 135.95,59.2 135.95,51.02 135.53,50.6 135.53,47.92 135.68,47.77 135.8,47.77 135.95,47.61 135.95,47.3 135.8,47.15 135.68,47.15 135.53,46.99 135.53,46.68 135.68,46.53 135.8,46.53 135.95,46.37 135.95,46.06 135.8,45.91 135.68,45.91 135.53,45.75 135.53,44.81 v2(136.66,43.67)
  BOTTOM w0.076: v2(147.01,97.86) 146.72,98.15 CPU1.AT8
  BOTTOM w0.175: v2(136.66,43.67) 136.2,44.13 136.2,45.79 136.5,46.09 138.48,46.09 138.69,46.31 JDIMM2.109
DDR_CKE3_DIMMB: length 67.9
  IN1 w0.089: 141.45,83.85 141.45,84.45 143.65,86.65 143.65,90.01 145.16,91.52 145.16,98.25 v2(146.07,99.15)
  IN1 w0.13: 141.45,83.85 141.45,81.72 135.84,76.11 135.84,63.24 135.62,63.02 135.62,60.17 135.03,59.58 135.03,51.4 134.61,50.98 134.61,43.18 v2(136.66,41.13)
  BOTTOM w0.076: CPU1.AT10 146.36,99.45 v2(146.07,99.15)
  BOTTOM w0.175: v2(136.66,41.13) 137.7,41.13 138.94,39.89 JDIMM2.110
DDR_CS0_DIMMA#: length 50.5
  IN6 w0.089: v2(156.09,95.86) 154.96,95.86 154.76,95.66 154.76,94.71 153.85,93.8 153.85,86.67 156.15,84.36 156.15,83.85
  IN6 w0.13: v2(150.91,56.72) 151.19,56.72 151.34,56.88 151.34,57.6 151.5,57.75 151.78,57.75 151.94,57.91 151.94,61.91 152.4,62.38 152.4,64.64 156.15,68.39 156.15,83.85
  BOTTOM w0.076: v2(156.09,95.86) 156.41,96.19 CPU1.AD5
  BOTTOM w0.175: JDIMM1.149 150.69,58.9 150.39,58.6 150.39,57.78 149.49,56.88 149.49,56.55 149.93,56.1 150.29,56.1 v2(150.91,56.72)
DDR_CS1_DIMMA#: length 52.8
  IN6 w0.089: v2(154.82,91.13) 154.36,91.13 154.2,90.98 154.2,87.04 155.1,86.14 155.58,86.14 157.62,84.11 157.62,83.85
  IN6 w0.13: 157.62,83.85 157.62,83.5 157.46,83.34 157.22,83.34 157.07,83.19 157.07,82.88 157.22,82.72 157.46,82.72 157.62,82.57 157.62,82.26 157.46,82.1 157.22,82.1 157.07,81.95 157.07,81.64 157.22,81.48 157.46,81.48 157.62,81.33 157.62,81.02 157.46,80.86 157.22,80.86 157.07,80.71 157.07,80.3 157.22,80.15 157.46,80.15 157.62,79.99 157.62,79.68 157.46,79.53 157.22,79.53 157.07,79.37 157.07,79.06 157.22,78.91 157.46,78.91 157.62,78.75 157.62,78.44 157.46,78.29 157.22,78.29 157.07,78.13 157.07,77.82 157.22,77.67 157.46,77.67 157.62,77.51 157.62,77.2 157.46,77.05 157.22,77.05 157.07,76.89 157.07,76.48 157.22,76.33 157.46,76.33 157.62,76.17 157.62,75.87 157.46,75.71 157.22,75.71 157.07,75.55 157.07,75.27 157.22,75.12 157.46,75.12 157.62,74.96 157.62,74.65 157.46,74.5 157.22,74.5 157.07,74.34 157.07,74.03 157.22,73.88 157.46,73.88 157.62,73.72 157.62,73.41 157.46,73.26 157.22,73.26 157.07,73.1 157.07,72.82 157.22,72.67 157.46,72.67 157.62,72.51 157.62,72.2 157.46,72.05 157.22,72.05 157.07,71.89 157.07,71.55 157.22,71.39 157.46,71.39 157.62,71.24 157.62,68.55 153.32,64.26 153.32,62 152.86,61.53 152.86,60.92 153.01,60.76 153.24,60.76 153.39,60.61 153.39,60.3 153.24,60.14 153.01,60.14 152.86,59.99 152.86,58.53 v2(152.89,58.5)
  BOTTOM w0.076: CPU1.AE2 155.43,93.96 155.43,93.14 155.51,93.06 155.63,93.06 155.71,92.98 155.71,92.74 155.63,92.66 155.28,92.66 155.2,92.59 155.2,92.37 155.28,92.29 155.63,92.29 155.71,92.22 155.71,92 155.63,91.93 155.28,91.93 155.2,91.85 155.2,91.63 155.28,91.56 155.63,91.56 155.71,91.48 155.71,91.03 155.46,90.77 155.19,90.77 v2(154.82,91.13)
  BOTTOM w0.175: v2(152.89,58.5) 152.69,58.69 JDIMM1.157
DDR_CS2_DIMMB#: length 63.2
  IN1 w0.089: 156.72,83.85 156.72,86.02 155.51,87.22 155.51,93.6 154.76,94.35 154.76,96.33 154.76,97.25 154.44,97.58 154.44,98.75 154.7,99.01 154.7,99.23 v2(155.22,99.74)
  IN1 w0.13: 156.72,83.85 156.72,73.67 151.19,68.14 151.19,62.29 151.81,61.67 151.81,59.83 152.36,59.28 152.36,51.74 151.78,51.15 151.78,49.42 151.17,48.8 151.17,45.75 v2(150.99,45.57)
  BOTTOM w0.076: v2(155.22,99.74) 155.19,99.74 154.84,100.1 CPU1.AF11
  BOTTOM w0.175: v2(150.99,45.57) 150.39,44.97 150.14,44.97 149.8,45.31 149.8,45.56 150.69,46.45 JDIMM2.149
DDR_CS3_DIMMB#: length 66
  IN1 w0.089: v2(156.09,97.15) 155.72,96.78 155.72,95.27 156.6,94.39 156.6,88.61 158.76,86.45 158.76,83.85
  IN1 w0.13: v2(152.85,44.17) 153.33,44.66 153.33,47.51 154.2,48.37 154.2,48.86 154.2,48.86 154.2,50.68 155.42,51.9 155.42,60.06 154.38,61.1 154.38,64.68 154.6,64.9 155.13,64.9 155.29,65.06 155.29,65.37 155.13,65.52 154.53,65.52 154.38,65.67 154.38,65.92 154.6,66.14 155.13,66.14 155.29,66.3 155.29,66.61 155.13,66.76 154.53,66.76 154.38,66.91 154.38,67.16 154.6,67.38 155.13,67.38 155.29,67.54 155.29,67.84 155.13,68 154.53,68 154.38,68.15 154.38,68.44 158.76,72.82 158.76,83.85
  BOTTOM w0.076: CPU1.AE7 156.04,97.15 v2(156.09,97.15)
  BOTTOM w0.175: v2(152.85,44.17) 153.36,44.68 153.36,45.77 152.69,46.43 JDIMM2.157
DDR_RCOMP0: length 6.2
  BOTTOM w0.089: RH148.2 171.88,89.28 v1(171.52,88.92)
  BOTTOM w0.254: CPU1.G1 169.6,93.59 170.19,93 170.63,93
  BOTTOM w0.381: RH148.2 171.88,91.75 170.63,93
DDR_RCOMP1: length 3.4
  BOTTOM w0.254: v1(169.55,92.04) 168.54,93.06 CPU1.H1
  BOTTOM w0.381: v1(169.55,92.04) 169.55,91.15 RH149.2
DDR_RCOMP2: length 5.6
  BOTTOM w0.089: v1(167.38,91.74) 167.5,91.62 167.5,91.24 167.98,90.76 RH150.2
  BOTTOM w0.254: RH150.2 168.27,91.29 168.73,91.75 168.73,92.2 167.96,92.99 167.96,93.96 CPU1.J2
DDR_VTT_PG_CTRL: length 26.9
  TOP w0.102: v2(131.31,102.18) 131.24,102.18 v1(129.93,100.87) 127.24,98.18 127.24,85.68 124.93,83.36 UC1.2
  BOTTOM w0.089: v2(131.31,102.18) 131.88,101.61 CPU1.BT13
