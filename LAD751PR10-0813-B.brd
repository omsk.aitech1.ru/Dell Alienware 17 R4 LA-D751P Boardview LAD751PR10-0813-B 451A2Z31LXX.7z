# Allegro board LAD751PR10-0813-B.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+NVVDD2 on BOTTOM (solid shape): 238.31,96.68 238.36,96.63 238.41,96.59 238.59,96.41 238.59,96.4 238.62,96.29 238.69,96.19 238.71,96.12 238.68,96.05 238.63,96 238.51,96 238.38,96.13 238.22,96.13 238.06,96.13 237.91,95.98 237.16,95.98 237.03,96.1 236.97,96.1 236.96,96.11 236.82,96.13 236.68,96.11 236.66,96.1 236.55,96.02 236.48,95.93 235.78,95.93 235.58,96.13 235.42,96.13 235.23,96.13 235.08,95.98 235.03,95.98 234.96,96.05 234.93,96.12 234.95,96.19 235.01,96.28 235.05,96.38 235.05,96.4 235.31,96.66 235.53,96.66 235.57,96.62 235.62,96.59 235.71,96.5 236.52,96.5 236.6,96.57 236.67,96.62 236.72,96.68 236.92,96.68 236.96,96.63 237.01,96.59 237.1,96.5 237.94,96.5 238.09,96.63 238.13,96.68
+NVVDD2 on BOTTOM (solid shape): 229.22,91.08 229.26,91.03 229.3,90.99 229.35,90.94 229.39,90.94 229.4,90.92 229.64,90.92 229.66,90.94 230.06,90.94 230.08,90.92 230.23,90.92 230.27,90.96 230.28,90.97 230.36,91.01 230.42,91.08 230.61,91.08 230.67,91.02 231.05,90.64 231.05,90.47 230.95,90.37 230.8,90.37 230.77,90.4 230.74,90.43 230.68,90.49 230.64,90.49 230.63,90.49 230.52,90.51 230.41,90.49 230.39,90.49 230.38,90.48 230.29,90.42 230.24,90.37 229.4,90.37 229.35,90.42 229.3,90.46 229.26,90.49 229.12,90.51 228.98,90.49 228.95,90.46 228.89,90.42 228.84,90.37 228.7,90.37 228.65,90.42 228.6,90.46 228.56,90.49 228.42,90.51 228.27,90.49 228.22,90.44 228.17,90.41 228.13,90.36 227.96,90.36 227.88,90.44 227.88,90.65 228.21,90.98 228.27,91.02 228.32,91.08 228.51,91.08 228.55,91.03 228.58,91.01 228.66,90.93 228.86,90.93 228.9,90.97 228.97,91.02 229.02,91.08
+NVVDD2 on BOTTOM (solid shape): 228.5,93.9 228.75,93.75 229.02,93.87 229.22,93.87 229.29,93.81 229.36,93.76 229.38,93.76 229.4,93.72 229.64,93.72 229.73,93.82 229.97,93.82 230.01,93.79 230.08,93.72 230.23,93.72 230.25,93.76 230.27,93.76 230.36,93.81 230.42,93.88 230.62,93.88 230.66,93.83 230.72,93.78 230.75,93.74 230.96,93.53 230.96,93.49 231.03,93.34 230.94,93.2 230.91,93.19 230.9,93.17 230.8,93.17 230.74,93.23 230.69,93.26 230.67,93.28 230.52,93.31 230.37,93.28 230.35,93.27 230.33,93.25 230.28,93.21 230.24,93.17 229.4,93.17 229.35,93.22 229.3,93.26 229.23,93.33 229.02,93.33 228.95,93.27 228.89,93.22 228.84,93.17 228.7,93.17 228.6,93.28 228.56,93.28 228.55,93.28 228.42,93.31 228.29,93.28 228.27,93.28 228.19,93.22 228.14,93.17 227.97,93.17 227.88,93.26 227.88,93.46 228.2,93.77 228.2,93.78 228.28,93.83 228.34,93.9
+NVVDD2 on BOTTOM (solid shape): 245.98,107.18 246.03,107.16 246.06,107.13 246.1,107.1 246.14,106.97 246.09,106.84 246.07,106.81 246.07,106.78 245.53,106.24 244.76,106.24 244.74,106.23 244.67,106.18 244.61,106.11 244.43,106.11 244.37,106.18 244.29,106.23 244.18,106.34 242.9,106.34 242.76,106.48 242.72,106.49 242.61,106.6 242.64,106.75 242.66,106.79 242.68,106.83 242.68,106.87 242.8,106.87 242.88,106.78 242.98,106.72 243.21,106.71 243.4,106.84 244.25,106.84 244.3,106.8 244.34,106.75 244.37,106.7 244.67,106.7 244.69,106.75 244.73,106.79 244.77,106.82 244.79,106.84 244.93,106.84 245.12,106.71 245.35,106.72 245.37,106.72 245.45,106.78 245.56,106.89 245.63,107.02 245.67,107.06 245.68,107.07 245.76,107.11 245.82,107.17 245.82,107.18 245.87,107.2
+NVVDD2 on BOTTOM (solid shape): 242.83,104.04 243.11,103.89 243.4,104.03 244.25,104.03 244.27,104.03 244.29,104.03 244.42,103.9 244.67,103.9 244.69,103.95 244.73,104 244.79,104.03 244.94,104.03 245.21,103.89 245.49,104.02 245.5,104.03 245.66,104.03 245.75,103.94 245.75,103.74 245.42,103.42 245.36,103.37 245.31,103.32 245.12,103.32 245.09,103.37 244.99,103.45 244.87,103.46 244.77,103.45 244.75,103.43 244.67,103.38 244.61,103.32 244.43,103.32 244.39,103.37 244.33,103.42 244.3,103.42 244.17,103.46 244.04,103.42 244.02,103.42 243.62,103.42 243.6,103.42 243.39,103.45 243.22,103.33 243.02,103.33 242.96,103.39 242.89,103.43 242.9,103.48 242.9,103.59 242.81,103.68 242.76,103.69 242.62,103.78 242.64,103.95 242.66,103.99 242.71,104.04
+NVVDD2 on BOTTOM (solid shape): 243.21,93.89 243.29,93.81 243.38,93.76 243.39,93.75 243.5,93.75 244.14,93.75 244.27,93.75 244.28,93.76 244.29,93.77 244.37,93.82 244.43,93.88 244.44,93.89 244.6,93.89 244.61,93.88 244.68,93.81 244.75,93.77 244.76,93.76 244.78,93.75 244.95,93.75 244.95,93.76 244.97,93.76 245.06,93.81 245.13,93.89 245.29,93.89 245.76,93.42 245.76,93.26 245.66,93.17 245.5,93.17 245.28,93.3 245.04,93.26 245.02,93.25 245.01,93.25 244.93,93.17 244.8,93.17 244.63,93.29 244.41,93.29 244.38,93.29 244.29,93.22 244.23,93.16 243.41,93.16 243.35,93.22 243.28,93.27 243.22,93.33 243,93.33 242.83,93.16 242.7,93.16 242.64,93.22 242.62,93.27 242.62,93.41 242.72,93.51 242.76,93.52 242.83,93.59 242.87,93.65 242.88,93.71 242.87,93.73 242.9,93.77 242.91,93.78 242.98,93.83 243.03,93.89
+NVVDD2 on BOTTOM (solid shape): 243.23,91.06 243.29,91.01 243.35,90.97 243.36,90.96 243.38,90.95 243.47,90.94 243.52,90.95 244.12,90.95 244.17,90.94 244.26,90.95 244.28,90.96 244.29,90.97 244.35,91.01 244.41,91.06 244.63,91.06 244.69,91 244.76,90.97 244.77,90.96 244.78,90.95 244.87,90.94 244.94,90.95 244.96,90.96 245.04,91 245.11,91.06 245.33,91.06 245.37,91.02 245.42,90.99 245.45,90.96 245.76,90.66 245.76,90.46 245.65,90.36 245.51,90.36 245.5,90.38 245.23,90.51 244.95,90.39 244.79,90.39 244.52,90.51 244.25,90.39 243.39,90.39 243.34,90.43 243.3,90.46 243.26,90.5 243.12,90.51 242.98,90.5 242.95,90.46 242.89,90.42 242.84,90.36 242.7,90.36 242.64,90.42 242.62,90.47 242.62,90.61 242.72,90.71 242.76,90.72 242.83,90.79 242.87,90.85 242.88,90.92 242.87,90.94 242.9,90.97 242.96,91.01 243.01,91.06
+NVVDD2 on BOTTOM (solid shape): 228.12,104.05 228.17,103.99 228.27,103.91 228.32,103.91 228.42,103.89 228.52,103.91 228.57,103.91 228.65,103.98 228.7,104.03 228.84,104.03 229.12,103.89 229.4,104.03 230.24,104.03 230.43,103.91 230.65,103.92 230.69,103.94 230.76,103.98 230.81,104.04 230.94,104.04 231.01,103.96 231.03,103.9 231.01,103.76 230.88,103.69 230.83,103.68 230.74,103.59 230.74,103.48 230.75,103.43 230.67,103.38 230.61,103.32 230.43,103.32 230.36,103.39 230.28,103.43 230.26,103.45 230.17,103.46 230.1,103.45 229.54,103.45 229.47,103.46 229.34,103.45 229.24,103.35 229,103.35 228.77,103.46 228.54,103.35 228.3,103.35 228.25,103.39 228.19,103.43 227.88,103.74 227.88,103.95 227.98,104.05
+NVVDD2 on IN4 (solid shape): outline of 70670 points within 227.97,50.96 296.43,123.09
+NVVDD2 on IN5: 234.49,49.94 233.82,50.62 233.82,55.64 232.59,56.86 214.87,56.86 211.21,60.53 211.21,90.8 227.44,107.03 276.19,107.03 276.76,106.46 279.01,106.46 279.09,106.54 279.09,93.78 282.27,90.6 282.27,69.33 283.75,67.85 290.42,67.85 294.71,63.55 294.71,49.94 ; 6 cut-outs
+PEX_VDD on TOP (solid shape): outline of 193 points within 240.29,107.32 243.98,113.86
+PEX_VDD on TOP (solid shape): outline of 202 points within 228.16,107.6 235.14,118.97
+PEX_VDD on BOTTOM (solid shape): 233.31,110.32 233.39,110.28 233.41,110.2 233.42,110.06 233.49,109.95 233.49,109.71 233.67,109.13 233.85,109.71 233.85,109.95 233.92,110.06 233.93,110.2 233.93,110.22 234.1,110.23 234.24,110.32 234.53,110.32 234.64,110.21 234.64,109.07 234.47,108.9 232.84,108.9 232.44,108.9 231.92,109.41 231.89,109.61 231.75,109.76 231.75,109.95 231.81,110.03 231.84,110.14 231.87,110.21 231.95,110.23 232.08,110.25 232.19,110.32
+PEX_VDD on BOTTOM (solid shape): outline of 160 points within 231.02,46.29 235.78,52.36
+PEX_VDD on BOTTOM (solid shape): 241.45,111.02 241.68,110.93 241.9,111.03 242.53,111.03 242.53,110.97 242.51,110.91 242.47,110.87 242.45,110.87 242.23,110.76 242.15,110.53 242.13,110.45 242.06,110.42 241.82,110.24 241.89,109.95 241.89,109.71 242.07,109.13 242.25,109.71 242.25,109.95 242.31,110.03 242.34,110.14 242.37,110.21 242.45,110.23 242.68,110.31 242.79,110.53 242.79,110.55 242.83,110.59 242.84,110.59 243,110.71 243.03,110.91 243.05,110.99 243.13,111.03 243.54,111.03 243.66,110.95 243.79,110.93 243.82,110.93 243.98,110.78 243.98,110.33 243.9,110.15 243.98,109.97 243.98,109.7 243.85,109.45 243.98,109.2 243.98,109.06 243.79,108.87 241.37,108.87 241.18,109.06 241.18,110.84 241.37,111.03 241.44,111.03
+PEX_VDD on IN5: 210.7,60.32 210.7,91.01 227.23,107.54 243.97,107.54 243.97,108.48 243.98,108.49 243.98,114.16 242.98,115.16 220.14,115.16 219.27,114.29 219.28,114.28 219.28,111.49 218.31,110.52 218.31,107.05 214.54,103.28 207.52,103.28 207.34,103.09 207.34,94.14 206.38,93.18 206.38,57.34 215.11,48.61 232.82,48.61 233.31,49.09 233.31,55.43 232.38,56.36 214.66,56.36
+TBTA_VBUS on TOP (solid shape): outline of 213 points within 202.51,158.32 206.38,164.92
+TBTA_VBUS on TOP (solid shape): outline of 203 points within 190.32,175.53 194.34,180.1
+TBTA_VBUS on BOTTOM (solid shape): 194.28,178.93 194.28,177.17 193.92,176.82 193.92,176.75 193.9,176.63 193.92,176.5 193.92,176.2 193.79,176.06 193.59,176.06 193.45,176.21 193.45,177.01 193.96,177.52 193.96,178.94 194.02,179.01 194.2,179.01
+TBTA_VBUS on BOTTOM (solid shape): 202.79,160.67 202.79,159.78 202.81,159.77 202.81,159.71 203.04,159.47 203.04,159.35 203.3,159.1 203.3,158.8 203.22,158.72 203.05,158.72 202.88,158.88 202.83,158.88 202.54,159.17 202.54,159.27 202.54,159.28 202.56,159.4 202.54,159.53 202.54,159.54 202.54,159.68 202.57,159.71 202.57,160.65 202.62,160.7 202.77,160.7
+TBTA_VBUS on BOTTOM (solid shape): 191.41,178.99 191.41,178.95 191.39,178.85 191.41,178.75 191.41,178.71 191.43,178.69 191.5,178.6 191.58,178.53 191.74,178.38 191.74,177.91 191.74,177.9 191.74,177.4 191.92,177.23 191.92,176.32 191.79,176.2 191.56,176.2 191.42,176.34 191.42,178.4 191.23,178.59 191.05,178.59 190.96,178.68 190.96,178.92 191.11,179.07 191.33,179.07
+TBTA_VBUS on BOTTOM (solid shape): 209.11,165.96 209.11,164.87 208.52,164.27 206.1,164.27 205.96,164.41 205.51,164.41 205.33,164.23 205.01,164.42 204.78,164.13 204.45,163.8 203.58,163.8 203.26,163.48 203.01,163.48 202.97,163.52 202.97,163.75 202.84,163.88 202.61,163.88 202.55,163.94 202.56,163.95 202.56,164.24 202.6,164.28 202.84,164.28 202.98,164.42 202.98,164.62 203.11,164.74 203.23,164.74 203.4,164.91 204.1,164.91 204.19,165 204.6,165.07 204.67,165.48 205.04,165.85 205.05,165.85 205.34,166.15 208.92,166.15
+TBTA_VBUS on IN2 (solid shape): outline of 2850 points within 190.33,158.72 206.46,179.5
ADPIN on BOTTOM (solid shape): outline of 84 points within 76.38,32.67 86.37,47.78
AMP_ASEL on BOTTOM (solid shape): 35.37,15.34 35.89,15.34 35.96,15.28 35.96,14.77 35.89,14.7 35.64,14.7 35.51,14.58 35.51,14.13 35.38,14.01 35.13,14.01 35,14.13 35,14.58 34.88,14.7 34.55,14.7 34.42,14.83 34.42,15.28 34.48,15.34 35.37,15.34
AMP_LDO_A1.5V on BOTTOM (solid shape): 34.23,14.39 34.23,14.01 34.43,13.81 35.51,13.81 35.55,13.76 35.55,13.29 35.51,13.25 34.04,13.25 33.72,13.57 33.72,14.39 33.85,14.52 34.1,14.52
B+ on TOP (solid shape): 249.1,39.69 249.1,37.6 248.61,37.11 247.97,37.11 247.55,37.53 247.55,39.74 247.75,39.95 248.85,39.95
B+ on TOP (solid shape): 258.63,13.97 259.95,13.97 260.09,13.83 260.09,12.83 259.88,12.63 256.59,12.63 253.73,9.76 251.95,9.76 251.71,10 251.71,12.8 253.04,14.12 258.47,14.12
B+ on TOP (solid shape): outline of 158 points within 113.69,110.19 119.83,123.79
B+ on TOP (solid shape): outline of 954 points within 80.34,23.72 100.97,55.47
B+ on TOP (solid shape): outline of 1102 points within 130.73,134.53 156.41,158.98
B+ on BOTTOM (solid shape): 140.14,141.87 140.14,132.04 138.88,130.78 135.84,130.78 135.24,131.38 135.24,143.08 135.47,143.32 138.69,143.32
B+ on BOTTOM (solid shape): 235.23,37.06 235.23,35.09 234.93,34.8 233.43,34.8 233.16,35.08 233.16,35.63 233.7,35.63 233.7,36.06 233.16,36.06 233.16,37.03 233.5,37.38 234.91,37.38
B+ on BOTTOM (solid shape): 249.48,40.31 249.48,38.59 249.21,38.32 247.15,38.32 246.96,38.51 246.96,39.48 246.96,39.48 246.96,39.76 247.48,39.76 247.48,40.19 246.96,40.19 246.96,40.74 247.02,40.8 248.99,40.8
B+ on BOTTOM (solid shape): 156.8,169.12 158.05,169.12 158.17,169 158.17,168.83 158.16,168.82 158.16,168.59 158.01,168.45 156.5,168.45 156.25,168.2 156.25,168.01 155.98,167.74 155.98,166.84 155.95,166.81 155.2,166.81 154.14,167.87 151.52,167.87 151.35,168.04 151.35,168.66 151.47,168.78 153.28,168.78 153.69,169.19 154.38,169.19 154.92,169.74 156.18,169.74
B+ on BOTTOM (solid shape): 58.36,34.02 59.13,34.02 59.13,37.35 60.37,37.35 60.4,37.33 60.4,33.62 59.64,32.86 59.64,31.66 57.98,30 57.98,27.72 57.54,27.27 55.51,27.27 55.13,27.65 55.13,30.13 53.92,31.34 51.89,31.34 51.44,31.78 51.44,33.56 52.14,34.26 54.36,34.26 55.83,35.72 55.83,36.74 56.4,37.31 56.4,37.31 56.45,37.35 58.36,37.35
B+ on BOTTOM (solid shape): 104.25,62.36 104.25,60.03 100.33,56.11 100.33,54.82 96.97,51.46 96.97,50.45 96.4,49.88 94.69,49.88 94.37,50.2 94.37,51.98 97.25,54.86 97.25,55.65 97.42,55.82 97.42,58.14 100.03,60.74 100.03,60.88 100.7,61.55 100.7,62.56 100.88,62.75 103.87,62.75
B+ on BOTTOM (solid shape): 132.22,130.59 132.22,129.83 127.45,125.06 122.06,125.06 119.68,122.69 119.68,121.7 119.13,121.15 119.13,120.92 118.88,120.67 118.56,120.67 118.56,121.24 118.06,121.24 118.06,120.67 117.77,120.67 117.77,120.67 117.66,120.67 117.1,120.11 117.1,115.79 116.21,114.9 113.69,114.9 113.69,124.81 118.21,124.81 118.21,124.78 118.22,124.73 118.23,124.68 118.25,124.63 118.28,124.59 118.32,124.55 118.36,124.51 118.41,124.49 118.46,124.47 118.51,124.46 118.56,124.45 118.62,124.46 118.67,124.47 118.72,124.49 118.76,124.51 118.81,124.55 118.84,124.59 118.87,124.63 118.9,124.68 118.91,124.73 118.92,124.78 118.92,124.84 118.91,124.89 118.9,124.94 118.87,124.99 118.84,125.03 118.81,125.07 118.76,125.1 118.72,125.13 118.67,125.15 118.62,125.16 118.56,125.17 118.51,125.16 118.46,125.15 118.41,125.13 118.36,125.1 118.32,125.07 118.28,125.03 118.25,124.99 118.23,124.94 118.22,124.89 118.21,124.84 118.21,124.81 113.69,124.81 113.69,125.91 118.12,130.33 127.52,130.33 129.61,132.43 130.37,132.43
B+ on IN1 (solid shape): 207.93,6.79 207.93,4.75 207.46,4.28 204.55,4.28 204.35,4.48 204.35,7.08 204.54,7.27 207.45,7.27
B+ on IN1 (solid shape): 106.5,22.45 106.5,20.92 107.32,20.1 107.32,17.81 107.07,17.56 105.42,17.56 102.05,20.92 102.05,22.96 102.94,23.84 105.1,23.84
B+ on IN1 (solid shape): outline of 389 points within 223.4,4.3 254.21,11.24
B+ on IN2 (solid shape): outline of 568 points within 152.87,157.07 160.44,169.28
B+ on IN2 (solid shape): outline of 2698 points within 54.62,26.89 91.89,43.09
B+ on IN3 (solid shape): 120.32,123.56 120.32,121.88 120.11,121.67 117.53,121.67 116.77,120.91 116.77,116.04 116.4,115.67 113.98,115.67 113.69,115.96 113.69,122.58 115.04,123.93 119.95,123.93
B+ on IN3 (solid shape): outline of 359 points within 83.64,28.23 99.81,56.18
B+ on IN6 (solid shape): outline of 3457 points within 53.54,21.24 105.36,42.39
B+_BIAS on TOP (solid shape): 69.75,13.91 69.75,10.34 69.54,10.12 68.02,10.12 67.88,9.98 66.65,9.98 66.49,10.13 66.49,13.78 66.8,14.08 69.58,14.08
B+_BIAS on TOP (solid shape): 324.91,9.99 326.01,9.99 326.11,9.89 326.11,9.47 326.06,9.42 324.5,9.42 324.29,9.64 324.29,9.99 324.4,10.11 324.79,10.11
B+_BIAS on BOTTOM (solid shape): 29.51,3.49 29.51,2.75 29.48,2.71 28.79,2.71 28.46,2.38 28.46,1.98 28.03,1.56 27.25,1.56 27.12,1.68 27.12,3.02 27.5,3.4 27.95,3.4 28.08,3.53 29.48,3.53
B+_BIAS on IN2 (solid shape): 30.93,4.79 30.93,3.14 30.43,2.64 29.44,2.64 29.43,2.64 29.28,2.67 29.13,2.64 29.12,2.64 29.03,2.64 28.84,2.45 28.84,2.19 28.2,1.56 27.25,1.56 27.06,1.75 27.06,2.83 27.19,2.95 27.76,2.95 28.39,3.59 29.54,3.59 29.66,3.72 29.66,4.16 28.84,4.99 28.84,5.43 30.3,5.43
B+_BIAS on IN2 (solid shape): 69.92,8.29 69.67,8.03 67.2,8.03 67.19,8.06 66.86,8.28 66.53,8.06 66.52,8.03 65.92,8.03 65.73,8.22 65.73,9.89 65.77,9.9 65.98,10.08 66,10.36 66.02,10.45 66.1,10.5 69.92,10.5
B+_BIAS on IN2 (solid shape): 41.66,7.72 41.66,7.08 40.71,6.13 37.92,6.13 37.6,5.81 35.7,5.81 35.7,7.06 39.21,7.06 39.21,7 39.22,6.95 39.24,6.9 39.26,6.85 39.29,6.81 39.33,6.77 39.37,6.74 39.41,6.71 39.46,6.69 39.52,6.68 39.57,6.67 39.62,6.68 39.67,6.69 39.72,6.71 39.77,6.74 39.81,6.77 39.85,6.81 39.88,6.85 39.9,6.9 39.92,6.95 39.92,7 39.92,7.06 39.92,7.11 39.9,7.16 39.88,7.21 39.85,7.25 39.81,7.29 39.77,7.32 39.72,7.35 39.67,7.37 39.62,7.38 39.57,7.39 39.52,7.38 39.46,7.37 39.41,7.35 39.37,7.32 39.33,7.29 39.29,7.25 39.26,7.21 39.24,7.16 39.22,7.11 39.21,7.06 35.7,7.06 35.7,7.27 35.76,7.33 36.46,7.33 37.35,8.22 40.65,8.22 40.84,8.41 40.97,8.41
B+_VCCIO on BOTTOM (solid shape): 118.41,120.53 120.3,120.53 120.44,120.38 120.44,118.86 119.99,118.58 120.34,118.17 120.44,118.06 120.44,117.39 120.53,117.3 120.53,115.8 120.45,115.72 119.57,115.72 119.17,116.12 118.34,116.12 118.19,116.27 118.19,119.52 117.74,119.98 117.74,120.46 117.81,120.53 118.22,120.53 118.22,121.08 118.41,121.08
BATT+ on BOTTOM (solid shape): 87,27.08 88.65,27.08 88.72,27.02 88.72,23.15 88.34,22.77 83,22.77 81.23,20.99 78.81,20.99 78.56,21.24 78.56,23.34 78.62,23.4 79.47,23.4 79.47,23.4 79.47,21.94 79.83,21.58 80.18,21.94 80.18,23.4 81.03,23.4 81.42,23.78 81.42,27.15 81.73,27.46 86.62,27.46
BATT++ on TOP (solid shape): 85.67,20.48 85.67,19.15 85.35,18.83 82.94,18.83 82.81,18.96 82.81,20.54 83,20.73 85.42,20.73
BATT++ on BOTTOM (solid shape): 89.32,21.21 93.39,21.21 93.93,20.67 93.93,10.42 93.81,10.31 87.02,10.31 86.81,10.51 86.81,17.34 86.81,17.38 87.03,17.59 87.03,18.16 86.77,18.43 84.54,18.43 84.15,18.83 82.5,18.83 82.3,19.02 82.3,21.88 82.5,22.07 88.46,22.07
BOOT_1.2V on BOTTOM (solid shape): 90.05,44.1 91.55,44.1 91.6,44.05 91.6,43.93 91.56,43.9 90.31,43.9 89.69,43.28 89.29,43.28 89.23,43.34 89.23,44.23 89.29,44.29 89.86,44.29
BST_1.2V on BOTTOM (solid shape): 88.71,44.25 88.71,41.61 88.53,41.43 87.83,41.43 87.72,41.55 87.72,44.25 87.77,44.3 88.65,44.3
BST_3V on BOTTOM (solid shape): 56.4,45.19 57.48,45.19 57.6,45.06 57.6,44.23 57.54,44.17 56.9,44.17 55.95,45.12 55.06,45.12 54.93,45.25 54.93,45.31 55,45.38 56.2,45.38
BST_5V on BOTTOM (solid shape): 52.76,45.35 52.76,45.21 52.73,45.17 51.65,45.17 51.2,44.73 51.2,44.17 51,43.97 50.43,43.97 50.36,44.04 50.36,44.94 50.81,45.39 52.73,45.39
BST_+1VALWP on TOP (solid shape): 247.02,21.18 247.02,20.1 246.71,19.78 246.71,18.96 246.58,18.83 245.88,18.83 245.75,18.96 245.75,20.99 246.07,21.3 246.9,21.3
BST_VCCIO on BOTTOM (solid shape): 120.52,115.46 120.52,115.37 119.36,114.21 117.95,114.21 117.84,114.32 117.84,115.09 117.87,115.12 119.09,115.12 119.51,115.53 120.45,115.53
BTST_CHG on TOP (solid shape): 60.53,22.17 61.68,22.17 61.74,22.12 61.74,21.24 61.68,21.19 61.11,21.19 61.06,21.24 61.06,21.7 60.91,21.85 60.53,21.85 60.26,22.12 59.11,22.12 59.04,22.18 59.04,22.29 59.08,22.33 60.36,22.33
CHG_B+ on TOP (solid shape): 75,26.89 75,21.62 74.41,21.03 69.63,21.03 69.6,21.05 69.6,23.98 69.29,24.3 69.29,25.88 68.49,26.67 65,26.67 64.72,26.96 61.41,26.96 61.22,27.15 61.22,29.12 62.18,30.07 71.83,30.07
CHG_B+ on BOTTOM (solid shape): 62.81,30.07 64.84,30.07 65.16,29.75 65.16,27.46 64.59,26.89 59.64,26.89 59,27.53 59,30.07 59.76,30.83 62.05,30.83
CPU_B+ on TOP (solid shape): 181.43,145.4 181.43,143.85 181.43,143.8 181.31,143.68 181.06,143.68 180.26,142.88 180.26,142.81 180.25,142.81 180.25,142.54 180.2,142.48 179.44,142.48 179.09,142.83 176.08,142.83 176.06,142.85 176.06,144.77 176.19,144.9 177.99,144.9 178.18,144.71 180.08,144.71 180.31,144.94 180.31,145.41 180.48,145.58 181.26,145.58
CPU_B+ on TOP (solid shape): 148.6,148.75 148.6,146.81 148.6,146.81 148.6,146.51 148.53,146.45 148.47,146.37 147.7,146.37 147.52,146.19 147.52,145.73 147.41,145.61 146.87,145.61 146.39,146.1 143.26,146.1 143.25,146.1 143.25,146.96 143.32,147.02 144.37,147.02 144.63,147.28 144.63,148.55 144.76,148.68 145.66,148.68 145.75,148.6 145.75,148.01 145.85,147.91 147.5,147.91 147.71,148.12 147.71,148.68 147.84,148.81 148.54,148.81
CPU_B+ on TOP (solid shape): 164.6,144.8 164.6,143.35 164.42,143.18 163.82,143.18 163.62,142.98 163.62,140.76 163.46,140.6 162.98,140.6 162.8,140.77 162.8,142.61 162.55,142.85 159.48,142.85 159.28,143.06 159.28,143.64 159.16,143.76 159.04,143.88 158.91,144.01 158.82,144.01 158.79,144.04 158.79,144.53 158.88,144.61 159.43,144.61 159.81,144.99 164.4,144.99
CPU_B+ on TOP (solid shape): 172.92,145.36 172.92,143.23 172.73,143.04 172.17,143.04 171.95,142.82 171.95,142.37 171.84,142.26 171.32,142.26 170.79,142.79 170.13,142.79 170.08,142.79 170.03,142.79 169.48,142.79 169.43,142.79 169.38,142.79 168.83,142.79 168.78,142.79 168.74,142.79 168.18,142.79 168.14,142.79 168.09,142.79 167.87,142.79 167.77,142.88 167.77,144.11 168.07,144.41 168.07,144.6 168.42,144.95 170.68,144.95 170.93,144.7 171.73,144.7 171.96,144.94 171.96,145.16 172.26,145.45 172.82,145.45
CPU_B+ on TOP (solid shape): 154.36,148.58 154.36,148.08 154.46,147.97 155.26,147.97 155.38,148.1 156.02,148.1 156.24,148.32 156.86,148.32 156.92,148.25 156.99,148.19 156.99,146.23 156.44,145.68 155.33,145.68 154.93,146.09 154.18,146.09 154.07,146.11 153.95,146.09 153.53,146.09 153.42,146.11 153.3,146.09 152.89,146.09 152.77,146.11 152.65,146.09 152.24,146.09 152.12,146.11 152,146.09 151.71,146.09 151.6,146.2 151.6,147 151.65,147.06 152.92,147.06 153.26,147.4 153.26,148.56 153.4,148.7 154.24,148.7
CPU_B+ on TOP (solid shape): outline of 116 points within 182.16,138.64 188.2,144.32
CPU_B+ on BOTTOM (solid shape): 148.6,148.5 148.6,146.53 148.37,146.31 147.8,146.31 147.79,146.29 143.93,146.29 143.87,146.36 143.87,147.5 145.26,147.5 145.39,147.63 145.39,148.52 145.64,148.77 148.32,148.77
CPU_B+ on BOTTOM (solid shape): 173.11,145.26 173.11,143.35 172.76,143 168.28,143 168.21,143.07 168.21,144.14 168.24,144.16 169.64,144.16 169.74,144.25 169.74,145.23 169.99,145.48 172.89,145.48
CPU_B+ on BOTTOM (solid shape): 186.44,142.46 186.44,139.92 186.25,139.73 185.94,139.73 185.81,139.86 185.81,141.2 185.56,141.45 183.96,141.45 183.96,142.66 184.6,142.66 184.79,142.85 186.06,142.85
CPU_B+ on BOTTOM (solid shape): 140.08,147.24 140.08,145 140.09,145 140.09,143.42 139.9,143.22 139.01,143.22 138.69,143.54 136.09,143.54 135.46,144.17 135.46,146.76 135.55,146.85 136.21,146.85 136.58,147.23 136.59,147.23 136.75,147.4 139.92,147.4
CPU_B+ on BOTTOM (solid shape): 180.06,144.86 180.06,144.7 180.19,144.56 180.19,144.55 180.21,144.55 180.22,144.54 181.22,144.54 181.28,144.47 181.28,143.91 180.35,142.98 176.6,142.98 176.56,143.02 176.56,144.24 177.95,144.24 178.08,144.36 178.08,145.25 178.33,145.51 179.41,145.51
CPU_B+ on BOTTOM (solid shape): 163.44,145.49 163.65,145.28 163.93,145.37 164.5,145.37 164.72,145.15 164.72,143.35 164.68,143.31 164.67,143.3 164.54,143.22 164.46,143.09 164.45,143.08 164.42,143.05 159.94,143.05 159.9,143.1 159.9,144.26 161.28,144.26 161.41,144.39 161.41,145.28 161.66,145.53 163.43,145.53
CPU_B+ on BOTTOM (solid shape): 155.66,155.22 155.66,155.21 155.96,153.94 156.6,152.82 156.6,148.6 156.84,148.36 156.85,148.34 156.85,146.52 156.84,146.52 156.84,146.15 156.59,145.9 156.02,145.9 155.6,146.32 152.26,146.32 152.2,146.38 152.2,147.53 153.59,147.53 153.72,147.65 153.72,148.54 153.98,148.8 154.45,148.8 154.64,148.99 154.68,149 154.95,148.9 155.19,149 155.26,149.03 155.33,149 155.94,149.26 155.33,149.52 155.26,149.49 155.19,149.52 155.11,149.57 155.02,149.61 154.99,149.62 154.99,151.6 154.64,151.95 153.11,151.95 153.04,151.98 153.01,152.06 152.74,152.39 152.46,152.06 152.44,151.98 152.36,151.95 141.95,151.95 141.42,152.48 141.42,156.49 141.68,156.75 154.14,156.75
CPU_B+ on IN3 (solid shape): outline of 5946 points within 138.63,132.97 186.25,153.61
CPU_B+ on IN4 (solid shape): outline of 6031 points within 138.63,133.13 186.29,153.58
DH_1.2V on TOP (solid shape): 90.2,38.77 90.2,37.96 90.04,37.81 89.67,37.81 89.07,38.41 89.07,39.34 89.15,39.42 89.55,39.42
DH_1.2V on BOTTOM (solid shape): 91.59,43.65 91.59,43.54 91.53,43.48 90.72,43.48 90.5,43.26 90.5,43.09 90.14,42.73 89.96,42.73 89.95,42.72 89.81,42.72 89.7,42.83 89.7,43.1 89.81,43.2 89.98,43.2 90.12,43.35 90.12,43.52 90.31,43.71 91.53,43.71
DH_1.2V on IN4 (solid shape): 90.56,43.58 90.56,43.32 89.99,42.75 87.96,42.75 88.91,43.71 90.43,43.71
DH_1.2V on IN4 (solid shape): 88.78,40.04 89.61,39.21 89.61,38.39 89.48,38.26 89.23,38.26 89.04,38.45 89.04,38.7 87.77,39.97 87.77,40.42 87.83,40.48 88.78,40.48
DH_CHG on TOP (solid shape): 75.13,20.48 75.13,19.27 74.81,18.96 73.29,18.96 73.1,19.15 73.1,20.42 73.35,20.67 74.94,20.67
DH_CHG on TOP (solid shape): 62.18,22.77 62.3,22.77 62.37,22.7 62.37,22.45 62.23,22.31 60.59,22.31 60.38,22.52 59.08,22.52 59.03,22.57 59.03,22.69 59.08,22.74 60.57,22.74 60.61,22.78 62.16,22.78
DH_CHG on IN1 (solid shape): 62.81,22.19 62.81,21.75 62.49,21.43 61.92,21.43 61.22,22.13 61.22,22.61 61.42,22.8 62.2,22.8
DH_CHG on IN1 (solid shape): 75.07,20.42 75.07,19.4 74.94,19.27 72.97,19.27 72.72,19.53 72.72,20.16 73.1,20.54 74.94,20.54
DL_1.2V on TOP (solid shape): 95.92,35.82 95.92,33.78 95.77,33.62 95.45,33.62 95.32,33.75 95.32,34.77 95.45,34.89 95.45,35.85 95.51,35.91 95.83,35.91
DL_1.2V on BOTTOM (solid shape): 92,42.8 92,42.03 91.51,41.55 91.21,41.55 91.07,41.69 91.07,42.32 91.64,42.89 91.91,42.89
DL_1.2V on IN4 (solid shape): 96.47,35.66 96.47,34 96.08,33.62 95.51,33.62 95.39,33.75 95.39,35.08 95.07,35.4 95.07,35.78 95.51,36.23 95.89,36.23
DL_1.2V on IN4 (solid shape): 91.7,42.51 91.7,41.05 91.83,40.93 91.83,40.35 91.77,40.29 91.07,40.29 90.85,40.51 90.85,42.25 91.23,42.64 91.58,42.64
DL_CHG on TOP (solid shape): 65.35,21.75 65.35,20.86 65.22,20.73 64.4,20.73 64.21,20.92 64.21,21.5 64.59,21.88 65.22,21.88
DL_CHG on TOP (solid shape): 61.08,20.62 61.08,20.39 60.99,20.3 60.67,20.3 60.16,20.81 60.16,21.04 59.87,21.33 59.07,21.33 59.03,21.37 59.03,21.49 59.08,21.55 60.15,21.55
DL_CHG on IN4 (solid shape): 65.35,21.18 65.35,20.67 64.97,20.29 64.46,20.29 64.02,19.84 63.32,20.54 63.32,20.67 64.02,21.37 65.16,21.37
DL_CHG on IN4 (solid shape): 60.65,21.05 61.09,21.05 61.1,21.05 61.28,21.05 61.98,20.35 62.17,20.35 62.18,20.35 62.37,20.16 62.37,19.34 62.17,19.34 61.41,19.34 61.1,19.65 61.1,19.97 60.78,20.29 60.59,20.29 60.53,20.34 60.52,20.34 60.14,20.73 60.14,20.99 60.33,21.18 60.52,21.18
ECAGND on TOP (solid shape): 295.04,9.6 295.04,9.32 294.89,9.17 294.89,7.35 294.82,7.28 294.68,7.28 294.61,7.36 294.61,9.15 294.47,9.29 294.47,9.62 294.56,9.71 294.93,9.71
EN_TPLED on TOP (solid shape): 192.97,20.45 193.03,20.42 193.19,20.35 193.36,20.36 193.45,20.34 193.49,20.27 193.53,20.15 193.6,20.05 193.64,19.97 193.6,19.89 193.59,19.4 194.08,19.5 194.09,19.53 194.57,19.53 194.7,19.4 194.7,18.71 194.53,18.55 193.54,18.55 193.35,18.37 193.35,18.12 193.33,18.05 193.32,17.98 193.32,17.96 192.67,17.3 192.67,16.06 192.57,15.96 192.13,15.96 192.03,16.06 192.03,17.43 192.73,18.13 192.73,20.34 192.77,20.35 192.84,20.38 192.91,20.42
GPU_B+ on TOP (solid shape): outline of 163 points within 159,143.38 200.92,150.92
GPU_B+ on TOP (solid shape): outline of 708 points within 87.64,9.48 119.96,22.38
GPU_B+ on TOP (solid shape): outline of 1675 points within 261.84,7.75 277.26,32.54
GPU_B+ on BOTTOM (solid shape): 273.38,34.53 273.38,31.27 272.72,30.61 269.41,30.61 269.11,30.9 269.11,32.25 269.39,32.53 270.71,32.53 270.9,32.72 270.9,34.39 271.15,34.64 273.26,34.64
GPU_B+ on BOTTOM (solid shape): 264.79,23.17 264.79,22.91 264.67,22.79 264.05,22.79 263.98,22.72 263.98,22.72 263.68,22.42 263.65,22.38 263.65,21.36 263.5,21.22 261.49,21.22 261.45,21.25 261.45,22.12 261.45,22.64 262.15,23.34 264.63,23.34
GPU_B+ on BOTTOM (solid shape): outline of 132 points within 158.82,144.26 203.17,150.89
GPU_B+ on IN1 (solid shape): outline of 5303 points within 87.58,7.4 119.33,73.63
GPU_B+ on IN2 (solid shape): 207.72,7.14 207.72,4.54 207.51,4.33 204.5,4.33 204.35,4.48 204.35,7.08 204.54,7.27 207.59,7.27
GPU_B+ on IN2 (solid shape): 119.36,13.88 119.36,10.28 120.27,9.37 120.27,9.07 118.84,7.64 118.58,7.64 116.15,10.07 115.64,10.58 115.64,14.13 115.79,14.27 118.96,14.27
GPU_B+ on IN2 (solid shape): 187.07,8.24 187.07,7.27 185.56,5.76 185.16,5.76 181.25,9.67 171.73,9.67 171.29,10.11 154.38,10.11 154.02,10.47 154.02,12.86 154.46,13.3 154.5,13.3 154.95,13.75 181.56,13.75
GPU_B+ on IN2 (solid shape): outline of 864 points within 223.4,4.27 276.99,11.39
GPU_B+ on IN2 (solid shape): outline of 10842 points within 102.12,69.44 185.56,151.23
GPU_B+ on IN3 (solid shape): 207.72,7.14 207.72,4.54 207.47,4.29 204.54,4.29 204.35,4.48 204.35,7.08 204.54,7.27 207.59,7.27
GPU_B+ on IN3 (solid shape): 118.99,13.88 118.99,8.78 118.31,8.1 116.98,8.1 115.58,9.49 115.58,14 115.78,14.2 118.67,14.2
GPU_B+ on IN3 (solid shape): 174.39,12.15 184.27,12.15 187.07,9.35 187.07,7.35 185.56,5.84 185,5.84 181.17,9.67 172.05,9.67 171.71,10.01 154.07,10.01 153.49,10.59 153.49,12.64 154.47,13.62 172.92,13.62
GPU_B+ on IN3 (solid shape): outline of 1007 points within 223.4,4.22 276.74,11.56
GPU_B+ on IN4 (solid shape): 207.72,7.14 207.72,4.54 207.47,4.29 204.54,4.29 204.35,4.48 204.35,7.08 204.54,7.27 207.59,7.27
GPU_B+ on IN4 (solid shape): 119.71,13.37 119.71,11.12 119.7,11.11 119.67,10.95 119.7,10.8 119.71,10.79 119.71,8.99 118.63,7.91 117.86,7.91 115.64,10.13 115.64,14.06 115.81,14.23 118.84,14.23
GPU_B+ on IN4 (solid shape): 174.4,12.12 175,12.12 175.05,12.07 181.31,12.07 181.36,12.12 184.05,12.12 187.07,9.1 187.07,7.68 185.44,6.05 184.82,6.05 184.74,6.13 184.41,6.13 181.59,8.95 180.95,8.95 180.94,8.96 179.66,9.27 178.39,8.95 172.82,8.95 171.65,10.13 169.1,10.13 168.21,11.02 168.21,13.67 168.51,13.98 172.54,13.98
GPU_B+ on IN4 (solid shape): outline of 977 points within 223.4,4.22 276.74,11.97
GPU_B+ on IN5: 197.41,144.3 196.77,144.94 178.55,144.94 177.34,146.15 160.71,146.15 158.95,147.9 158.95,150.87 159.69,151.61 166.65,151.61 168.18,150.08 171.63,150.08 172.45,150.91 179.23,150.91 180.62,149.51 200.56,149.51 201.05,149.02 201.05,144.73 200.63,144.3
GPU_PH1 on TOP (solid shape): 258.63,145.03 258.63,143.61 258.43,143.4 257.34,143.4 257.18,143.55 257.18,145.33 257.29,145.43 258.23,145.43
GPU_PH1 on BOTTOM (solid shape): 252.93,148.24 252.93,147.03 253.12,146.84 256.8,146.84 258.58,145.07 259.53,145.07 259.79,144.81 259.79,141.51 259.72,141.45 257.63,141.45 257.63,142.33 256.87,142.33 256.87,141.45 254.64,141.45 251.91,144.18 251.91,148.24 251.98,148.3 252.87,148.3
GPU_PH2 on TOP (solid shape): 244.67,145.29 244.76,145.18 244.88,145.11 244.89,145.11 244.93,145.07 244.93,143.63 244.56,143.26 243.48,143.26 243.28,143.47 243.28,145.13 243.47,145.32 244.66,145.32
GPU_PH2 on BOTTOM (solid shape): 239.15,148.18 239.15,146.97 239.34,146.78 243.02,146.78 244.8,145 245.75,145 246.01,144.75 246.01,141.45 245.94,141.38 243.85,141.38 243.85,142.26 243.09,142.26 243.09,141.38 240.86,141.38 238.13,144.11 238.13,148.18 238.2,148.24 239.09,148.24
GPU_PH3 on TOP (solid shape): 231.15,145.07 231.15,143.43 230.95,143.22 229.76,143.22 229.56,143.43 229.56,145.07 229.75,145.26 230.96,145.26
GPU_PH3 on BOTTOM (solid shape): 225.45,148.13 225.45,146.89 225.62,146.72 229.31,146.72 231.09,144.94 232.04,144.94 232.29,144.69 232.29,141.38 232.23,141.32 230.13,141.32 230.13,142.2 229.37,142.2 229.37,141.32 224.86,141.32 224.47,141.71 224.47,148.08 224.6,148.21 225.38,148.21
GPU_PH4 on BOTTOM (solid shape): 211.78,148.11 211.78,146.91 211.97,146.72 215.65,146.72 217.43,144.94 218.39,144.94 218.6,144.72 218.6,144.7 218.61,144.61 218.63,144.53 218.64,144.52 218.64,143.58 218.63,143.57 218.6,143.42 218.63,143.26 218.64,143.25 218.64,141.38 218.58,141.32 216.48,141.32 216.48,142.2 215.72,142.2 215.72,141.32 213.5,141.32 212.36,142.45 212.36,142.48 212.25,142.78 211.95,142.89 211.92,142.89 210.77,144.05 210.77,148.11 210.83,148.18 211.72,148.18
GPU_SNB1 on TOP (solid shape): 260.38,143.62 260.38,141.85 260.23,141.7 257.46,141.7 257.32,141.84 257.32,142.67 257.5,142.84 258.45,142.84 258.46,142.85 258.66,142.85 259.26,143.45 259.28,143.46 259.28,143.68 259.37,143.78 260.22,143.78
GPU_SNB2 on TOP (solid shape): 246.45,143.66 246.45,141.85 246.33,141.73 243.59,141.73 243.48,141.84 243.48,142.79 243.49,142.81 244.75,142.81 245.48,143.53 245.48,143.63 245.56,143.72 246.4,143.72
GPU_SNB3 on TOP (solid shape): 232.66,143.52 232.66,141.76 232.57,141.68 229.73,141.68 229.66,141.74 229.66,142.77 229.75,142.86 231.11,142.86 231.61,143.35 231.85,143.59 232.59,143.59
GPU_SNB4 on BOTTOM (solid shape): 207.96,142.6 207.96,140.21 207.91,140.16 207.32,140.16 207.23,140.25 207.23,141.04 206.8,141.47 206.8,142.84 206.87,142.91 207.65,142.91
HP2_D_L_C on TOP (solid shape): 27.38,27.07 27.38,25.43 27.25,25.31 26.68,25.31 26.55,25.43 26.55,26.37 25.8,27.12 25.22,27.12 25.07,27.28 25.07,27.82 25.1,27.86 26.59,27.86
HP2_D_L_C on BOTTOM (solid shape): 27.44,26.32 27.44,24.8 26.87,24.23 23.44,24.23 21.85,22.64 21.85,20.91 21.74,20.8 19.57,20.8 19.44,20.92 19.44,22.86 20.92,24.34 21.77,24.34 22.81,25.37 25.92,25.37 26.36,25.81 26.36,26.19 26.62,26.45 27.31,26.45
HP2_D_R_C on TOP (solid shape): 25.84,24.53 26.05,24.53 26.17,24.42 26.17,23.4 25.98,23.21 25.02,23.21 24.88,23.35 24.88,23.8 25.07,24 25.07,24.5 25.11,24.54 25.84,24.54
HP2_D_R_C on BOTTOM (solid shape): 26.62,23.53 26.62,20.99 26.3,20.67 24.33,20.67 24.08,20.92 24.08,23.46 24.39,23.78 26.36,23.78
ISENSEP_L_R on TOP (solid shape): 38.87,3.53 38.87,2.51 38.86,2.51 38.74,2.39 38.74,2.39 38.55,2.2 37.85,2.2 37.16,2.89 36.97,2.89 36.84,3.02 36.83,3.02 36.83,3.53 36.9,3.6 37.66,3.6 37.79,3.72 38.68,3.72
ISENSEP_L_R on TOP (solid shape): 34.22,17.08 34.22,16.88 34.09,16.75 33.92,16.75 33.71,16.53 33.71,16.06 33.66,16.01 33.11,16.01 33.07,16.06 33.07,16.64 33.2,16.77 33.2,17.09 33.34,17.23 34.06,17.23
ISENSEP_L_R on BOTTOM (solid shape): 38.98,2.67 38.98,1.48 38.87,1.38 37.48,1.38 37.44,1.42 37.44,2.18 37.45,2.25 37.44,2.33 37.44,2.69 37.6,2.85 38.79,2.85
ISENSEP_L_R on IN1 (solid shape): 34.19,17.13 34.19,15.95 33.94,15.69 33.35,15.69 33.12,15.92 33.12,17.11 33.29,17.28 34.04,17.28
ISENSEP_L_R on IN1 (solid shape): 38.43,3.34 38.55,3.34 38.55,3.33 38.8,3.09 38.8,2.58 38.42,2.2 37.79,2.2 37.54,2.45 37.53,2.45 36.9,3.08 36.9,4.04 37.73,4.04
ISENSEP_R_R on TOP (solid shape): 29.26,16.61 29.26,16.26 29.22,16.22 29.22,15.68 29.07,15.53 28.49,15.53 28.39,15.63 28.39,16.04 28.26,16.17 28.26,16.55 28.39,16.68 29.19,16.68
ISENSEP_R_R on TOP (solid shape): 33.22,2.19 33.22,1.24 33.16,1.18 31.57,1.18 31.5,1.24 31.5,1.56 31.63,1.68 32.71,1.68 32.71,2 32.58,2.13 32.14,2.13 32.14,2.51 32.9,2.51
ISENSEP_R_R on BOTTOM (solid shape): 32.83,4.15 32.83,1.45 32.55,1.18 31.63,1.18 31.44,1.37 31.44,1.87 31.98,2.42 31.98,3.13 31.99,3.18 31.98,3.24 31.98,3.72 31.99,3.78 31.98,3.83 31.98,4.16 32.02,4.19 32.79,4.19
ISENSEP_R_R on IN1 (solid shape): 29.3,16.62 29.3,15.39 29.1,15.19 28.48,15.19 28.24,15.42 28.24,16.69 28.3,16.75 29.18,16.75
ISENSEP_R_R on IN1 (solid shape): 33.03,1.49 32.71,1.17 31.57,1.17 31.44,1.3 31.44,1.68 32.01,2.25 32.01,2.64 33.03,2.64
LG_3V on TOP (solid shape): 47.06,31.97 47.06,31.27 46.36,30.58 46.11,30.58 45.92,30.77 45.92,31.57 46.45,32.1 46.94,32.1
LG_3V on BOTTOM (solid shape): 55.89,43.53 55.89,43.22 55.76,43.09 55.19,43.09 54.55,43.73 54.55,44.49 54.68,44.61 54.81,44.61
LG_3V on IN1 (solid shape): 48.27,30.96 47.82,30.51 46.24,30.51 45.86,30.89 45.86,31.53 46.05,31.72 48.27,31.72
LG_3V on IN1 (solid shape): 55.89,43.53 55.89,42.96 56.84,42.01 56.84,41.44 56.59,41.19 56.27,41.19 55,42.46 55,43.34 54.81,43.53 54.81,43.92 54.93,44.04 55.38,44.04
LG_5V on TOP (solid shape): 48.65,36.16 48.65,35.65 48.63,35.58 48.62,35.52 48.62,35.5 48.38,35.26 46.98,35.26 46.87,35.37 46.87,35.78 46.94,35.85 47.57,35.85 47.7,35.97 47.7,36.23 47.76,36.29 48.52,36.29
LG_5V on BOTTOM (solid shape): 53.16,44.49 53.16,43.73 52.97,43.53 52.97,43.09 52.78,42.9 52.46,42.9 52.33,43.03 52.33,43.98 52.9,44.55 53.09,44.55
LG_5V on IN1 (solid shape): 48.65,36.99 48.65,35.53 48.46,35.34 48.08,35.34 47.63,35.78 47.63,37.05 48.59,37.05
LG_5V on IN1 (solid shape): 53.03,43.92 53.03,41.95 52.77,41.69 52.02,41.69 51.95,41.76 51.95,42.96 52.27,43.28 52.27,43.85 52.46,44.04 52.9,44.04
LG_+1VALWP on TOP (solid shape): 256.62,19.39 257.36,19.39 257.48,19.27 257.48,17.98 257.32,17.82 256.29,17.82 256.14,17.98 256.14,19.29 256.31,19.45 256.56,19.45
LG_+1VALWP on TOP (solid shape): 247.13,16.59 247.13,16.34 247.28,16.19 247.28,16.03 247.28,15.59 246.81,15.12 246.3,15.12 245.79,15.63 245.79,17.02 245.92,17.15 246.57,17.15
LG_+1VALWP on IN1 (solid shape): 256.92,19.22 256.92,18.46 256.66,18.21 255.49,18.21 255.3,18.4 255.3,19.11 255.69,19.49 256.65,19.49
LG_+1VALWP on IN1 (solid shape): 248,17.04 248,16.39 247.42,15.81 247.25,15.64 246.99,15.64 246.41,16.21 246.41,16.48 247.21,17.28 247.76,17.28
LINE1_L on BOTTOM (solid shape): 26.25,30.37 27.13,30.37 27.18,30.42 29.09,30.42 29.12,30.38 29.12,30.22 29.09,30.18 27.66,30.18 27.54,30.21 27.42,30.18 27.28,30.18 27.17,30.07 26.13,30.07 25.98,29.91 25.98,29.5 25.72,29.24 23.63,29.24 23.06,28.67 23.06,27.53 22.11,26.58 21.67,26.58 21.48,26.63 21.3,26.58 20.92,26.58 20.82,26.59 20.73,26.58 19.19,26.58 19.06,26.7 19.06,29.05 19.19,29.18 21.92,29.18 23.17,30.44 26.19,30.44
LINE1_R on BOTTOM (solid shape): 29.12,29.95 29.12,29.85 29.06,29.79 27.41,29.79 27.01,29.39 27.01,26.8 26.91,26.7 26.51,26.7 26.45,26.64 23.98,26.64 23.97,26.66 23.97,29.04 23.98,29.05 25.85,29.05 26.11,29.31 26.11,29.81 26.23,29.94 27.26,29.94 27.33,30.02 29.06,30.02
LX_1.0VS_VGAP on BOTTOM (solid shape): 246.97,46.74 246.97,45.22 247.56,44.63 247.56,42.46 247.53,42.44 246.83,42.44 246.78,42.49 243.1,42.49 242.78,42.17 242.21,42.17 242.13,42.25 242.13,43.17 242.29,43.33 242.29,43.63 242.59,43.94 244.12,43.94 244.33,44.15 244.33,46.72 244.83,47.21 246.5,47.21
LX_3V on TOP (solid shape): 50.05,29.37 52.08,29.37 52.21,29.24 52.21,26.96 49.79,24.54 44.01,24.54 43.58,24.97 43.58,27.43 43.68,27.53 45.22,27.53 46.43,28.73 46.43,30.32 46.68,30.58 48.84,30.58
LX_3V on BOTTOM (solid shape): 51.82,30.07 51.82,25.75 50.55,24.48 44.59,24.48 44.27,24.8 44.27,27.78 46.87,30.39 51.51,30.39
LX_3V on BOTTOM (solid shape): 57.35,46.14 57.79,46.14 57.86,46.07 57.86,45.5 57.79,45.43 57.42,45.43 57.41,45.44 56.4,45.44 56.27,45.57 55,45.57 54.93,45.63 54.93,45.76 55,45.82 56.01,45.82 56.33,46.14 57.35,46.14
LX_3V on IN4 (solid shape): 57.98,44.93 57.98,44.68 57.86,44.55 56.71,44.55 56.01,45.25 56.01,45.88 56.14,46.01 56.9,46.01
LX_3V on IN4 (solid shape): 51.37,26.73 51.37,26.68 50.41,25.71 49.62,25.71 49.54,25.72 49.46,25.71 48.99,25.71 48.9,25.72 48.82,25.71 48.48,25.71 48.36,25.84 48.36,25.86 48.37,25.94 48.36,26.02 48.36,26.39 48.63,26.65 49.84,26.65 50.62,27.43 50.67,27.43
LX_5V on TOP (solid shape): 43.75,37.26 45.93,37.26 46.05,37.14 46.05,35.91 46.3,35.66 46.3,33.45 46.22,33.37 41.22,33.37 41.2,33.39 41.14,33.39 40.04,34.49 40.04,36.63 40.01,36.65 40.01,37.62 40.33,37.94 43.06,37.94
LX_5V on BOTTOM (solid shape): 47.13,35.4 47.13,32.29 46.94,32.1 42.55,32.1 39.7,34.96 39.7,37.24 40.3,37.85 44.68,37.85
LX_5V on BOTTOM (solid shape): 50.98,46.02 51.14,45.97 51.3,46.02 51.43,46.02 51.66,45.8 52.74,45.8 52.78,45.76 52.78,45.63 52.71,45.57 50.67,45.57 50.43,45.33 49.96,45.33 49.88,45.4 49.88,45.96 49.94,46.02
LX_5V on IN4 (solid shape): 51.63,45.82 51.63,45.38 50.93,44.68 50.3,44.68 50.11,44.87 50.11,45.5 50.62,46.01 51.44,46.01
LX_5V on IN4 (solid shape): 44.4,38.13 44.4,37.43 43.82,36.86 43.32,36.86 43.19,36.99 43.19,37.24 42.93,37.5 42.93,38.13 43.51,38.7 43.82,38.7
LX_+1.8VGS on BOTTOM (solid shape): 231.2,48.31 231.2,46.64 232.48,45.37 232.48,43.44 233.03,42.89 233.03,42 232.89,41.87 230.9,41.87 230.6,41.57 229.95,41.57 229.91,41.61 229.91,42.51 230.03,42.64 230.03,43.77 230.02,43.78 230.02,44.49 229.62,44.89 229.62,48.32 229.66,48.37 231.14,48.37
LX_CHG on TOP (solid shape): 62.05,23.78 62.05,23.02 61.98,22.96 60.44,22.96 60.4,22.92 59.1,22.92 59.04,22.97 59.04,23.08 59.11,23.15 59.95,23.15 60.97,24.16 61.67,24.16
LX_CHG on TOP (solid shape): 69.35,23.65 69.35,20.99 69.6,20.73 71.95,20.73 72.53,20.16 72.53,18.89 72.34,18.7 66.24,18.7 65.67,19.27 65.67,24.16 65.92,24.42 68.59,24.42
LX_CHG on BOTTOM (solid shape): outline of 100 points within 63.8,19.78 69.68,25.91
LX_CHG on IN1 (solid shape): 61.86,23.95 62.11,23.95 62.11,23.08 61.98,22.96 60.91,22.96 60.58,23.28 60.58,23.68 61.06,24.16 61.64,24.16
LX_CHG on IN1 (solid shape): 66.81,21.88 66.81,20.73 66.62,20.54 65.79,20.54 65.67,20.67 65.67,21.56 65.22,22 65.22,22.07 65.79,22.64 66.05,22.64
LX_VCCIO on BOTTOM (solid shape): 121.33,115.08 121.33,112.51 121.56,112.28 122.36,112.28 122.61,111.88 122.87,112.28 127.36,112.28 127.55,112.09 127.55,110.69 127.32,110.46 125.06,110.46 123.58,108.98 120.86,108.98 120.44,109.4 120.44,115.04 120.62,115.22 121.19,115.22
Net_138 on TOP (solid shape): 157.78,13.34 149.78,13.34 149.78,21.34 157.78,21.34
Net_139 on TOP (solid shape): 147.64,20.25 132.64,20.25 132.64,30.25 147.64,30.25
NVVDD_B+ on TOP (solid shape): 222.58,150.65 222.58,149.38 222.39,149.19 217.12,149.19 216.99,149.32 216.99,150.65 217.15,150.81 222.42,150.81
NVVDD_B+ on TOP (solid shape): 262.96,152.95 263.03,152.95 263.36,152.62 263.37,152.62 263.72,152.27 263.72,149.51 263.53,149.32 258.26,149.32 258.14,149.45 258.14,150.78 259.79,152.43 259.79,152.6 260.16,152.98 262.96,152.98
NVVDD_B+ on TOP (solid shape): 236.23,152 236.23,149.32 236.04,149.13 230.77,149.13 230.64,149.26 230.64,150.59 232.48,152.43 232.49,152.43 232.49,152.64 232.51,152.66 232.51,152.79 232.52,152.83 232.55,152.87 235.37,152.87
NVVDD_B+ on TOP (solid shape): 246.84,152.91 246.9,152.91 247.48,152.91 247.53,152.91 248.11,152.91 248.17,152.91 248.75,152.91 248.8,152.91 249.13,152.91 249.94,152.1 249.94,149.45 249.75,149.26 244.48,149.26 244.36,149.38 244.36,150.94 246.33,152.91
NVVDD_B+ on BOTTOM (solid shape): 209.24,146.34 209.24,146.24 209.5,145.99 209.5,143.22 209.3,143.03 205.05,143.03 204.86,143.22 204.86,145.38 204.92,145.45 207.46,145.45 207.49,145.47 207.49,146.11 207.72,146.34 209.05,146.34
NVVDD_B+ on BOTTOM (solid shape): 230.58,150.84 232.42,150.84 232.74,150.53 236.04,150.53 236.23,150.34 236.23,148.24 236.04,148.05 231.08,148.05 230.89,148.24 230.89,148.75 230.39,149.26 227.66,149.26 227.53,149.38 227.53,150.53 227.66,150.65 228.93,150.65 229.05,150.78 229.05,151.67 229.12,151.73 229.69,151.73
NVVDD_B+ on BOTTOM (solid shape): 258.07,150.97 259.91,150.97 260.23,150.65 263.53,150.65 263.72,150.46 263.72,148.37 263.53,148.18 258.58,148.18 258.39,148.37 258.39,148.88 257.88,149.38 255.15,149.38 255.02,149.51 255.02,150.65 255.15,150.78 256.42,150.78 256.55,150.91 256.55,151.8 256.61,151.86 257.18,151.86
NVVDD_B+ on BOTTOM (solid shape): 244.29,150.91 246.13,150.91 246.45,150.59 249.75,150.59 249.94,150.4 249.94,148.3 249.75,148.11 244.8,148.11 244.61,148.3 244.61,148.81 244.1,149.32 241.37,149.32 241.25,149.45 241.25,150.59 241.37,150.72 242.64,150.72 242.77,150.84 242.77,151.73 242.83,151.8 243.4,151.8
NVVDD_B+ on BOTTOM (solid shape): 217.14,153.23 217.2,153.06 217.33,152.94 217.17,152.48 217.62,152.29 217.65,152.28 217.81,152.11 222,152.11 222.51,151.6 222.51,150.62 222.57,150.57 222.57,150.34 222.58,150.34 222.58,148.24 222.39,148.05 217.43,148.05 217.24,148.24 217.24,148.75 216.73,149.26 214,149.26 213.88,149.38 213.88,150.53 214,150.65 215.27,150.65 215.4,150.78 215.4,151.67 215.46,151.73 215.46,152.27 215.46,152.27 215.46,153.03 215.51,153.07 215.59,153.14 215.65,153.22 215.66,153.23
NVVDD_B+ on IN6 (solid shape): outline of 3575 points within 207.46,142.65 264.93,150.53
NVVDD_B+ on IN5: 207.08,143.73 207.08,151.63 208.2,152.75 241.27,152.75 241.78,152.24 264.51,152.24 264.87,151.88 264.87,148.79 264.44,148.37 213.71,148.37 209.07,143.73
NVVDDS_B+ on TOP (solid shape): outline of 517 points within 274.47,34.39 290.2,48.17
NVVDDS_B+ on BOTTOM (solid shape): 278.3,38.52 278.3,34.77 278.1,34.58 275.37,34.58 275.02,34.93 272.88,34.93 272.49,35.32 272.49,38.73 272.64,38.88 272.66,38.89 277.92,38.89
NVVDDS_B+ on BOTTOM (solid shape): 289.41,49.09 290.55,49.09 290.9,48.74 290.9,39.34 290.67,39.11 290.06,39.11 289.9,39.27 289.9,39.74 289.77,39.88 287.93,39.88 287.7,39.65 287.7,38.84 287.57,38.7 285.63,38.7 285.38,38.96 285.38,44.39 286.57,44.39 286.57,42.76 286.82,42.52 287.42,42.52 287.69,42.79 287.69,44.17 287.7,44.2 287.7,44.25 287.7,44.3 287.7,44.35 287.69,44.37 287.69,44.43 287.64,44.47 287.62,44.5 287.58,44.55 287.49,44.62 287.38,44.63 287.31,44.63 287.28,44.62 286.81,44.62 286.57,44.39 285.38,44.39 285.38,45.18 288.17,45.18 288.17,44.21 288.76,43.62 289.22,43.62 289.59,43.99 289.59,45.24 289.33,45.5 288.49,45.5 288.17,45.18 285.38,45.18 285.38,48.84 285.42,48.89 285.99,48.89 286.12,48.76 286.12,48.43 286.33,48.22 287.96,48.22 288.25,48.5 288.25,48.94 288.46,49.15 289.34,49.15
NVVDDS_BST1 on TOP (solid shape): 305.52,52.98 305.76,52.98 306.87,51.87 306.87,51.63 307.11,51.39 307.11,50.62 307.03,50.54 306.41,50.54 306.36,50.6 306.36,51.57 305.19,52.74 304.55,52.74 304.49,52.8 304.49,52.93 304.55,52.99 305.51,52.99
NVVDDS_BST2 on TOP (solid shape): 302.38,52.88 302.38,52.58 300.89,51.09 299.8,51.09 299.68,51.21 299.68,52.04 299.72,52.08 299.9,52.08 300.45,52.63 301.15,52.63 301.49,52.97 302.28,52.97
NVVDDS_LG1 on TOP (solid shape): 303.95,52.52 303.95,51.64 304.67,50.92 304.67,50.13 304.55,50.02 303.99,50.02 303.92,50.08 303.92,51 303.73,51.19 303.73,52.52 303.76,52.55 303.92,52.55
NVVDDS_LG1 on BOTTOM (solid shape): 295.59,45.05 295.59,44.17 295.43,44.01 294.58,44.01 294.43,44.15 294.41,44.18 294.41,45.17 294.59,45.35 295.29,45.35
NVVDDS_LG1 on BOTTOM (solid shape): 295.02,39.42 295.02,38.97 294.92,38.88 294.92,38.36 294.81,38.25 294.01,38.25 293.86,38.39 293.86,38.74 294.13,39.01 294.13,39.35 294.37,39.59 294.85,39.59
NVVDDS_LG1 on IN1 (solid shape): 296.32,44.75 296.32,43.81 296.27,43.76 294.5,43.76 294.43,43.83 294.43,44.7 294.53,44.8 296.28,44.8
NVVDDS_LG1 on IN1 (solid shape): 304.85,50.89 304.85,50.54 304.16,49.85 304.01,49.85 303.34,50.52 303.34,50.65 303.61,50.92 303.61,51.35 303.88,51.61 304.12,51.61
NVVDDS_LG1 on IN2 (solid shape): 295.63,44.52 295.63,43.28 295.46,43.11 294.75,43.11 294.5,43.36 294.5,44.53 294.66,44.69 295.47,44.69
NVVDDS_LG1 on IN2 (solid shape): 294.65,40.14 294.65,39.53 294.95,39.23 294.95,38.34 294.82,38.21 294.07,38.21 293.86,38.41 293.86,38.72 293.62,38.96 293.62,40.1 293.79,40.26 294.53,40.26
NVVDDS_LG2 on TOP (solid shape): 303.15,52.5 303.15,51.68 303.17,51.66 303.17,51.19 303.15,51.16 303.15,51.06 303.09,51.01 303.09,50.02 302.3,50.02 302.23,50.09 302.23,50.99 302.93,51.7 302.93,52.49 302.98,52.54 303.11,52.54
NVVDDS_LG2 on BOTTOM (solid shape): 282.08,44.03 282.08,43.37 282.01,43.3 282.01,42.96 281.71,42.66 281.21,42.66 281,42.87 281,44.06 281.07,44.13 281.97,44.13
NVVDDS_LG2 on BOTTOM (solid shape): 282.22,49.64 282.22,49.38 281.86,49.02 281.86,48.57 281.67,48.38 281.24,48.38 281.02,48.6 281.02,49.62 281.22,49.82 282.04,49.82
NVVDDS_LG2 on IN1 (solid shape): 282.38,49.78 283.03,49.78 283.91,48.9 283.91,48.88 283.37,48.34 283,48.34 282.63,48.71 281.14,48.71 281.05,48.8 281.05,49.68 281.16,49.79 282.38,49.79
NVVDDS_LG2 on IN1 (solid shape): 303.37,51.22 303.37,50.99 302.65,50.27 302.38,50.27 301.87,49.77 301.67,49.77 301.2,50.24 301.2,50.56 301.67,51.03 302.18,51.03 302.79,51.65 302.94,51.65
NVVDDS_LG2 on IN2 (solid shape): 281.88,45.04 281.88,44.19 282.13,43.94 282.13,43.58 282.01,43.46 281.23,43.46 280.98,43.7 280.98,45.03 281.1,45.14 281.78,45.14
NVVDDS_LG2 on IN2 (solid shape): 282.22,49.54 282.22,49.28 281.9,48.96 281.9,48.13 281.81,48.04 280.94,48.04 280.87,48.11 280.87,49.42 281.2,49.75 282.01,49.75
NVVDDS_SW1 on TOP (solid shape): 304.36,52.48 304.36,52.15 306.53,49.99 306.53,48.39 306.44,48.31 305.74,48.31 305.44,48.61 305.44,49.4 305.24,49.6 305.19,49.67 305.11,49.73 305.01,49.83 305.01,50.75 304.78,50.98 304.78,51 304.68,51.21 304.47,51.31 304.45,51.31 304.14,51.63 304.14,52.51 304.17,52.55 304.3,52.55
NVVDDS_SW2 on TOP (solid shape): 302.75,52.51 302.75,51.69 302.36,51.3 302.34,51.3 302.21,51.21 302.12,51.07 302.12,51.06 300.98,49.92 300.98,49.15 300.71,48.88 300.01,48.88 299.91,48.99 299.91,49.69 299.67,49.92 299.67,50.8 299.84,50.96 300.94,50.96 302.52,52.55 302.71,52.55
NVVDDS_VIDBUF on TOP (solid shape): 306.21,57.63 306.21,56.67 304.3,54.77 304.17,54.77 304.11,54.83 304.11,55.59 305.57,57.06 305.57,57.63 305.63,57.69 306.14,57.69
ON/OFF# on TOP (solid shape): 212.65,166.74 212.65,165.55 212.65,165.55 212.65,165.17 212.5,165.02 212.5,164.66 212.4,164.57 212.15,164.57 211.98,164.73 211.98,166.75 212.12,166.89 212.51,166.89
OUT_A on TOP (solid shape): 36.36,6.67 36.36,5.69 36.53,5.52 37,5.52 37.12,5.4 37.12,5.4 37.66,4.86 37.66,3.91 37.59,3.85 36.9,3.85 36.83,3.91 36.83,4.4 36.67,4.57 36.8,4.96 36.48,5.21 36.36,5.34 36.28,5.48 36.14,5.57 36.14,6.67 36.19,6.72 36.31,6.72
OUT_A on BOTTOM (solid shape): 40.06,5.97 40.06,5.92 39.31,5.18 38.87,5.18 38.55,4.86 38.55,4.48 38.43,4.35 37.53,4.35 36.79,5.09 36.79,5.09 36.71,5.18 36.71,5.43 36.79,5.5 37.4,5.5 37.67,5.24 38.49,5.24 38.87,5.62 38.87,6.03 39.42,6.57 39.46,6.57
OUT_B on TOP (solid shape): 35.16,6.65 35.16,5.75 35.66,5.25 35.76,4.99 36.03,4.88 36.11,4.8 36.24,4.58 36.5,4.5 36.52,4.48 36.52,3.08 36.52,3.08 36.52,2.51 36.58,2.45 36.58,2.25 36.39,2.06 36.2,2.06 35.94,2.32 35.94,3.47 35.5,3.91 35.5,4.8 35.27,5.03 35.27,5.21 34.95,5.53 34.95,6.65 35,6.7 35.11,6.7
OUT_C on TOP (solid shape): 33.15,6.66 33.15,5.65 32.66,5.17 32.66,3.72 32.91,3.47 33.66,3.47 33.82,3.32 33.82,2.67 33.78,2.64 33.28,2.64 33.09,2.83 32.14,2.83 32.05,2.91 32.05,4.95 32.15,5.04 32.15,5.45 32.28,5.58 32.69,5.58 32.95,5.84 32.95,6.66 33,6.72 33.1,6.72
OUT_D on TOP (solid shape): 28.08,7.46 28.08,6.57 27.89,6.38 26.81,6.38 26.68,6.51 26.68,7.4 26.81,7.53 28.01,7.53
OUT_D on TOP (solid shape): 31.96,6.68 31.96,5.75 32.02,5.69 32.02,5.13 31.88,4.99 31.88,3.2 31.7,3.02 30.81,3.02 30.74,3.09 30.74,4.79 30.81,4.86 30.98,4.86 31.74,5.62 31.74,6.67 31.79,6.72 31.92,6.72
OUT_D on IN1 (solid shape): outline of 245 points within 26.42,2.83 31.89,7.53
P1 on TOP (solid shape): 70.32,39.24 70.32,36.04 70.14,35.86 69.48,35.86 68.87,35.25 68.87,34.89 68.9,34.86 68.94,34.79 68.98,34.73 68.98,34.53 68.89,34.45 68.56,34.45 67.45,34.45 67.24,34.25 66.54,34.25 66.43,34.36 66.43,37.81 66.75,38.13 67.3,38.13 67.87,38.7 67.87,38.75 67.89,38.76 67.89,39.34 68.23,39.68 69.88,39.68
P1 on BOTTOM (solid shape): 69.02,39.33 69.02,38.2 69.01,38.19 68.97,38.01 69.01,37.82 69.02,37.81 69.02,37.65 69.43,37.24 70.37,37.24 70.49,37.12 70.49,34.13 70.18,33.81 68.73,33.81 68.23,34.31 68.13,34.48 67.96,34.58 67.63,34.91 66.82,34.91 66.56,35.17 66.56,38.44 67.89,39.77 68.57,39.77
