# Allegro board LAD751PR10-0813-B.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on BOTTOM (solid shape): 180.4,171.41 180.4,170.37 180.02,169.99 180.02,169.62 180,169.6 179.68,169.6 179.65,169.63 179.65,170.07 179.56,170.16 178.95,170.16 178.86,170.08 178.86,168.59 179.08,168.37 179.08,168.28 179.09,168.27 179.72,168.27 179.78,168.32 179.78,168.5 179.87,168.59 180.06,168.59 180.29,168.37 180.29,167.55 180.16,167.42 180.01,167.42 179.9,167.42 179.76,167.56 179.76,167.57 179.65,167.67 179.27,167.67 178.82,168.12 178.57,168.12 178.44,168.24 178.44,168.88 178.25,169.07 178.25,170.68 178.31,170.74 178.35,170.82 178.82,171.29 179.1,171.29 179.29,171.49 180.31,171.49
GND on BOTTOM (solid shape): 230.51,148.75 230.51,148.24 230.83,147.92 237.24,147.92 237.75,147.42 237.75,141.18 237.57,140.88 237.75,140.57 237.75,140.29 237.66,140.05 237.75,139.81 237.75,139.34 237.71,139.22 237.71,139.09 237.72,139.06 237.5,138.84 233.05,138.84 232.86,139.03 232.86,144.56 232.23,145.19 231.15,145.19 229.5,146.84 225.81,146.84 225.69,146.97 225.69,148.05 225.81,148.18 226.45,148.18 226.51,148.24 226.51,148.94 226.64,149.07 230.2,149.07
GND on BOTTOM (solid shape): 216.2,40.27 216.2,39.95 215.91,39.65 215.84,39.6 215.78,39.52 215.76,39.41 215.78,39.31 215.84,39.23 215.92,39.16 216.04,39.15 216.1,39.12 216.12,39.07 216.13,38.98 216.13,38.94 215.97,38.78 215.44,38.78 215.42,38.79 215.25,38.96 215.25,39.14 215.12,39.26 214.38,39.26 214.31,39.33 214.31,39.58 215.23,40.5 215.97,40.5
GND on BOTTOM (solid shape): 180.41,142.69 180.46,142.61 180.53,142.55 180.53,142.3 180.96,141.86 181.02,141.8 182.02,141.8 182.13,141.7 182.13,141.53 182.06,141.46 181.28,141.46 181.15,141.34 181.15,141.28 181.15,141.27 181.14,141 181.38,140.86 181.98,140.86 182.02,140.87 182.07,140.88 182.63,140.88 182.63,140.88 183.01,141.26 185.56,141.26 185.68,141.13 185.68,139.81 185.68,139.8 185.68,139.48 185.62,139.42 184.79,139.42 184.6,139.61 182.25,139.61 181.36,138.72 181.36,137.07 181.19,136.9 179.02,136.9 178.94,136.98 178.94,138.56 178.72,138.79 178.72,140.44 178.46,140.69 174.78,140.69 174.78,141.84 175.6,141.84 175.6,142.72 180.39,142.72
GND on BOTTOM (solid shape): 144.85,162.21 146.28,162.21 146.47,162.02 151.35,162.02 151.44,162.11 153.39,162.11 153.86,161.65 153.86,157.89 153.35,157.39 142.63,157.39 142.06,157.96 142.06,160.66 146.05,160.66 146.05,160.63 146.06,160.58 146.08,160.52 146.1,160.48 146.13,160.43 146.17,160.39 146.21,160.36 146.25,160.33 146.3,160.31 146.35,160.3 146.41,160.3 146.46,160.3 146.51,160.31 146.56,160.33 146.61,160.36 146.65,160.39 146.69,160.43 146.72,160.48 146.74,160.52 146.76,160.58 146.76,160.63 146.76,160.68 146.76,160.73 146.74,160.79 146.72,160.83 146.69,160.88 146.65,160.92 146.61,160.95 146.56,160.98 146.51,161 146.46,161.01 146.41,161.01 146.35,161.01 146.3,161 146.25,160.98 146.21,160.95 146.17,160.92 146.13,160.88 146.1,160.83 146.08,160.79 146.06,160.73 146.05,160.68 146.05,160.66 142.06,160.66 142.06,161.83 142.42,162.19 142.47,162.21 144.69,162.21
GND on BOTTOM (solid shape): 235.07,99.12 235.14,99.09 235.17,99.06 235.2,99.03 235.25,98.95 235.2,98.87 235.13,98.8 235.07,98.7 235.07,98.7 234.97,98.55 234.95,98.53 234.94,98.52 234.86,98.46 234.79,98.38 234.79,98.37 234.65,98.23 234.63,98.22 234.5,98.16 234.39,98.05 233.09,98.05 232.89,97.84 232.88,97.84 232.79,97.79 232.72,97.72 232.54,97.72 232.24,98.02 231.52,98.02 231.37,98.17 231.37,98.35 231.49,98.47 234.29,98.47 234.49,98.67 234.5,98.67 234.58,98.74 234.64,98.82 234.65,98.83 234.79,98.97 234.81,98.98 234.91,99.02 235,99.09
GND on BOTTOM (solid shape): 241.44,99.13 242.19,99.13 242.29,99.02 242.29,98.85 242.19,98.75 241.29,98.75 241.14,98.9 240.92,98.9 240.77,98.75 239.39,98.75 239.19,98.54 239.18,98.54 239.06,98.46 238.98,98.34 238.98,98.33 238.88,98.23 238.86,98.23 238.73,98.18 238.62,98.09 238.55,98.06 238.48,98.08 238.44,98.11 238.4,98.14 238.37,98.15 238.37,98.3 238.4,98.31 238.5,98.39 238.57,98.5 238.57,98.5 238.66,98.64 238.7,98.67 238.78,98.74 238.84,98.82 238.85,98.83 238.99,98.97 239.01,98.98 239.16,99.05 239.26,99.17 240.59,99.17 240.79,99.37 240.88,99.43 240.93,99.5 241.07,99.5
GND on BOTTOM (solid shape): 9.57,47.5 1.31,47.5 1.6,47.9 2.07,48.05 2.27,48.05 3.12,48.4 3.47,49.25 3.47,51.75 3.12,52.6 2.27,52.95 2.07,52.95 1.51,53.19 1.27,53.75 1.27,54.3 9.57,54.3
GND on BOTTOM (solid shape): 219.81,112.39 220.06,112.26 220.31,112.39 220.59,112.39 220.77,112.33 220.95,112.39 221.29,112.39 221.31,112.38 221.36,112.29 221.31,112.21 221.21,112.08 221.18,111.93 221.15,111.85 221.08,111.82 220.93,111.78 220.83,111.67 220.61,111.67 220.44,111.81 220.22,111.77 220.18,111.74 219.89,112.03 219.6,112.03 219.47,112.16 219.44,112.23 219.47,112.3 219.51,112.34 219.53,112.39
GND on BOTTOM (solid shape): 236.19,99.52 236.25,99.43 236.34,99.37 236.35,99.36 236.44,99.27 236.44,99.26 236.54,99.07 236.73,98.97 236.74,98.97 236.88,98.83 236.89,98.82 236.95,98.73 237.04,98.67 237.05,98.66 237.29,98.42 237.91,98.42 237.98,98.35 238.06,98.29 238.09,98.28 238.09,98.17 238.06,98.16 237.99,98.11 237.93,98.06 237.11,98.06 237.05,98.11 236.97,98.16 236.76,98.37 236.75,98.38 236.69,98.47 236.6,98.53 236.59,98.54 236.37,98.76 235.75,98.76 235.7,98.82 235.64,98.87 235.6,98.95 235.64,99.03 235.74,99.13 235.8,99.26 235.8,99.27 235.89,99.36 236.01,99.45 236.05,99.52 236.06,99.54 236.18,99.54
GND on BOTTOM (solid shape): 233.63,83.15 233.72,83.11 233.84,83.01 233.99,82.98 234.07,82.95 234.1,82.87 234.17,82.67 234.37,82.58 234.39,82.58 234.51,82.46 234.45,82.41 234.42,82.41 234.2,82.36 234.1,82.15 234.1,82.13 233.84,81.87 233.84,81.37 233.64,81.18 233.5,81.32 233.5,81.72 233.2,82.02 233.22,82.05 233.23,82.09 233.24,82.14 233.26,82.2 233.32,82.24 233.58,82.48 233.45,82.82 233.4,82.9 233.45,82.98 233.5,83.03 233.55,83.1
GND on BOTTOM (solid shape): 250.42,83.12 250.5,83.09 250.63,82.99 250.79,82.97 250.87,82.94 250.9,82.86 250.97,82.67 251.17,82.58 251.19,82.58 251.31,82.46 251.25,82.41 251.22,82.41 251,82.36 250.9,82.15 250.9,82.13 250.64,81.87 250.64,81.37 250.44,81.18 250.3,81.32 250.3,81.72 250,82.02 250.02,82.05 250.03,82.09 250.04,82.14 250.06,82.2 250.12,82.24 250.38,82.48 250.24,82.82 250.2,82.9 250.24,82.99 250.29,83.03 250.34,83.08
GND on BOTTOM (solid shape): 195.95,39.65 196.17,39.65 196.3,39.52 196.3,39.27 196.55,39.01 196.55,38.82 196.43,38.7 196.17,38.7 196.05,38.57 196.05,38.15 196.03,38.12 196.02,38.09 195.88,37.94 195.73,37.71 195.9,37.49 195.93,37.45 195.93,37.45 195.95,37.28 196.03,37.13 196.05,37.07 196.01,37.01 195.95,36.96 195.91,36.89 195.87,36.86 195.87,36.86 195.66,36.85 195.48,36.73 195.47,36.72 195.42,36.72 195.37,36.75 195.32,36.76 195,37.09 194.97,37.17 194.91,37.24 194.89,37.3 194.91,37.36 194.94,37.39 194.97,37.42 194.99,37.65 194.81,37.81 194.74,37.81 194.59,37.96 194.59,39.33 194.38,39.55 194.38,40.41 194.53,40.56 195.04,40.56
GND on BOTTOM (solid shape): 220.19,95.95 220.23,95.92 220.27,95.9 220.32,95.86 220.33,95.79 220.63,95.4 220.95,95.78 220.94,95.8 221.02,95.89 221.08,95.88 221.16,95.85 221.18,95.77 221.2,95.64 221.27,95.52 221.29,95.45 221.26,95.38 221.17,95.26 221.14,95.12 221.12,95.05 221.05,95.02 220.88,94.93 220.8,94.75 220.8,94.73 220.68,94.61 220.63,94.67 220.63,94.7 220.58,94.92 220.37,95.02 220.35,95.02 220.09,95.28 219.59,95.28 219.43,95.45 219.43,95.51 219.54,95.62 219.86,95.62
GND on BOTTOM (solid shape): 253.03,89.98 253.02,89.95 253.06,89.69 253.29,89.58 253.32,89.59 253.54,89.37 253.56,89.37 253.56,88.81 253.42,88.67 253.36,88.7 253.3,88.75 253.29,88.81 252.96,89.17 252.66,88.79 252.67,88.76 252.62,88.71 252.56,88.72 252.48,88.75 252.46,88.83 252.44,88.97 252.36,89.09 252.33,89.16 252.35,89.23 252.42,89.35 252.44,89.47 252.47,89.55 252.76,89.66 252.84,89.87 252.83,89.9 252.97,90.04
GND on BOTTOM (solid shape): outline of 107 points within 218.18,154.8 222.74,158.58
GND on BOTTOM (solid shape): 228.55,99.43 228.67,99.32 228.89,99.32 229.07,99.5 229.21,99.5 229.28,99.41 229.38,99.36 229.39,99.35 229.47,99.35 229.52,99.35 230.12,99.35 230.12,99.35 230.29,99.37 230.42,99.47 230.62,99.47 230.7,99.4 230.81,99.35 230.82,99.35 231.07,99.1 231.07,98.82 230.99,98.75 230.85,98.75 230.52,98.93 230.19,98.75 230.02,98.75 229.92,98.85 229.69,98.85 229.57,98.72 229.46,98.72 229.17,98.93 228.84,98.81 228.77,98.78 228.7,98.81 228.35,98.93 227.97,98.7 227.87,98.8 227.87,99.1 228.12,99.35 228.13,99.35 228.25,99.41 228.33,99.5 228.49,99.5
GND on BOTTOM (solid shape): outline of 114 points within 260.93,22.96 270.06,35.27
GND on BOTTOM (solid shape): 198.15,185.35 198.37,185.32 198.57,185.22 198.63,185.19 198.92,184.93 200.3,183.7 200.67,183.48 201.1,183.4 208.67,183.4 208.67,175.3 209.27,174.6 210.04,175.1 211.24,175.1 211.24,174.64 210.32,174.64 209.02,174.19 208.21,175.3 208.21,176.24 207.76,176.69 198.7,176.69 198.07,177.32 197.41,177.32 197.39,177.3 195.55,177.3 195.42,177.43 195.42,178.34 195.52,178.44 195.71,178.44 195.79,178.52 195.79,179.08 195.66,179.22 195.28,179.22 195.2,179.29 195.2,179.75 195.29,179.84 196.81,179.84 197.07,180.1 197.07,180.92 196.68,181.31 196.68,181.4 196.67,181.41 196.67,182.39 196.38,182.68 196.37,182.7 196.37,184.48 196.38,184.48 196.38,184.51 196.66,184.79 196.66,185.35
GND on BOTTOM (solid shape): 257.37,86.96 257.37,86.71 257.14,86.48 257.11,86.5 256.76,86.48 256.64,86.16 256.64,86.13 256.41,85.9 255.24,85.9 254.98,86.15 254.33,86.15 254.25,86.19 254.23,86.28 254.24,86.33 254.24,86.37 254.23,86.4 254.28,86.44 254.31,86.44 254.62,86.55 254.66,86.88 254.67,86.98 254.75,87.03 254.93,87.03 255.01,86.94 255.01,86.91 255.16,86.58 255.53,86.61 255.6,86.63 255.67,86.6 255.93,86.48 256.17,86.61 256.21,86.64 256.75,86.72 256.63,87.19 256.63,87.28 257.06,87.28
GND on BOTTOM (solid shape): 156.08,145.46 156.51,145.46 156.86,145.11 156.86,144.83 157.07,144.62 157.07,144.53 157.06,144.49 157.02,144.48 156.78,144.31 156.82,144.01 156.85,143.95 156.82,143.88 156.8,143.84 156.78,143.8 156.72,143.75 156.65,143.74 156.18,143.48 156.51,143.05 156.53,143.05 156.64,142.94 156.64,142.94 156.72,142.86 157.69,142.86 157.77,142.78 157.77,142.6 157.7,142.53 156.54,142.53 156.15,142.38 156.18,141.96 156.2,141.9 156.18,141.83 156.14,141.44 156.5,141.25 156.58,141.23 156.61,141.15 156.61,140.41 156.4,140.19 154.59,140.19 154.36,140.43 154.36,143.73 154.1,143.98 150.42,143.98 150.42,145.12 151.25,145.12 151.25,146.01 155.53,146.01
GND on BOTTOM (solid shape): 93.21,60.4 93.21,60.38 95.63,54.75 89.57,55.72 89.57,56.99 89.57,57.1 89.69,57.96 90.03,58.77 90.96,59.79 92.24,60.33 92.55,60.38 92.87,60.4
GND on BOTTOM (solid shape): outline of 142 points within 102.69,47.78 107.26,53.25
GND on BOTTOM (solid shape): outline of 144 points within 273.06,34.36 285.22,47.85
GND on BOTTOM (solid shape): 241.74,19.87 242.01,19.74 242.28,19.87 242.92,19.87 243.01,19.82 243.01,19.72 243.1,19.27 243.56,19.28 243.62,19.3 243.69,19.28 244.16,19.3 244.19,19.77 244.18,19.81 244.21,19.85 244.24,19.87 245.7,19.87 246.01,19.56 246.01,16.35 247.85,14.51 247.85,14 247.79,13.94 245.82,13.94 245.74,13.98 245.73,14.08 245.4,14.57 245.07,14.08 245.06,13.98 244.97,13.94 243.72,13.94 243.64,13.98 243.62,14.06 243.28,14.5 242.93,14.06 242.91,13.98 242.83,13.94 241.56,13.94 240.36,15.15 238.49,15.15 238.41,15.22 238.41,17.59 240.69,19.87
GND on BOTTOM (solid shape): outline of 170 points within 290.08,40.04 299.08,61.12
GND on BOTTOM (solid shape): 252.69,83 252.8,82.88 252.96,82.83 252.99,82.82 253.01,82.79 253.29,82.58 253.54,82.84 253.56,82.9 253.62,82.94 253.68,82.94 253.71,82.69 253.91,82.55 254.26,82.19 254.63,82.53 254.83,82.57 254.96,82.72 255.2,82.72 255.46,82.46 255.48,82.25 255.63,82.1 255.66,82.09 255.66,81.31 254.39,80.04 253.25,80.04 252.99,80.3 252.99,80.37 253.1,80.48 253.1,81.09 253.11,81.13 253.13,81.16 253.46,81.19 253.59,81.49 253.93,81.86 253.57,82.21 253.25,82.46 252.97,82.18 252.94,82.17 252.88,82.17 252.85,82.18 252.83,82.21 252.64,82.41 252.37,82.33 252.3,82.3 252.23,82.33 252.1,82.46 252.1,82.71 252.33,82.94 252.35,82.94 252.43,82.97 252.5,83.03 252.68,83.03
GND on BOTTOM (solid shape): outline of 135 points within 227.84,106.8 245.77,107.53
GND on BOTTOM (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 241.82,173.01 241.82,171.36 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95
GND on BOTTOM (solid shape): outline of 154 points within 227.84,89.62 245.79,90.4
GND on BOTTOM (solid shape): outline of 102 points within 211.97,30.01 214.42,32.88
GND on BOTTOM (solid shape): 220.56,117.23 220.59,117.15 220.55,117.08 220.39,116.81 220.5,116.51 220.54,116.48 220.58,116.4 220.54,116.32 220.5,116.28 220.42,116.24 220.34,116.28 220.31,116.31 219.8,116.32 219.81,115.81 219.84,115.78 219.88,115.7 219.84,115.62 219.8,115.58 219.72,115.54 219.64,115.58 219.62,115.61 219.1,115.61 219.11,115.1 219.22,115.03 219.36,114.99 219.65,114.73 219.98,114.96 220.02,115 220.07,114.99 220.2,114.8 220.43,114.75 220.45,114.71 220.45,114.66 220.4,114.62 220.38,114.62 220.21,114.56 220.11,114.41 220.09,114.38 220.06,114.37 220.03,114.37 219.97,114.38 219.92,114.43 219.46,114.51 219.66,114.08 219.72,114.06 219.76,114 219.85,113.83 220.02,113.74 220.08,113.7 220.1,113.64 220.11,113.59 220.02,113.51 219.34,113.51 219.26,113.54 219.24,113.62 219.18,113.82 218.99,113.92 219,113.95 218.99,113.98 219,114.02 219.03,114.04 219.17,114.6 218.65,114.34 218.61,114.29 218.53,114.28 218.46,114.25 218.43,114.23 218.32,114.33 218.32,116.37 218.61,116.62 218.5,116.99 218.87,117.35 220.44,117.35
GND on BOTTOM (solid shape): outline of 103 points within 211.39,26.59 213.76,29.39
GND on BOTTOM (solid shape): outline of 127 points within 198.88,160.15 202.43,164.33
GND on BOTTOM (solid shape): outline of 108 points within 251.25,83.09 255.47,85.84
GND on BOTTOM (solid shape): outline of 119 points within 196.94,17.99 199.57,21.61
GND on BOTTOM (solid shape): outline of 176 points within 227.84,104 245.75,104.7
GND on BOTTOM (solid shape): outline of 165 points within 227.84,91.02 245.79,91.8
GND on BOTTOM (solid shape): outline of 163 points within 227.84,105.4 245.77,106.1
GND on BOTTOM (solid shape): outline of 166 points within 227.84,101.2 245.77,101.9
GND on BOTTOM (solid shape): outline of 166 points within 227.84,102.6 245.77,103.3
GND on BOTTOM (solid shape): outline of 166 points within 227.84,92.43 245.79,93.2
GND on BOTTOM (solid shape): outline of 173 points within 227.93,99.8 245.77,100.53
GND on BOTTOM (solid shape): outline of 187 points within 227.84,93.82 245.79,94.6
GND on BOTTOM (solid shape): outline of 183 points within 227.84,95.22 245.79,96
GND on BOTTOM (solid shape): outline of 193 points within 227.84,96.62 245.79,97.4
GND on BOTTOM (solid shape): outline of 142 points within 219.18,96.71 224.09,100.13
GND on BOTTOM (solid shape): outline of 117 points within 16.02,0.2 338.22,183.4
GND on BOTTOM (solid shape): outline of 208 points within 215.53,79.85 221.94,85.82
GND on BOTTOM (solid shape): outline of 232 points within 0.2,34.2 189.98,185.55
GND on BOTTOM (solid shape): outline of 1933 points within 231.1,81.06 241.35,87.23
GND on BOTTOM (solid shape): outline of 3893 points within 213.5,98.08 227.61,117.54
GND on BOTTOM (solid shape): outline of 5168 points within 218.32,80.92 232.03,100.62
GND on BOTTOM (solid shape): outline of 7007 points within 240.61,81.06 255.15,108.92
GND on BOTTOM (solid shape): outline of 8576 points within 195.38,18.73 215.52,38.89
GND on IN1 (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on IN1 (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 242.01,173.2 242.01,171.55 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95
GND on IN1 (solid shape): outline of 117 points within 16.02,0.2 338.22,183.4
GND on IN1 (solid shape): outline of 239 points within 0.2,34.2 211.24,185.55
GND on IN2 (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on IN2 (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,179.67 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.01,174.99 239.66,175.55 239.67,175.62 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 242.01,173.2 242.01,171.55 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,179.67 224.57,183.95
GND on IN2 (solid shape): outline of 117 points within 16.02,0.2 338.22,183.4
GND on IN2 (solid shape): outline of 237 points within 0.2,34.2 211.24,185.55
GND on IN3 (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on IN3 (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,180.32 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 238.64,175.07 239.16,175.01 239.54,175.26 239.68,175.69 239.68,181.45 240.47,181.45 240.61,181.45 240.74,181.48 241.34,181.82 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 241.82,173.01 241.82,171.36 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.13,175.1 223.2,175.1 223.35,174.83 223.59,174.65 223.65,174.63 223.87,174.6 224.09,174.63 224.44,174.89 224.57,175.3 224.57,175.85 224.57,180.32 224.57,183.95
GND on IN3 (solid shape): outline of 117 points within 16.02,0.2 338.22,183.4
GND on IN3 (solid shape): outline of 255 points within 0.2,34.2 211.24,185.55
GND on IN4 (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on IN4 (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 241.72,172.91 241.72,171.26 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95
GND on IN4 (solid shape): outline of 117 points within 16.02,0.2 338.22,183.4
GND on IN4 (solid shape): outline of 249 points within 0.2,34.2 211.24,185.55
GND on IN6 (solid shape): 16.58,31.97 16.58,30.58 14.75,28.74 1.27,28.74 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,31.85 13.37,32.16 16.39,32.16
GND on IN6 (solid shape): 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.58 244.55,175.42 244.23,175.42 242.01,173.2 242.01,171.55 240.99,170.53 240.29,170.53 239.98,170.85 239.98,172.37 240.23,172.63 240.23,174.28 239.76,174.74 239.64,174.74 238.77,174.55 238.02,175.03 232.13,175.03 231.54,174.59 230.8,174.59 230.13,174.59 229.75,174.21 229.75,172.82 230.2,172.37 230.2,170.59 229.82,170.21 228.29,170.21 227.08,171.42 223.47,171.42 223.08,171.8 223.08,172.12 223.11,172.14 223.11,174.43 223,174.53 222.92,174.64 222.04,174.64 222.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95
GND on IN6 (solid shape): outline of 117 points within 16.02,0.2 338.22,183.4
GND on IN6 (solid shape): outline of 240 points within 0.2,34.2 211.24,185.55
GND on GND1: outline of 280 points within 0.25,0.26 338.16,185.49
GND on GND2: outline of 285 points within 0.25,0.26 338.16,185.49
GND on GND3: outline of 282 points within 0.25,0.26 338.16,185.49 ; 1 cut-out
GND on GND4: outline of 286 points within 0.25,0.26 338.16,185.49
GND on IN5: 265.63,163.86 265.63,171.52 264.99,172.16 264.99,174.51 263.7,175.8 261.72,175.8 261.72,183.4 265.42,183.4 265.98,183.16 266.22,182.6 266.22,175.1 266.57,174.25 267.42,173.9 279.1,173.9 279.1,172.4 279.09,172.4 279.09,163.86
GND on IN5: 1.27,28.73 1.27,30.1 1.51,30.66 2.07,30.9 11.68,30.9 12.45,30.4 13.05,31.1 13.05,44.7 12.45,45.4 11.68,44.9 2.07,44.9 1.51,45.14 1.27,45.7 1.27,47.25 1.51,47.81 2.07,48.05 2.27,48.05 3.12,48.4 3.47,49.25 3.47,51.75 3.12,52.6 2.27,52.95 2.07,52.95 1.88,52.98 1.71,53.04 1.39,53.33 1.27,53.74 1.27,54.55 0.54,54.64 0.2,55.3 0.2,65.3 0.54,65.96 1.27,66.05 1.27,72.1 1.51,72.66 2.07,72.9 11.74,72.9 12.43,72.76 13.01,72.37 16.84,68.54 17.07,68.25 17.24,67.92 17.34,67.6 17.37,67.27 17.37,59.5 18.01,57.94 19.57,57.3 19.57,32.29 19.53,32.29 17.66,30.43 17.66,29.28 17.11,28.73
GND on IN5: 30.15,37.37 38.15,37.37 38.49,37.03 38.49,33.65 39.29,32.85 39.91,32.85 40.01,32.75 40.01,32.2 39.98,32.16 39.09,32.16 38.67,31.74 38.67,21.53 38.62,21.48 33.45,21.48 33.35,21.58 33.35,25.65 33.18,25.81 33.02,25.81 32.77,26.05 32.77,27.54 32.84,27.6 32.84,27.82 32.69,27.97 29.83,27.97 29.66,28.14 29.66,32.89 29.76,32.99 30.72,32.99 30.87,33.14 30.87,33.34 30.74,33.47 30.74,34.87 30.81,34.93 30.81,35.12 30.11,35.82 30.11,37.33
GND on IN5: 218.77,121.87 218.05,122.59 206.81,122.59 206.68,122.71 199.93,122.71 199.72,122.5 199.72,137.53 203.7,141.51 206.17,141.51 207.08,142.42 207.08,143.22 209.28,143.22 213.92,147.86 264.66,147.86 265.38,148.58 265.38,152.09 264.72,152.75 242.32,152.75 242.32,155.61 278.07,155.61 279.09,154.59 279.09,107.26 278.8,106.97 276.97,106.97 276.4,107.54 244.51,107.54 244.48,107.56 244.48,114.37 243.18,115.68 219.11,115.68 218.77,116.02
GND on IN5: 188.84,171.48 186.3,174.02 173.94,174.02 173.94,180.93 146.51,180.93 146.51,174.09 141.32,174.09 141.32,184.75 141.56,185.31 142.12,185.55 147.72,185.55 148.07,185.4 148.22,185.05 148.22,184.9 148.48,184.26 149.12,184 173.72,184 174.36,184.26 174.62,184.9 174.62,185.05 174.77,185.4 175.12,185.55 179.22,185.55 179.78,185.31 180.02,184.75 180.02,184.6 180.37,183.75 181.22,183.4 184.34,183.4 184.77,183.48 185.14,183.7 185.2,183.76 186.76,185.14 187.01,185.29 187.29,185.35 198.15,185.35 198.43,185.29 198.68,185.14 199.27,184.62 200.3,183.7 200.67,183.48 201.1,183.4 208.67,183.4 208.67,175.3 209.27,174.6 210.04,175.1 223.2,175.1 223.97,174.6 224.57,175.3 224.57,183.95 227.67,183.95 228.23,183.71 228.47,183.15 228.47,182.65 228.82,181.8 229.67,181.45 230.47,181.45 230.47,175.69 231.07,174.99 231.85,175.49 238.3,175.49 239.08,174.99 239.68,175.69 239.68,181.45 240.47,181.45 241.24,181.72 241.65,182.42 241.67,182.42 241.67,182.62 241.91,183.17 242.47,183.4 244.71,183.4 244.71,175.01 244.25,174.58 244.32,173.95 244.32,173.95 244.32,173.73 243.91,173.32 243.91,171.48
GND on GND5: outline of 285 points within 0.25,0.26 338.16,185.49
GND on GND6: outline of 282 points within 0.25,0.26 338.16,185.49
GNDA on GND1, GND2, GND3, GND4, GND5, GND6: 2.07,0.26 1.54,0.47 1.32,1 1.32,4.25 1.54,4.78 2.07,4.99 14.37,4.99 15.11,5.62 14.62,6.46 14.62,11.59 15.11,12.43 14.37,13.06 2.07,13.06 1.54,13.27 1.32,13.8 1.32,16.95 1.54,17.48 2.07,17.69 14.37,17.69 15.11,18.32 14.62,19.16 14.62,24.29 15.11,25.13 14.37,25.76 2.07,25.76 1.54,25.97 1.32,26.5 1.32,28.23 17.32,28.23 18.17,29.07 18.17,30.22 19.74,31.78 21.83,31.78 27.42,37.37 29.43,37.37 29.6,37.2 29.6,35.61 30.45,34.77 30.49,34.77 30.49,33.5 29.56,33.5 29.16,33.09 29.16,27.93 29.62,27.46 32.9,27.46 32.9,25.72 32.84,25.66 32.84,21.6 31.38,20.14 31.38,17.98 31.08,17.69 29.37,17.69 28.86,17.18 27.84,17.18 27.02,16.35 23.99,16.35 23.82,16.52 23.82,18.87 23.36,19.34 21.81,19.34 21.22,18.74 21.22,15.95 21.11,15.84 20.67,15.84 17.98,13.15 17.98,3.76 17.18,2.95 16.1,2.95 15.5,2.36 15.5,0.26
GNDA on IN5: 2.07,0.2 1.51,0.44 1.27,1 1.27,4.25 1.51,4.81 2.07,5.05 14.37,5.05 15.07,5.65 14.57,6.42 14.57,11.63 15.07,12.4 14.37,13 2.07,13 1.51,13.24 1.27,13.8 1.27,16.95 1.51,17.51 2.07,17.75 14.37,17.75 15.07,18.35 14.57,19.12 14.57,24.33 15.07,25.1 14.37,25.7 2.07,25.7 1.51,25.94 1.27,26.5 1.27,28.23 17.51,28.23 18.23,28.95 18.23,30.15 19.74,31.66 21.7,31.66 27.42,37.37 29.43,37.37 29.6,37.2 29.6,35.61 30.45,34.77 30.49,34.77 30.49,33.5 29.56,33.5 29.16,33.09 29.16,27.93 29.62,27.46 32.43,27.46 32.52,27.38 32.52,25.94 32.84,25.62 32.84,21.6 31.4,20.16 29.81,20.16 29.22,19.57 29.22,18.43 27.21,16.42 24.12,16.42 23.95,16.58 23.95,19 23.48,19.46 21.75,19.46 21.09,18.81 21.09,16.27 17.98,13.15 17.98,3.76 17.18,2.95 16.1,2.95 15.5,2.36 15.5,0.2
VIN on TOP (solid shape): 77.35,40.75 77.35,33.62 75.78,32.06 71.32,32.06 71.08,32.3 69.74,32.3 69.66,32.38 69.66,33.86 70.66,34.87 70.66,39.36 69.86,40.16 69.86,40.8 70.11,41.05 77.05,41.05
VIN on BOTTOM (solid shape): 79.38,38.32 79.38,32.93 79.07,32.61 74.31,32.61 73.76,32.06 71.43,32.06 70.94,32.55 70.94,38.96 71.32,39.34 78.37,39.34
VIN on IN1 (solid shape): 74.24,33.81 74.24,32.48 73.92,32.16 71.26,32.16 70.94,32.48 70.94,33.88 71.19,34.13 73.92,34.13
VIN on IN3 (solid shape): 74.3,34 74.3,32.23 74.11,32.04 71.38,32.04 71,32.42 71,34 71.32,34.32 73.99,34.32
VIN on IN4 (solid shape): 74.49,34.07 74.49,32.54 74.05,32.1 71.32,32.1 70.94,32.48 70.94,33.88 71.26,34.2 74.37,34.2
+EC_VCCA on TOP (solid shape): 294.06,9.5 294.06,7.34 294,7.28 293.85,7.28 293.8,7.33 293.8,9.18 293.75,9.24 293.57,9.24 293.49,9.32 293.49,9.59 293.58,9.68 293.87,9.68
+FBX_PLLAVDD on TOP (solid shape): 204.44,106.32 205.25,106.32 205.43,106.14 205.43,104.87 205.24,104.68 201.74,104.68 201.46,104.96 201.46,106.53 201.58,106.64 203.14,106.64 203.15,106.65 204.12,106.65
+HDMI_5V_OUT on BOTTOM (solid shape): outline of 99 points within 220.29,166.66 225.91,173.39
+IFPX_PLLVDD on TOP (solid shape): outline of 113 points within 225.5,110.27 231.4,121.38
+INV_PWR_SRC on TOP (solid shape): 173.59,182.68 173.59,181.61 173.16,181.18 171.92,181.18 171.28,180.53 171.28,177.99 170.9,177.61 169.75,177.61 169.5,177.87 169.5,180.88 169.29,181.09 169.29,182.62 169.41,182.74 170.21,182.74 170.31,182.64 170.31,181.65 170.58,181.39 171.16,181.39 171.48,181.71 171.48,182.67 171.64,182.83 173.44,182.83
+INV_PWR_SRC on BOTTOM (solid shape): 159.18,172.39 159.18,171.89 159.12,171.69 159.18,171.49 159.18,171.45 159.43,171.2 160.28,171.2 160.62,170.86 160.62,169.66 160.49,169.53 156.84,169.53 156.69,169.67 156.69,170.25 156.74,170.43 156.69,170.6 156.69,171.04 156.86,171.2 157.16,171.2 157.64,171.16 157.73,171.63 157.92,171.82 157.92,172.31 158.01,172.39 158.08,172.5 158.09,172.51 159.06,172.51
+INV_PWR_SRC on IN2 (solid shape): outline of 1440 points within 157.91,168.99 171.22,179.74
+LAN_IO on TOP (solid shape): 270.74,169.96 270.78,169.91 270.82,169.87 270.69,169.46 271.05,169.22 271.05,166.36 270.39,165.7 269.38,165.7 269.22,165.86 269.22,168.11 269.45,168.44 269.22,168.77 269.22,169.84 269.34,169.96
+LAN_IO on BOTTOM (solid shape): 270.96,168.61 270.96,167.03 270.8,166.87 269.87,166.87 269.73,167.01 269.73,168.65 269.86,168.78 270.79,168.78
+LAN_IO on IN1 (solid shape): outline of 362 points within 242.32,157.39 271.24,172.88
+LAN_IO on IN2 (solid shape): outline of 499 points within 267.87,155.82 279.66,168.86
+LCDVDD on TOP (solid shape): outline of 500 points within 162.98,169.64 167.54,181.42
+LCDVDD on BOTTOM (solid shape): 164.77,171.41 164.77,167.8 164.71,167.73 164.36,167.73 164.01,167.38 164.01,166.39 163.81,166.18 163.09,166.18 162.89,166.39 162.89,167.04 162.47,167.45 162.47,170.56 163.61,171.69 164.49,171.69
+NVVDD1 on TOP (solid shape): 234.97,103.79 234.97,103.29 234.89,103.21 234.55,103.21 234.24,102.9 233.64,102.9 233.63,102.94 233.32,103.17 233.01,102.94 233,102.9 232.24,102.9 232.23,102.94 231.92,103.17 231.61,102.94 231.6,102.9 231.05,102.9 230.91,103.05 230.91,103.78 231.03,103.9 234.86,103.9
+NVVDD1 on TOP (solid shape): 245,98.46 245.19,98.36 245.4,98.41 245.5,98.41 245.55,98.32 245.55,97.63 245.36,97.63 245.2,97.47 245.18,97.47 245.09,97.44 245.01,97.39 244.73,97.39 244.65,97.44 244.56,97.47 244.54,97.47 244.34,97.67 244.17,97.67 244.17,97.77 243.53,97.77 243.45,97.81 243.43,97.89 243.44,98 244.17,98 244.17,98.1 244.27,98.1 244.55,98.38 244.57,98.38 244.66,98.41 244.74,98.46
+NVVDD1 on TOP (solid shape): 231.27,91.04 234.24,91.04 234.24,91.31 234.51,91.31 234.72,91.23 234.93,91.31 235.01,91.31 235.07,91.24 235.07,90.84 234.86,90.62 234.49,90.62 234.22,90.35 233.57,90.35 233.32,90.47 233.07,90.35 232.17,90.35 231.92,90.47 231.67,90.35 230.84,90.35 230.73,90.46 230.7,90.54 230.73,90.61 230.84,90.87 230.7,91.12 230.65,91.2 230.7,91.28 230.73,91.31 231.27,91.31
+NVVDD1 on TOP (solid shape): 241.48,91.34 241.72,91.23 241.96,91.34 241.97,91.34 241.97,91.24 242.71,91.24 242.71,91.34 242.88,91.34 242.92,91.31 242.96,91.27 243.01,91.18 242.96,91.1 242.83,90.96 242.81,90.77 242.81,90.74 242.68,90.61 238.62,90.61 238.51,90.72 238.52,90.75 238.53,90.92 238.45,91.07 238.45,91.18 238.37,91.25 238.43,91.31 238.71,91.31 238.93,91.23 239.14,91.32 239.15,91.33 239.24,91.33 239.24,91.23 239.98,91.23 240.05,91.3 240.14,91.29 240.32,91.23 240.5,91.29 240.55,91.29 240.58,91.24 241.31,91.24 241.31,91.34
+NVVDD1 on TOP (solid shape): 230.14,93.22 230.22,93.18 230.23,93.08 230.33,92.7 230.73,92.71 231.27,92.71 231.27,91.79 230.73,91.79 230.65,91.84 230.56,91.87 230.54,91.87 230.43,91.98 230.14,91.98 230.14,92.08 229.4,92.08 229.4,91.98 229.21,91.98 229.1,91.87 229.08,91.87 228.99,91.84 228.91,91.79 228.63,91.79 228.5,91.86 228.35,91.86 228.26,91.88 228.22,91.96 228.22,92.54 228.26,92.62 228.35,92.64 228.5,92.64 228.63,92.71 228.91,92.71 229.31,92.69 229.41,93.08 229.42,93.18 229.5,93.22
+NVVDD1 on TOP (solid shape): 238.57,97.02 238.65,96.97 238.87,96.84 239.11,96.9 239.13,96.91 239.23,96.91 239.24,96.9 239.24,96.53 239.98,96.53 239.98,96.9 239.99,96.91 240.11,96.91 240.13,96.9 240.28,96.83 240.44,96.85 240.53,96.84 240.58,96.76 240.58,96.53 241.31,96.53 241.53,96.74 241.74,96.74 242,96.49 242.7,96.49 242.75,96.43 242.75,95.81 242.69,95.74 242.12,95.74 242.03,95.84 242.02,95.85 241.81,96.05 241.53,96 241.51,95.99 241.48,95.99 241.22,95.74 240.67,95.74 240.64,95.77 240.64,95.78 240.37,96.06 240.03,95.88 240.03,95.87 239.9,95.75 239.32,95.75 239.22,95.85 239.22,95.86 239,96.06 238.71,95.99 238.43,95.99 238.4,96.02 238.35,96.1 238.54,96.45 238.35,96.8 238.4,96.88 238.44,96.93 238.49,96.97
+NVVDD1 on TOP (solid shape): outline of 1907 points within 227.37,91.56 246.17,100.76
+NVVDD1 on TOP (solid shape): outline of 4491 points within 217.5,100.29 268.44,138.16
+NVVDD1 on BOTTOM (solid shape): 234.62,91.13 234.78,91.11 234.91,91 234.94,90.95 234.96,90.95 234.98,90.89 234.95,90.86 234.94,90.79 234.93,90.77 234.84,90.68 234.8,90.55 234.8,90.5 234.57,90.5 234.55,90.45 234.49,90.39 234.41,90.35 234.37,90.34 234.3,90.28 233.71,90.28 233.64,90.34 233.55,90.39 233.5,90.43 233.47,90.48 233.17,90.48 233.14,90.43 233.09,90.39 233,90.34 232.85,90.2 232.36,90.2 232.21,90.35 232.14,90.4 232.1,90.43 232.07,90.48 231.77,90.48 231.74,90.43 231.7,90.4 231.63,90.35 231.55,90.28 231.27,90.28 231.19,90.36 231.19,90.99 231.22,91.02 231.35,91.02 231.43,90.95 232.44,90.95 232.51,91.02 232.73,91.02 232.83,90.92 233.09,90.92 233.19,91.02 233.45,91.02 233.53,90.95 234.4,90.95 234.42,90.99 234.44,90.99 234.53,91.03
+NVVDD1 on BOTTOM (solid shape): 231.91,93.93 232.04,93.91 232.09,93.84 232.16,93.8 232.19,93.75 232.44,93.75 232.56,93.87 232.68,93.87 232.83,93.72 233.04,93.72 233.09,93.81 233.15,93.85 233.19,93.9 233.32,93.93 233.45,93.9 233.48,93.86 233.55,93.81 233.59,93.75 234.4,93.75 234.42,93.79 234.44,93.79 234.54,93.84 234.61,93.92 234.78,93.91 234.91,93.8 234.94,93.75 234.95,93.75 235,93.72 234.99,93.66 234.95,93.63 234.94,93.59 234.93,93.58 234.84,93.48 234.8,93.35 234.8,93.3 234.57,93.3 234.55,93.25 234.49,93.19 234.41,93.15 234.37,93.14 234.23,93 231.26,93 231.16,93.1 231.16,93.85 231.21,93.9 231.28,93.9 231.43,93.75 231.65,93.75 231.69,93.81 231.76,93.86 231.79,93.9
+NVVDD1 on BOTTOM (solid shape): 241.4,101.26 241.48,101.22 241.52,101.18 241.55,101.15 241.62,101.15 241.63,101.15 241.79,101.14 241.93,101.21 241.95,101.23 241.99,101.23 242.14,101.37 242.39,101.37 242.43,101.33 242.43,100.66 242.37,100.6 242.16,100.6 242.15,100.6 242.07,100.62 241.99,100.6 241.98,100.6 241.92,100.6 241.89,100.58 241.55,100.58 241.52,100.6 241.46,100.6 241.45,100.6 241.37,100.62 241.29,100.6 241.28,100.6 241.23,100.6 241.2,100.58 240.84,100.58 240.81,100.6 240.76,100.6 240.75,100.6 240.67,100.62 240.59,100.6 240.58,100.6 240.52,100.6 240.49,100.58 240.15,100.58 240.12,100.6 240.06,100.6 240.05,100.6 239.97,100.62 239.89,100.6 239.88,100.6 239.36,100.6 239.25,100.62 239.25,100.83 239.16,100.88 239.12,100.95 239.08,100.99 239.06,101.06 239.05,101.09 239.05,101.15 239.09,101.15 239.12,101.18 239.17,101.22 239.23,101.25 239.27,101.26 239.41,101.4 239.85,101.4 240,101.26 240.09,101.21 240.14,101.17 240.17,101.12 240.47,101.12 240.5,101.17 240.55,101.21 240.64,101.26 240.81,101.42 241.23,101.42
+NVVDD1 on BOTTOM (solid shape): 238.73,96.6 238.86,96.71 239.03,96.72 239.1,96.64 239.2,96.59 239.22,96.59 239.24,96.55 240.05,96.55 240.09,96.61 240.14,96.65 240.19,96.69 240.32,96.73 240.45,96.69 240.5,96.65 240.55,96.61 240.59,96.55 241.45,96.55 241.49,96.61 241.54,96.65 241.59,96.69 241.72,96.73 241.85,96.69 241.9,96.65 241.95,96.61 241.99,96.55 242.26,96.55 242.43,96.38 242.43,96.02 242.29,95.88 242.09,95.88 241.99,95.97 241.95,95.97 241.89,96.03 241.87,96.03 241.72,96.07 241.57,96.03 241.55,96.03 241.49,95.97 241.47,95.97 241.4,95.94 241.35,95.9 240.71,95.9 240.67,95.94 240.57,95.97 240.55,95.97 240.51,96.01 240.41,96.1 240.23,96.1 240.13,96.01 240.09,95.97 240.05,95.97 239.95,95.88 239.26,95.88 239.15,95.98 239.1,96.03 239.04,96.1 238.84,96.1 238.84,96.15 238.8,96.29 238.7,96.39 238.69,96.44 238.69,96.53
+NVVDD1 on BOTTOM (solid shape): 234.62,96.73 234.78,96.71 234.91,96.6 234.94,96.55 234.96,96.55 234.99,96.49 234.96,96.45 234.94,96.39 234.93,96.37 234.84,96.28 234.8,96.15 234.8,96.1 234.57,96.1 234.55,96.05 234.49,95.99 234.41,95.95 234.37,95.94 234.3,95.88 233.71,95.88 233.64,95.94 233.55,95.99 233.5,96.03 233.47,96.08 233.17,96.08 233.14,96.03 233.09,95.99 233,95.94 232.85,95.8 232.36,95.8 232.21,95.95 232.14,96 232.1,96.03 232.07,96.08 231.75,96.08 231.55,95.88 231.22,95.88 231.18,95.91 231.19,95.96 231.21,95.99 231.21,96.49 231.08,96.62 231.16,96.7 231.28,96.7 231.43,96.55 231.68,96.55 231.71,96.58 231.92,96.68 232.13,96.58 232.16,96.55 232.37,96.55 232.4,96.58 232.53,96.67 232.69,96.68 232.78,96.64 232.84,96.58 232.88,96.52 233.06,96.52 233.15,96.62 233.21,96.66 233.25,96.67 233.32,96.68 233.39,96.67 233.43,96.66 233.49,96.63 233.53,96.58 233.56,96.55 234.4,96.55 234.42,96.59 234.44,96.59 234.53,96.63
+NVVDD1 on BOTTOM (solid shape): 238.97,93.93 239.02,93.93 239.13,93.83 239.23,93.79 239.24,93.78 239.28,93.75 240.05,93.75 240.09,93.81 240.14,93.85 240.19,93.89 240.32,93.93 240.45,93.89 240.5,93.85 240.55,93.81 240.59,93.75 241.45,93.75 241.49,93.81 241.54,93.85 241.59,93.89 241.72,93.93 241.85,93.89 241.9,93.85 241.95,93.81 241.99,93.75 242.72,93.75 242.77,93.72 242.76,93.66 242.71,93.61 242.7,93.61 242.52,93.46 242.53,93.23 242.53,93.13 242.44,93.08 242.09,93.08 241.99,93.17 241.95,93.17 241.89,93.23 241.87,93.23 241.72,93.27 241.57,93.23 241.55,93.23 241.49,93.17 241.47,93.17 241.4,93.14 241.35,93.1 240.71,93.1 240.67,93.14 240.57,93.17 240.55,93.17 240.51,93.21 240.41,93.3 240.23,93.3 240.13,93.21 240.09,93.17 240.05,93.17 239.95,93.08 239.26,93.08 239.15,93.18 239.1,93.24 239.04,93.3 238.84,93.3 238.84,93.35 238.8,93.49 238.7,93.59 238.69,93.62 238.69,93.65 238.69,93.77 238.84,93.92 238.9,93.92
+NVVDD1 on BOTTOM (solid shape): 241.4,106.86 241.47,106.83 241.49,106.83 241.57,106.75 241.62,106.75 241.63,106.75 241.72,106.73 241.81,106.75 241.82,106.75 241.87,106.75 241.95,106.83 241.99,106.83 242.01,106.84 242.39,106.84 242.48,106.75 242.48,106.28 242.4,106.2 242.16,106.2 242.07,106.22 241.96,106.2 241.89,106.15 241.85,106.1 241.72,106.07 241.59,106.1 241.55,106.15 241.48,106.2 241.43,106.21 241.36,106.28 240.68,106.28 240.61,106.21 240.56,106.2 240.53,106.18 240.11,106.18 240.08,106.2 239.97,106.22 239.88,106.2 239.36,106.2 239.35,106.2 239.17,106.2 239.03,106.08 238.88,106.08 238.76,106.17 238.73,106.2 238.67,106.2 238.67,106.26 238.68,106.31 238.69,106.4 238.76,106.46 238.82,106.53 238.83,106.6 238.84,106.64 238.87,106.7 238.93,106.73 238.97,106.74 239.02,106.75 239.09,106.75 239.12,106.78 239.17,106.82 239.23,106.85 239.27,106.86 239.41,107 239.85,107 240,106.86 240.07,106.83 240.09,106.83 240.2,106.72 240.44,106.72 240.55,106.83 240.57,106.83 240.64,106.86 240.81,107.02 241.23,107.02
+NVVDD1 on BOTTOM (solid shape): 238.73,91 238.86,91.11 239.02,91.13 239.05,91.1 239.08,91.06 239.17,91 239.22,90.99 239.24,90.95 240.05,90.95 240.09,91.01 240.14,91.05 240.19,91.09 240.32,91.13 240.45,91.09 240.5,91.05 240.55,91.01 240.59,90.95 241.45,90.95 241.49,91.01 241.54,91.05 241.59,91.09 241.72,91.13 241.85,91.1 241.89,91.04 241.95,91.01 241.99,90.95 242.72,90.95 242.77,90.92 242.76,90.86 242.71,90.81 242.7,90.81 242.52,90.66 242.53,90.43 242.53,90.33 242.44,90.28 242.09,90.28 241.99,90.37 241.95,90.37 241.89,90.43 241.87,90.43 241.72,90.47 241.57,90.43 241.55,90.43 241.49,90.37 241.47,90.37 241.4,90.34 241.35,90.3 240.71,90.3 240.67,90.34 240.57,90.37 240.55,90.37 240.51,90.41 240.41,90.5 240.23,90.5 240.13,90.41 240.09,90.37 240.05,90.37 239.95,90.28 239.26,90.28 239.15,90.38 239.1,90.43 239.04,90.5 238.84,90.5 238.84,90.55 238.8,90.69 238.7,90.79 238.68,90.88 238.67,90.9
+NVVDD1 on BOTTOM (solid shape): 234.48,101.22 234.51,101.19 234.62,101.08 234.58,101.04 234.56,100.99 234.51,100.94 234.48,100.88 234.45,100.86 234.45,100.72 234.42,100.65 234.35,100.62 234.32,100.61 234.28,100.6 233.77,100.6 233.67,100.62 233.59,100.6 233.56,100.6 233.48,100.54 233.45,100.51 233.32,100.47 233.19,100.51 233.15,100.55 233.08,100.6 232.97,100.62 232.89,100.6 232.88,100.6 232.37,100.6 232.27,100.62 232.19,100.6 232.16,100.6 232.09,100.55 232.05,100.51 231.92,100.47 231.79,100.51 231.76,100.54 231.69,100.59 231.68,100.6 231.57,100.62 231.49,100.6 231.48,100.6 231.32,100.6 231.22,100.7 231.22,101.13 231.32,101.23 231.65,101.23 231.65,101.23 231.69,101.23 231.8,101.12 232.04,101.12 232.15,101.23 232.3,101.25 232.94,101.25 233.03,101.24 233.04,101.23 233.36,101.1 233.64,101.3 234.4,101.3
+NVVDD1 on BOTTOM (solid shape): 234.48,106.82 234.51,106.79 234.58,106.72 234.71,106.72 234.77,106.69 234.8,106.63 234.81,106.59 234.82,106.53 234.88,106.46 234.93,106.42 235.09,106.26 235.04,106.22 234.98,106.2 234.91,106.2 234.88,106.17 234.76,106.08 234.61,106.08 234.47,106.2 234.29,106.2 234.28,106.2 233.76,106.2 233.67,106.22 233.56,106.2 233.48,106.14 233.45,106.11 233.32,106.07 233.19,106.11 233.15,106.15 233.08,106.2 232.97,106.22 232.88,106.2 232.36,106.2 232.27,106.22 232.16,106.2 232.09,106.15 232.05,106.11 231.92,106.07 231.79,106.11 231.76,106.14 231.68,106.2 231.57,106.22 231.48,106.2 231.3,106.2 231.2,106.31 231.2,106.7 231.32,106.83 231.69,106.83 231.8,106.72 232.04,106.72 232.15,106.83 232.17,106.83 232.3,106.85 232.94,106.85 232.95,106.85 232.98,106.85 233.02,106.85 233.07,106.83 233.09,106.83 233.2,106.72 233.44,106.72 233.55,106.83 233.57,106.83 233.64,106.9 234.4,106.9
+NVVDD1 on BOTTOM (solid shape): outline of 81 points within 230.84,103.27 234.97,104.1
+NVVDD1 on BOTTOM (solid shape): outline of 85 points within 238.67,103.27 242.8,104.22
+NVVDD1 on BOTTOM (solid shape): outline of 4291 points within 213.5,88.46 262.71,137.13
+NVVDD1 on IN1 (solid shape): outline of 13308 points within 217.37,88.99 261.18,137
+NVVDD1 on IN3 (solid shape): outline of 41015 points within 212.73,76.8 262.01,136.75
+NVVDD1 on IN6 (solid shape): outline of 14672 points within 216.82,88.6 262,138.26
+NVVDD1 on GND3: 228.78,90.39 227.78,91.39 227.78,108.21 213.18,122.82 213.18,133.66 215.44,135.92 260.32,135.92 261.18,135.05 261.18,119.77 247.34,105.93 247.34,91.58 246.16,90.39 ; 2 cut-outs
+NVVDD1 on GND4: 214.17,67.47 210.38,71.26 210.38,131.88 213.22,134.72 287.16,134.72 287.16,115 287.24,113 287.38,105.77 288.62,98.64 288.62,74.24 281.84,67.47 ; 5 cut-outs
+NVVDD2 on TOP (solid shape): outline of 212 points within 275.09,55.85 294.2,68.04
+NVVDD2 on BOTTOM (solid shape): 242.86,101.15 242.89,101.15 242.9,101.14 243.21,101.08 243.46,101.27 244.2,101.27 244.42,101.05 244.62,101.05 244.8,101.22 244.94,101.22 245.09,101.07 245.17,101.07 245.22,101.07 245.27,101.07 245.33,101.07 245.54,101.29 245.7,101.29 245.76,101.23 245.76,100.83 245.58,100.65 242.83,100.65 242.53,100.95 242.53,101.26 242.59,101.32 242.68,101.32
+NVVDD2 on BOTTOM (solid shape): 228.23,101.1 228.27,101.1 228.28,101.09 228.42,101.07 228.56,101.09 228.57,101.1 228.61,101.1 228.73,101.22 228.76,101.22 228.88,101.1 228.97,101.1 228.98,101.09 229.12,101.07 229.26,101.09 229.27,101.1 229.33,101.1 229.48,101.25 229.58,101.25 229.6,101.26 230.14,101.26 230.33,101.07 230.47,101.07 230.52,101.07 230.57,101.07 230.64,101.07 230.8,101.23 230.95,101.23 231.05,101.13 231.05,100.92 230.78,100.65 228.15,100.65 227.85,100.95 227.85,101.2 227.92,101.27 228.06,101.27
+NVVDD2 on BOTTOM (solid shape): 228.66,96.47 229.66,96.47 229.76,96.57 229.96,96.57 230.06,96.47 231.01,96.47 231.05,96.51 231.11,96.45 231.11,96.03 231.01,95.93 230.93,95.93 230.73,96.13 230.57,96.13 230.52,96.13 230.47,96.13 230.33,96.13 230.16,95.95 229.41,95.95 229.24,96.13 229.17,96.13 229.12,96.13 229.07,96.13 228.96,96.13 228.81,95.98 228.76,95.98 228.61,96.13 228.47,96.13 228.42,96.13 228.37,96.13 228.21,96.13 227.97,95.89 227.82,95.89 227.73,95.98 227.73,96.18 228.05,96.5 228.28,96.5 228.38,96.6 228.53,96.6
+NVVDD2 on BOTTOM (solid shape): 245.78,96.3 245.78,95.86 245.65,95.86 245.43,96.08 245.42,96.08 245.4,96.08 245.21,96.13 245.02,96.08 244.72,96.08 244.53,96.13 244.33,96.08 244.32,96.08 244.31,96.08 244.13,95.9 243.53,95.9 243.33,96.1 243.27,96.1 243.26,96.11 243.12,96.13 242.98,96.11 242.97,96.1 242.82,95.95 242.69,95.95 242.58,96.06 242.58,96.42 242.66,96.5 245.58,96.5
+NVVDD2 on BOTTOM (solid shape): 236.66,106.65 236.98,106.65 237.18,106.85 237.83,106.85 237.98,106.7 238.07,106.7 238.08,106.69 238.22,106.67 238.36,106.69 238.37,106.7 238.44,106.77 238.48,106.81 238.63,106.81 238.72,106.72 238.72,106.57 238.6,106.45 238.59,106.4 238.59,106.35 238.56,106.28 238.49,106.25 235.62,106.25 235.52,106.15 235.34,106.15 234.92,106.57 234.92,106.71 235.03,106.81 235.18,106.81 235.32,106.67 235.37,106.67 235.42,106.67 235.47,106.67 235.61,106.67 235.79,106.85 236.45,106.85
+NVVDD2 on BOTTOM (solid shape): 236.66,103.85 236.98,103.85 237.18,104.05 237.88,104.05 238.03,103.9 238.07,103.9 238.08,103.89 238.22,103.87 238.36,103.89 238.37,103.9 238.46,103.99 238.65,103.99 238.71,103.93 238.71,103.78 238.61,103.68 238.59,103.62 238.59,103.55 238.56,103.48 238.49,103.45 235.15,103.45 235.08,103.48 235.05,103.55 235.05,103.61 235.03,103.67 234.9,103.81 234.9,103.91 235.01,104.02 235.15,104.02 235.3,103.87 235.37,103.87 235.42,103.87 235.47,103.87 235.61,103.87 235.79,104.05 236.45,104.05
+NVVDD2 on BOTTOM (solid shape): 236.66,101.05 236.98,101.05 237.18,101.24 237.84,101.24 237.98,101.1 238.07,101.1 238.08,101.09 238.22,101.07 238.36,101.09 238.37,101.1 238.77,101.1 238.85,101.07 238.92,101.07 238.95,101.05 238.97,101.02 239.02,100.88 239.12,100.78 239.15,100.77 239.15,100.65 234.55,100.65 234.55,100.8 234.62,100.88 234.66,100.97 234.67,100.99 234.75,101.07 235.37,101.07 235.42,101.07 235.47,101.07 235.61,101.07 235.78,101.24 236.46,101.24
+NVVDD2 on BOTTOM (solid shape): 235.8,98.5 236.4,98.5 236.5,98.38 236.59,98.31 236.68,98.22 236.68,98.16 236.65,98.14 236.56,98.08 236.49,98 235.75,98 235.47,98.18 235.16,98.08 235.09,98.06 235.02,98.09 234.99,98.13 234.95,98.15 234.91,98.23 234.94,98.3 235.04,98.38 235.13,98.5 235.13,98.59 235.32,98.78 235.52,98.78
+NVVDD2 on BOTTOM (solid shape): 242.76,99.21 243.1,98.97 243.46,99.17 243.47,99.2 244.17,99.2 244.18,99.17 244.48,98.97 244.82,99.11 244.83,99.13 244.91,99.13 244.92,99.11 245.26,98.97 245.56,99.18 245.71,99.18 245.78,99.11 245.78,98.71 245.67,98.6 243.33,98.6 243.21,98.48 243.03,98.48 242.88,98.63 242.75,98.63 242.55,98.83 242.55,99.22 242.57,99.24 242.75,99.24
+NVVDD2 on BOTTOM (solid shape): 238.59,90.81 238.62,90.7 238.69,90.59 238.71,90.52 238.68,90.45 238.63,90.4 238.51,90.4 238.38,90.53 238.27,90.53 238.22,90.53 238.17,90.53 238.06,90.53 237.91,90.38 237.16,90.38 237.03,90.5 236.97,90.5 236.96,90.51 236.82,90.53 236.68,90.51 236.66,90.5 236.55,90.42 236.48,90.33 235.78,90.33 235.58,90.53 235.47,90.53 235.42,90.53 235.37,90.53 235.23,90.53 235.08,90.38 235.03,90.38 234.96,90.45 234.93,90.52 234.95,90.59 235.01,90.67 235.04,90.75 235.31,91.02 235.52,91.02 235.65,90.9 236.58,90.9 236.72,91.03 236.92,91.03 237.06,90.9 237.94,90.9 238.13,91.08 238.32,91.08
+NVVDD2 on BOTTOM (solid shape): 237.11,93.7 237.95,93.7 238.14,93.88 238.31,93.88 238.59,93.6 238.62,93.49 238.69,93.39 238.71,93.32 238.68,93.25 238.63,93.2 238.51,93.2 238.38,93.33 238.27,93.33 238.22,93.33 238.17,93.33 238.06,93.33 237.91,93.18 237.16,93.18 237.03,93.3 236.97,93.3 236.96,93.31 236.82,93.33 236.68,93.31 236.66,93.3 236.55,93.22 236.48,93.13 235.78,93.13 235.58,93.33 235.47,93.33 235.42,93.33 235.37,93.33 235.23,93.33 235.08,93.18 235.03,93.18 234.96,93.25 234.93,93.32 234.95,93.39 235.01,93.47 235.04,93.56 235.05,93.58 235.35,93.88 235.49,93.88 235.67,93.7 236.53,93.7 236.72,93.88 236.93,93.88
+NVVDD2 on BOTTOM (solid shape): 228.58,98.6 228.96,98.6 229.03,98.67 229.18,98.67 229.28,98.57 229.63,98.57 229.76,98.7 229.86,98.7 229.96,98.6 230.38,98.6 230.46,98.67 230.58,98.67 230.66,98.6 231.15,98.6 231.18,98.57 231.18,98.15 231.05,98.02 230.86,98.02 230.54,98.23 230.19,98.05 229.45,98.05 229.16,98.23 228.84,98.11 228.77,98.08 228.7,98.11 228.36,98.23 228.07,98.01 227.89,98.01 227.8,98.1 227.8,98.3 228.05,98.55 228.21,98.55 228.38,98.72 228.46,98.72
+NVVDD2 on BOTTOM (solid shape): 289.62,70.67 289.62,69.33 290.08,68.87 291.35,68.87 292.3,67.91 292.3,60 292.21,59.91 289.7,59.91 289.25,59.47 289.25,56.1 289.06,55.91 277.63,55.91 274.1,59.44 274.1,66.44 274.98,67.32 276.92,67.32 276.99,67.25 276.99,65.25 277.39,64.85 281.86,64.85 282.06,64.65 282.06,63.98 282.13,63.95 282.17,63.88 282.19,63.78 282.25,63.69 282.27,63.62 282.25,63.56 282.52,62.98 282.79,63.56 282.77,63.62 282.79,63.69 282.85,63.78 282.88,63.88 282.91,63.95 282.98,63.98 284.87,63.98 285.63,64.74 285.63,69.12 287.43,70.92 289.37,70.92
+NVVDD2 on BOTTOM (solid shape): 231.06,106.73 231.06,106.57 230.69,106.19 230.64,106.15 230.4,106.15 230.21,106.25 230,106.2 229.64,106.2 229.43,106.25 229.24,106.15 229,106.15 228.77,106.26 228.54,106.15 228.3,106.15 228.27,106.18 228.22,106.22 227.87,106.56 227.87,106.72 227.99,106.84 228.13,106.84 228.41,106.69 228.7,106.83 228.84,106.83 228.88,106.79 228.95,106.73 229.19,106.7 229.39,106.82 230.25,106.82 230.44,106.7 230.65,106.72 230.69,106.74 230.75,106.78 230.81,106.84 230.95,106.84
