# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CSSN_2: length 5.2
  TOP w0.203: PR704.2 60.51,25.99 v1(59.88,25.36) 59.52,25 v2(59.05,25) 58.64,24.59 PU700.1
  BOTTOM w0.254: v2(59.05,25) 59.05,24.94 59.43,24.56 PC709.1 59.64,25.51 PC708.2
CSSN_B+: length 187.4
  TOP w0.102: PR6100.3 86.88,19.28 v1(87.31,18.85)
  TOP w0.254: v2(89.1,23.02) 87.58,23.02 86.88,22.33 PR6100.3
  IN3 w0.254: v2(183.21,101.25) 183.1,101.35 182.63,101.35 182.38,101.1 182.38,100.04 177.99,95.65 173.67,95.65 172.22,94.2 172.22,90.93 174.44,88.71 174.44,75.53 170.76,71.85 170.76,59.21 170,58.45 170,52.61 168.41,51.02 168.41,41.18 165.68,38.45 165.68,30.51 164.47,29.31 112.49,29.31 107.47,24.29 103.83,24.29 99.32,19.78 94.88,19.78 91.64,23.02 v2(89.1,23.02)
  BOTTOM w0.254: v2(183.21,101.25) 183.32,101.37 186.65,101.37 189.69,104.4 189.69,107.64 190.64,108.59 190.64,110.53 191.83,111.73 RG59.1
CSSN_NVVDD: length 60.2
  IN1 w0.254: v2(185.81,115.27) 182.36,118.72 v2(179.26,118.72)
  BOTTOM w0.254: PR6101.3 204.65,146.19 204.16,145.7 204.16,143.27 203.91,143.01 195.77,143.01 193.59,145.19 191.21,145.19 189.15,143.14 189.15,125.9 182.96,119.7 v1(182.57,119.7) 180.24,119.7 v2(179.26,118.72) ; RG64.1 v2(185.81,115.27)
CSSN_NVVDDS: length 166.2
  IN6 w0.254: v2(271.38,39.92) 266.71,44.58 248.55,44.58 246.52,42.55 240.77,42.55 239.69,43.63 239.15,43.63 236.82,45.97 232.81,45.97 230.65,48.13 227.06,48.13 226.6,48.59 221.55,48.59 220.63,47.67 v2(220.63,47.25)
  BOTTOM w0.254: RG138.1 188.48,121.44 184.73,117.7 184.73,115.67 185.59,114.81 185.59,113.53 185.14,113.08 185.14,105.8 182.62,103.28 182.62,100.48 183,100.11 184.11,100.11 189.14,95.08 189.14,84.08 188.27,83.22 188.27,68.32 188.65,67.94 188.65,65.65 188.17,65.18 188.17,63.93 188.63,63.47 189.84,63.47 190.64,64.27 199.71,64.27 201.53,62.45 202.7,62.45 208.59,56.56 208.59,56 210.42,54.17 v1(210.42,53.51) 210.42,52.91 212.19,51.14 212.19,50.75 215.09,47.85 220.38,47.85 220.63,47.59 v2(220.63,47.25) ; PR6401.3 271.38,37.98 v2(271.38,39.92)
CSSP_1: length 16.3
  TOP w0.254: v2(62.18,31.79) 62.08,31.79 61.69,31.41 61.69,30.7 v1(60.5,29.5) 59.89,28.89 59.89,27.49 PR703.1
  IN3 w0.254: v2(62.18,31.79) 62.18,32.42 61.22,33.37 61.22,37.43 60.75,37.9 60.37,37.9 v2(60.27,38.01)
  BOTTOM w0.254: v2(60.27,38.01) 59.95,38.32 59,38.32 58.75,38.58 PR702.2
CSSP_2: length 4.6
  TOP w0.203: PU700.2 58.24,24.9 v2(58.41,25.07) 58.84,25.5 59.25,25.5 59.63,25.87 PR703.2
  BOTTOM w0.254: PC708.1 58.48,25.14 v2(58.41,25.07) 58.37,25.02 PC707.2
CSSP_B+: length 184.9
  TOP w0.102: PR6100.2 89.28,26.67 v1(90.13,27.51)
  TOP w0.254: PR6100.2 89.28,23.84 v2(89.1,23.65)
  IN3 w0.254: v2(89.1,23.65) 89.29,23.46 91.74,23.46 95.04,20.16 99.16,20.16 103.67,24.67 107.31,24.67 112.33,29.69 164.32,29.69 165.3,30.67 165.3,38.61 168.03,41.34 168.03,51.18 169.62,52.77 169.62,58.61 170.38,59.37 170.38,72.01 174.06,75.69 174.06,88.55 171.88,90.73 171.88,94.34 173.53,96 177.79,96 182,100.2 182,101.26 182.48,101.73 183.1,101.73 v2(183.21,101.84)
  BOTTOM w0.254: RG62.1 190.06,110.7 190.06,110.69 190.25,110.5 190.25,108.74 189.31,107.8 189.31,104.56 186.5,101.75 183.29,101.75 v2(183.21,101.84)
CSSP_NVVDD: length 53.8
  IN1 w0.254: v2(178.57,118.71) 179.02,119.16 184.5,119.16 v2(185.7,117.96)
  BOTTOM w0.254: RG66.1 v2(185.7,117.96) ; v2(178.57,118.71) 179.97,120.11 v1(180.49,120.11) 182.83,120.11 188.77,126.06 188.77,143.29 191.05,145.57 193.75,145.57 195.54,143.79 PR6101.2
CSSP_NVVDDS: length 187.2
  IN6 w0.254: v2(220.05,47.21) 220.05,47.67 221.35,48.97 226.76,48.97 227.22,48.51 230.8,48.51 232.97,46.35 236.97,46.35 239.31,44.01 239.85,44.01 240.93,42.93 246.36,42.93 248.39,44.96 268.95,44.96 274.34,39.57 277.71,39.57 v2(279.15,38.13)
  BOTTOM w0.254: v2(220.05,47.21) 219.8,47.47 215.63,47.47 v1(215.6,47.44) 214.96,47.44 211.81,50.59 211.81,50.98 210.02,52.78 210.02,54.04 208.21,55.85 208.21,56.36 202.5,62.07 201.37,62.07 199.55,63.89 190.8,63.89 190,63.09 188.48,63.09 187.79,63.77 187.79,65.33 188.27,65.81 188.27,67.78 187.89,68.16 187.89,83.37 188.76,84.24 188.76,94.92 183.96,99.73 182.84,99.73 182.24,100.32 182.24,103.44 184.76,105.96 184.76,113.24 185.21,113.69 185.21,114.65 184.35,115.51 184.35,117.86 188.57,122.08 191.6,122.08 191.86,121.83 RG137.1 ; PR6401.2 274.75,33.3 275.52,34.07 279.47,34.07 279.92,34.51 279.92,35.53 278.96,36.49 278.96,37.93 v2(279.15,38.13)
CTL1: length 352
  TOP w0.102: v2(324.43,26.51) 324.02,26.92 324.02,30.43 327.13,33.53 v1(327.55,33.53) 329.22,33.53 330.54,34.86 332.44,34.86 334.21,36.63 334.21,41.29 334.04,41.45 UE6.7 ; v2(24.73,44.25) 24.64,44.33 UU1.6
  IN2 w0.102: v2(324.43,26.51) 322.86,26.51 322.65,26.73 309.07,26.73 307.08,24.73 305.42,24.73 304.73,24.05 294.31,24.05 290.42,27.95 283.83,27.95 279.38,32.39 275.99,32.39 266.69,41.69 240.55,41.69 239.04,43.2 233.64,43.2 231.37,40.93 229,40.93 228.41,40.34 225.65,40.34 221.47,44.52 216.51,44.52 215.99,45.04 212.76,45.04 212,45.8 207.58,45.8 206.82,45.05 203.33,45.05 199.13,49.25 192.83,49.25 190.99,47.42 187.82,47.42 180.51,40.11 176.6,40.11 175.75,40.96 175.75,45.3 175.17,45.88 174.3,45.88 173.84,46.34 172.4,46.34 172.3,46.45 124.1,46.45 123.6,46.95 107.93,46.95 106.71,45.72 96.95,45.72 95.98,46.69 94.83,46.69 94.7,46.82 90.18,46.82 89.54,46.18 67.6,46.18 66.51,47.27 58.26,47.27 57.78,47.74 48.13,47.74 47.8,47.42 35.37,47.42 33.98,48.81 29.11,48.81 27.25,46.95 27.25,45.95 26.04,44.74 25.22,44.74 v2(24.73,44.25)
CTL2: length 351.9
  TOP w0.102: v2(324.43,27.15) v1(324.43,29.88) 324.43,30.51 326.97,33.05 329.06,33.05 330.63,34.63 332.53,34.63 334.44,36.53 334.44,41.59 334.07,41.95 UE6.8
  TOP w0.107: v2(24.69,44.83) UU1.7
  IN2 w0.102: v2(324.43,27.15) 323.95,27.63 321.42,27.63 320.75,26.96 308.98,26.96 306.99,24.96 305.32,24.96 304.64,24.28 294.41,24.28 290.51,28.17 283.92,28.17 279.47,32.62 276.08,32.62 266.79,41.92 240.64,41.92 239.13,43.43 233.55,43.43 231.27,41.15 228.9,41.15 228.32,40.57 225.74,40.57 221.56,44.75 216.6,44.75 216.09,45.27 212.86,45.27 212.09,46.03 207.48,46.03 206.73,45.27 203.43,45.27 199.23,49.48 192.73,49.48 190.9,47.64 187.72,47.64 180.42,40.34 176.69,40.34 175.98,41.05 175.98,45.4 175.27,46.11 174.39,46.11 173.93,46.57 172.5,46.57 172.39,46.68 124.19,46.68 123.69,47.17 107.84,47.17 106.68,46.02 99.44,46.02 98.85,46.6 96.45,46.6 96.13,46.92 94.97,46.92 94.85,47.05 90.08,47.05 89.45,46.41 67.69,46.41 66.61,47.49 58.35,47.49 57.88,47.97 48.03,47.97 47.71,47.65 35.83,47.65 34.43,49.05 29.03,49.05 27.02,47.05 27.02,46.04 26.15,45.17 25.03,45.17 v2(24.69,44.83)
DAT_SMB: length 10.5
  TOP w0.114: PR21.1 81.91,11.5 81.91,11.07 82.44,10.55 84.54,10.55 84.98,10.11 84.98,9.45 v2(84.78,9.25)
  BOTTOM w0.114: v2(84.78,9.25) 84.98,9.45 84.98,9.84 84.78,10.04 84.57,10.04 84.32,10.3 PBATT1.6
DDR4_DRAMRST#: length 18
  TOP w0.114: CD92.1 CD91.1 ; CD91.1 137.52,49.77 v2(137.41,49.88) ; CD91.1 138.18,50.45 138.32,50.59 RD31.1
  IN4 w0.127: v2(137.41,49.88) 136.85,49.33 136.85,47.4 137.41,46.85 137.41,40.62 v2(137.55,40.48)
  BOTTOM w0.114: JDIMM1.108 138.44,50.27 138.06,49.88 v2(137.41,49.88) ; JDIMM2.108 138.44,39.9 137.87,40.48 v2(137.55,40.48)
DDR_A_ACT#: length 47.3
  IN6 w0.13: 144.7,83.85 144.7,74.34 140.08,69.72 140.08,64.22 138.89,63.03 138.89,56.08 139.83,55.14 v2(139.83,55.12)
  IN6 w0.152: v2(144.52,91.39) 145.11,90.81 145.11,86.65 144.7,86.24 144.7,83.85
  BOTTOM w0.076: CPU1.AU3 145.38,94.61 145.38,92.25 v2(144.52,91.39)
  BOTTOM w0.175: v2(139.83,55.12) 139.83,55.1 139.2,54.47 139.2,53.37 139.94,52.63 JDIMM1.114
DDR_A_ALERT#: length 53
  IN6 w0.13: 142.14,83.85 142.14,75.28 137.6,70.75 137.6,65.25 136,63.65 136,54.38 137.44,52.94 139.12,52.94 v2(139.83,53.65)
  IN6 w0.152: v2(144.39,93.21) 144.39,93.06 144.05,92.72 144.05,90.58 142.14,88.66 142.14,83.85
  BOTTOM w0.076: v2(144.39,93.21) 144.79,93.21 145.05,93.47 145.05,95.58 CPU1.AU5
  BOTTOM w0.175: v2(139.83,53.65) 140.12,53.65 140.44,53.33 JDIMM1.116
DDR_A_BG0: length 49.1
  IN6 w0.13: 142.67,83.85 142.67,75.06 138.14,70.53 138.14,65.02 136.54,63.42 136.54,56.51 v2(137.62,55.43)
  IN6 w0.152: 142.67,83.85 142.67,87.37 v2(143.07,87.76)
  BOTTOM w0.076: v2(143.07,87.76) 142.68,88.15 142.68,89.34 144.01,90.67 144.36,90.67 145.65,91.96 145.65,93.02 145.66,93.02 CPU1.AU1
  BOTTOM w0.175: JDIMM1.115 140.19,58.77 139.18,57.76 139.18,56.09 138.52,55.43 v2(137.62,55.43)
DDR_A_BG1: length 46.2
  IN6 w0.13: 143.22,83.85 143.22,74.96 138.6,70.33 138.6,64.83 137,63.23 137,57.42 v2(137.62,56.8)
  IN6 w0.152: 143.22,83.85 143.22,85.32 143.46,85.56 143.46,88.64 v2(143.07,89.03)
  BOTTOM w0.076: CPU1.AU2 145.66,93.98 145.93,93.7 145.93,92.01 143.07,89.14 v2(143.07,89.03)
  BOTTOM w0.175: JDIMM1.113 139.69,58.95 138.7,57.96 138.7,57.33 138.17,56.8 v2(137.62,56.8)
DDR_A_BS0: length 50.3
  IN6 w0.089: v2(152.29,92.42) 153.3,91.42 153.3,86.05 154.68,84.67 154.68,83.85
  IN6 w0.13: 154.68,83.85 154.68,70.09 150.92,66.33 150.92,62.99 150.46,62.53 150.46,62.16 149.93,61.63 149.93,53 150.19,52.74 150.65,52.74 150.91,53 v2(150.91,53.67)
  BOTTOM w0.076: v2(152.29,92.42) 152.74,92.88 152.74,95.73 CPU1.AH5
  BOTTOM w0.175: JDIMM1.150 150.94,53.64 v2(150.91,53.67)
DDR_A_BS1: length 48.4
  IN6 w0.089: v2(152.31,90.5) 152.75,90.5 152.94,90.31 152.94,85.57 153.76,84.75 153.76,83.85
  IN6 w0.13: v2(148.86,58.5) 149.01,58.65 149.01,63.32 149.16,63.48 149.85,63.48 150,63.63 150,63.94 149.85,64.1 149.16,64.1 149.01,64.25 149.01,64.56 149.16,64.72 149.85,64.72 150,64.87 150,65.18 149.85,65.33 149.16,65.33 149.01,65.49 149.01,65.71 153.76,70.47 153.76,83.85
  BOTTOM w0.076: CPU1.AH1 153.2,91.32 153.12,91.24 152.87,91.24 152.79,91.16 152.79,91.01 152.87,90.94 153.12,90.94 153.2,90.86 153.2,90.71 153.12,90.63 152.87,90.63 152.79,90.56 152.79,90.4 152.87,90.33 153.12,90.33 153.2,90.25 153.2,89.66 153.11,89.57 152.74,89.57 152.65,89.65 152.65,90.01 152.31,90.35 v2(152.31,90.5)
  BOTTOM w0.175: JDIMM1.145 149.69,59.01 149.8,58.9 149.8,58.02 149.63,57.85 149.37,57.85 148.86,58.36 v2(148.86,58.5)
DDR_A_CAS#: length 51.5
  IN6 w0.13: 158.64,83.85 158.64,68.14 154.41,63.91 154.41,59.75 153.9,59.23 153.9,57.91 154.05,57.76 154.1,57.76 154.25,57.6 154.25,57.29 154.1,57.14 154.04,57.14 153.88,56.98 153.88,56.67 154.04,56.52 154.1,56.52 154.25,56.36 154.25,56.05 154.1,55.9 154.01,55.9 153.85,55.74 153.85,55.43 154.01,55.28 154.1,55.28 154.25,55.12 154.25,54.84 154.1,54.69 v2(153.5,54.69)
  IN6 w0.152: v2(154.82,87.32) 155.57,87.32 158.64,84.25 158.64,83.85
  BOTTOM w0.076: v2(154.82,87.32) 154.36,87.32 154.19,87.15 154.19,86.77 154.38,86.58 155.27,86.58 156.73,88.04 156.73,93.31 CPU1.AD1
  BOTTOM w0.175: JDIMM1.156 152.44,53.63 v2(153.5,54.69)
DDR_A_D0: length 57.4
  IN6 w0.081: v2(112.68,55.27) 113.14,55.73 113.14,61.3 113.82,61.98 113.82,66.05 115.62,67.85 115.62,69.03 115.9,69.31 116.28,69.31 116.66,68.93 116.87,68.93 117.08,69.14 117.08,69.27 116.89,69.47 116.89,69.6 117.02,69.74 117.16,69.74 117.35,69.55 117.49,69.55 120.42,72.48 120.42,78.16 125.1,82.85 125.1,85.26 126.49,86.65 126.49,92.4 129.94,95.85 130.33,95.85 v2(130.46,95.72)
  BOTTOM w0.076: v2(130.46,95.72) 130.46,96.41 130.88,96.83 131.09,96.83 131.17,96.9 131.61,96.9 131.69,96.82 132.04,96.82 132.09,96.88 132.92,96.88 CPU1.BR6
  BOTTOM w0.114: v2(112.68,55.27) 112.22,54.81 112.22,53.39 112.44,53.17 JDIMM1.4
DDR_A_D1: length 57.1
  IN6 w0.081: v2(131.84,97.18) 131.14,97.18 130.28,96.32 129.55,96.32 125.89,92.66 125.89,86.91 124.5,85.52 124.5,83.12 119.8,78.42 119.8,74.29 119.37,73.86 119.37,73.73 119.68,73.42 119.68,73.28 119.54,73.15 119.41,73.15 119.1,73.46 118.96,73.46 118.83,73.32 118.83,73.18 119.1,72.91 119.1,72.77 118.96,72.63 118.83,72.63 118.55,72.91 118.42,72.91 118.28,72.77 118.28,72.64 118.56,72.36 118.56,72.22 118.42,72.09 118.28,72.09 118.01,72.36 117.87,72.36 113.21,67.71 113.21,62.23 112.53,61.55 112.53,59.31 111.97,58.75 111.97,57.24 v2(112.68,56.54)
  BOTTOM w0.076: v2(131.84,97.18) CPU1.BT6
  BOTTOM w0.114: v2(112.68,56.54) 112.19,57.02 JDIMM1.3
DDR_A_D2: length 57.4
  IN6 w0.081: v2(131.33,94.3) 131.46,94.17 131.46,93.57 128.76,90.86 128.76,85.32 127.21,83.78 127.21,80.27 123.67,76.72 123.67,75.42 123.27,75.03 122.9,75.03 122.8,74.93 122.8,74.54 122.9,74.44 123.66,74.44 123.77,74.33 123.77,74.11 123.67,74.01 122.9,74.01 122.8,73.91 122.8,73.69 122.9,73.59 123.42,73.59 123.52,73.5 123.52,73.3 123.42,73.21 122.9,73.21 122.8,73.11 122.8,71.8 117.59,66.59 117.59,62.18 116.78,61.37 116.78,58.68 116.34,58.24 116.34,56.23 116.28,56.17 115.87,56.17 115.75,56.05 115.75,55.83 115.86,55.72 116.21,55.72 116.34,55.6 116.34,55.4 116.2,55.27 v2(115.34,55.27)
  BOTTOM w0.076: CPU1.BP3 133.43,95.29 132.87,95.29 132.85,95.27 132.27,95.27 132.05,95.05 131.55,95.05 131.33,94.83 v2(131.33,94.3)
  BOTTOM w0.114: JDIMM1.20 116.44,54.17 v2(115.34,55.27)
DDR_A_D3: length 57
  IN6 w0.081: v2(131,93.78) 130.46,93.78 128.15,91.48 128.15,85.57 126.61,84.03 126.61,80.86 122.18,76.43 122.18,72.12 116.99,66.92 116.99,64.91 116.89,64.81 116.19,64.81 116.09,64.71 116.09,64.5 116.19,64.41 116.89,64.41 116.99,64.31 116.99,64.11 116.89,64.01 115.42,64.01 115.33,63.91 115.33,63.65 115.42,63.55 116.82,63.55 116.99,63.39 116.99,62.53 116.85,62.39 116.64,62.39 115.99,63.04 115.85,63.04 115.71,62.9 115.71,62.76 116.4,62.07 116.4,61.93 116.26,61.79 116.12,61.79 115.61,62.3 115.47,62.3 115.33,62.16 115.33,62.02 115.68,61.66 115.68,61.53 115.34,61.19 115.34,59.42 115.44,59.32 115.64,59.32 115.74,59.22 115.74,59.03 115.64,58.93 115.42,58.93 115.32,58.83 115.32,58.67 115.41,58.58 115.64,58.58 115.74,58.48 115.74,58.26 115.67,58.2 115.45,58.2 115.34,58.09 v2(115.34,57.81)
  BOTTOM w0.076: CPU1.BR3 132.96,94.97 132.49,94.5 132.07,94.5 131.4,93.83 131.05,93.83 v2(131,93.78)
  BOTTOM w0.114: v2(115.34,57.81) 115.69,58.16 JDIMM1.17
DDR_A_D4: length 57.4
  IN6 w0.081: v2(129.99,95.38) 129.9,95.38 126.79,92.28 126.79,86.52 125.41,85.14 125.41,82.58 120.72,77.89 120.72,72.36 114.12,65.76 114.12,61.85 113.44,61.17 113.44,54.76 v2(112.68,54)
  BOTTOM w0.076: CPU1.BN5 134.19,96.78 133.66,97.31 132.91,97.31 132.68,97.53 131.69,97.53 131.22,97.07 131.1,97.07 131.02,97 130.81,97 129.99,96.18 v2(129.99,95.38)
  BOTTOM w0.114: v2(112.68,54) 113.44,53.23 JDIMM1.8
DDR_A_D5: length 56.9
  IN6 w0.081: v2(112.68,57.81) 112.27,58.21 112.27,58.63 112.83,59.19 112.83,61.42 113.52,62.11 113.52,66.17 115.32,67.97 115.32,69.15 115.85,69.69 116.55,69.69 117.2,70.34 117.33,70.34 117.52,70.14 117.66,70.14 117.8,70.28 117.8,70.42 117.61,70.61 117.61,70.75 117.74,70.88 117.88,70.88 118.07,70.69 118.21,70.69 118.34,70.83 118.34,70.96 118.15,71.15 118.15,71.29 118.29,71.43 118.42,71.43 118.62,71.24 118.75,71.24 118.89,71.37 118.89,71.51 118.7,71.7 118.7,71.84 118.83,71.97 118.97,71.97 119.16,71.78 119.3,71.78 119.43,71.92 119.43,72.06 119.24,72.25 119.24,72.38 119.38,72.52 119.52,72.52 119.71,72.33 119.84,72.33 119.98,72.47 119.98,72.6 119.79,72.79 119.79,72.93 120.12,73.26 120.12,78.29 124.8,82.97 124.8,85.39 126.19,86.78 126.19,92.53 129.75,96.08 130.77,96.08 v2(130.83,96.15)
  BOTTOM w0.076: v2(130.83,96.15) 130.83,96.55 130.95,96.67 131.16,96.67 131.23,96.74 131.54,96.74 131.62,96.66 132.16,96.66 132.22,96.71 132.63,96.71 132.78,96.57 132.82,96.57 132.9,96.49 133.31,96.49 133.7,96.88 CPU1.BP6
  BOTTOM w0.114: JDIMM1.7 113.19,58.96 113.25,58.9 113.25,58.26 112.8,57.81 v2(112.68,57.81)
DDR_A_D6: length 57
  IN6 w0.081: v2(130.39,91.74) 129.14,90.49 129.14,85.28 127.52,83.66 127.52,80.14 124.07,76.69 124.07,72.63 117.89,66.46 117.89,63.89 117.99,63.79 118.19,63.79 118.29,63.69 118.29,63.49 118.19,63.39 117.99,63.39 117.89,63.29 117.89,63.1 117.99,63 118.19,63 118.29,62.9 118.29,62.7 118.19,62.6 117.99,62.6 117.89,62.5 117.89,62.05 117.08,61.24 117.08,58.55 116.64,58.11 116.64,54.97 116.54,54.87 116,54.87 115.9,54.77 115.9,54.57 116,54.47 116.42,54.47 116.52,54.37 116.52,54.15 116.42,54.05 116,54.05 115.9,53.95 115.9,53.75 116,53.65 116.42,53.65 116.52,53.55 116.52,53.28 116.42,53.18 115.44,53.18 115.34,53.28 v2(115.34,54)
  BOTTOM w0.076: CPU1.BP2 133.98,94.14 133.98,93.45 133.78,93.26 133.69,93.26 133.04,92.6 132.77,92.6 131.91,91.74 v2(130.39,91.74)
  BOTTOM w0.114: JDIMM1.16 115.44,53.9 v2(115.34,54)
DDR_A_D7: length 57.5
  IN6 w0.081: v2(130.17,92.84) 128.45,91.12 128.45,85.44 126.91,83.9 126.91,80.73 123.37,77.18 123.37,76.4 123.27,76.3 122.58,76.3 122.48,76.2 122.48,76 122.58,75.9 123.23,75.9 123.33,75.8 123.33,75.6 123.23,75.5 122.6,75.5 122.5,75.4 122.5,71.93 117.29,66.71 117.29,62.3 116.49,61.5 116.49,60.91 116.39,60.81 115.74,60.81 115.64,60.71 115.64,60.51 115.74,60.41 116.39,60.41 116.49,60.31 116.49,60.11 116.39,60.02 115.74,60.02 115.64,59.92 115.64,59.72 115.74,59.62 116.39,59.62 116.49,59.52 116.49,59.22 116.39,59.12 116.16,59.12 116.04,58.99 116.04,57.75 115.94,57.65 115.8,57.65 115.7,57.55 115.7,57.36 115.8,57.26 115.92,57.26 116.04,57.14 116.04,56.64 115.94,56.54 v2(115.34,56.54)
  BOTTOM w0.076: v2(130.17,92.84) 130.57,92.84 131.25,93.52 131.41,93.52 131.56,93.37 132.11,93.37 132.7,93.96 132.7,94.06 132.7,94.41 132.72,94.44 132.91,94.63 133.13,94.63 133.24,94.75 134.14,94.75 CPU1.BN3
  BOTTOM w0.114: v2(115.34,56.54) 116.02,57.21 116.02,57.86 116.69,58.53 JDIMM1.21
DDR_A_D8: length 53.4
  IN6 w0.081: v2(117.38,56.54) 118.03,56.54 118.13,56.63 118.13,56.87 118.03,56.97 117.88,56.97 117.78,57.07 117.78,57.26 117.88,57.36 118.03,57.36 118.13,57.45 118.13,60.16 118.82,60.85 118.82,61.54 119.33,62.04 119.33,66.44 125.1,72.21 125.1,76.26 129.86,81.02 129.86,82.56 129.7,82.72 129.38,82.72 129.28,82.82 129.28,83.01 129.38,83.11 129.7,83.11 129.86,83.27 129.86,90.43 134.01,94.59 135.37,94.59 v2(135.99,95.21)
  BOTTOM w0.076: v2(135.99,95.21) 135.67,95.54 CPU1.BL4
  BOTTOM w0.114: JDIMM1.29 118.69,57.86 v2(117.38,56.54)
DDR_A_D9: length 53.3
  IN6 w0.081: v2(135.99,95.86) 134.9,94.77 133.94,94.77 129.55,90.39 129.55,84.43 128.7,83.58 128.7,82.46 128.8,82.36 129.46,82.36 129.56,82.27 129.56,82.07 129.46,81.98 128.8,81.98 128.7,81.88 128.7,81.69 128.8,81.59 129.46,81.59 129.56,81.49 129.56,81.3 129.46,81.21 128.8,81.21 128.7,81.11 128.7,80.29 124.8,76.39 124.8,72.33 119.02,66.56 119.02,65.77 118.92,65.67 118.73,65.67 118.63,65.57 118.63,65.37 118.73,65.27 118.92,65.27 119.02,65.17 119.02,64.97 118.92,64.87 118.73,64.87 118.63,64.78 118.63,64.58 118.73,64.48 118.92,64.48 119.02,64.38 119.02,62.17 118.52,61.66 118.52,60.97 117.82,60.27 117.82,58.25 v2(117.38,57.81)
  BOTTOM w0.076: v2(135.99,95.86) 135.67,96.19 CPU1.BL5
  BOTTOM w0.114: v2(117.38,57.81) 117.69,58.13 JDIMM1.25
DDR_A_D10: length 54
  IN6 w0.081: v2(133.47,91.87) 133.47,91.45 133.1,91.09 133.1,90.33 132.03,89.25 132.03,79.9 127.71,75.58 127.71,71.44 124.22,67.95 124.22,67.81 124.66,67.36 124.66,67.22 124.52,67.08 124.38,67.08 123.94,67.53 123.8,67.53 123.66,67.39 123.66,67.25 124.1,66.8 124.1,66.66 123.96,66.52 123.82,66.52 123.38,66.97 123.24,66.97 123.1,66.82 123.1,66.68 123.54,66.24 123.54,66.1 123.4,65.96 123.26,65.96 122.82,66.4 122.68,66.4 122.54,66.26 122.54,66.12 122.98,65.68 122.98,65.54 122.82,65.38 122.68,65.38 122.34,65.71 122.2,65.71 122.06,65.57 122.06,65.43 122.4,65.1 122.4,64.96 122.23,64.79 122.23,59.74 120.99,58.5 120.99,56.94 v2(120.59,56.54)
  BOTTOM w0.076: CPU1.BL2 135.31,94.24 134.72,93.64 134.72,93.42 134.52,93.22 134.09,93.22 133.47,92.6 v2(133.47,91.87)
  BOTTOM w0.114: v2(120.59,56.54) 121.69,57.64 JDIMM1.41
DDR_A_D11: length 54.1
  IN6 w0.081: v2(133.91,92.28) 133.91,91.58 133.36,91.03 133.36,90.2 132.41,89.25 132.41,79.85 128.01,75.46 128.01,71.31 126.4,69.7 126.4,69.56 126.84,69.11 126.84,68.97 126.7,68.83 126.56,68.83 126.12,69.28 125.98,69.28 125.84,69.14 125.84,69 126.28,68.55 126.28,68.41 126.14,68.27 126,68.27 125.56,68.72 125.42,68.72 125.28,68.58 125.28,68.44 125.72,67.99 125.72,67.85 125.58,67.71 125.44,67.71 125,68.16 124.86,68.16 124.72,68.02 124.72,67.88 125.16,67.43 125.16,67.29 122.66,64.79 122.66,59.75 121.34,58.42 121.34,56.17 121.24,56.07 121.09,56.07 120.99,55.98 120.99,55.78 121.09,55.69 121.24,55.69 121.34,55.59 121.34,55.39 121.22,55.27 v2(120.59,55.27)
  BOTTOM w0.076: CPU1.BM1 135.12,93.59 134.58,93.05 134.19,93.05 133.91,92.77 v2(133.91,92.28)
  BOTTOM w0.114: v2(120.59,55.27) 120.61,55.27 121.94,53.94 JDIMM1.42
DDR_A_D12: length 53.1
  IN6 w0.081: v2(117.38,54) 117.99,54 118.44,54.44 118.44,55.9 118.73,56.2 118.73,59.73 119.93,60.93 119.93,66.19 125.7,71.96 125.7,76.01 130.46,80.78 130.46,90.16 134.25,93.95 135.51,93.95 136.78,95.21 v2(136.78,95.21)
  BOTTOM w0.076: v2(136.78,95.21) CPU1.BK4
  BOTTOM w0.114: JDIMM1.24 117.44,53.93 v2(117.38,54)
DDR_A_D13: length 54
  IN6 w0.081: v2(117.38,55.27) 118.43,56.32 118.43,60.03 119.12,60.72 119.12,61.41 119.63,61.92 119.63,66.31 125.4,72.08 125.4,76.14 130.16,80.9 130.16,90.47 134.09,94.4 135.7,94.4 136.4,95.1 136.4,95.43 v2(136.79,95.81)
  BOTTOM w0.089: v2(136.79,95.81) 136.41,96.19 CPU1.BK5
  BOTTOM w0.114: v2(117.38,55.27) 117.79,54.86 117.79,53.86 118.44,53.2 JDIMM1.28
DDR_A_D14: length 53.3
  IN6 w0.081: v2(134.91,92.82) 134.91,92.26 133.61,90.96 133.61,90.08 132.72,89.19 132.72,79.74 128.31,75.33 128.31,71.19 128.2,71.08 128.06,70.94 128.06,70.8 128.51,70.35 128.51,70.21 128.37,70.07 128.23,70.07 127.78,70.52 127.64,70.52 127.5,70.38 127.5,70.24 127.95,69.79 127.95,69.65 127.81,69.51 127.67,69.51 127.22,69.96 127.08,69.96 126.94,69.81 126.94,69.67 127.39,69.23 127.39,69.09 122.96,64.66 122.96,59.62 121.74,58.39 121.74,54.92 121.64,54.82 121.2,54.82 121.1,54.72 121.1,54.53 121.2,54.43 121.64,54.43 121.74,54.34 121.74,54.09 121.64,54 v2(120.59,54)
  BOTTOM w0.076: v2(134.91,92.82) 135.13,93.04 135.26,93.04 135.8,93.59
  BOTTOM w0.089: CPU1.BK1 135.8,93.59
  BOTTOM w0.114: JDIMM1.38 120.94,53.64 v2(120.59,54)
DDR_A_D15: length 54.6
  IN6 w0.081: v2(131.69,89.61) 131.69,79.99 127.41,75.71 127.41,71.56 121.64,65.8 121.64,65.8 121.26,65.42 121.26,65.14 121.36,65.04 121.83,65.04 121.93,64.94 121.93,64.74 121.83,64.65 121.33,64.65 121.23,64.55 121.23,64.35 121.33,64.25 121.83,64.25 121.93,64.15 121.93,63.95 121.83,63.85 121.33,63.85 121.23,63.75 121.23,63.56 121.33,63.46 121.83,63.46 121.93,63.36 121.93,63.16 121.83,63.06 121.33,63.06 121.23,62.96 121.23,62.74 121.33,62.64 121.8,62.64 121.93,62.52 121.93,61.27 121.83,61.17 121.32,61.17 121.23,61.07 121.23,60.87 121.33,60.77 121.83,60.77 121.93,60.67 121.93,60.41 121.83,60.31 121.03,60.31 120.94,60.22 120.94,60.01 121.03,59.92 121.58,59.92 121.67,59.82 121.67,59.64 121.58,59.54 120.26,59.54 120.13,59.41 120.13,59.12 120.23,59.02 120.47,59.02 120.59,58.9 v2(120.59,57.81)
  BOTTOM w0.089: v2(131.69,89.61) 133.28,89.61 136.67,92.99 136.67,93.95 CPU1.BK2
  BOTTOM w0.114: v2(120.59,57.81) 120.69,57.91 JDIMM1.37
DDR_A_D16: length 50.4
  IN6 w0.081: v2(136.79,92.4) 135.69,92.4 134.06,90.77 134.06,89.82 133.23,89 133.23,86.35 133.53,86.05 133.53,79.07 129.24,74.78 129.24,69.91 124.26,64.93 124.26,64.36 124.16,64.26 123.79,64.26 123.69,64.16 123.69,63.96 123.79,63.86 124.16,63.86 124.26,63.77 124.26,63.57 124.16,63.47 123.79,63.47 123.69,63.37 123.69,63.17 123.79,63.07 124.16,63.07 124.26,62.97 124.26,62.77 124.16,62.68 123.79,62.68 123.69,62.58 123.69,62.38 123.79,62.28 124.16,62.28 124.26,62.18 124.26,59.88 122.95,58.57 v2(122.95,57.81)
  BOTTOM w0.076: v2(136.79,92.4) 137.27,92.4 137.54,92.67 137.54,93.02 137.41,93.15 137.41,93.88 137.51,93.98 137.51,95.17 137.88,95.54 CPU1.BG4
  BOTTOM w0.114: v2(122.95,57.81) 122.69,58.06 JDIMM1.45
DDR_A_D17: length 51.2
  IN6 w0.081: v2(122.95,56.54) 123.45,57.04 123.45,58.64 124.69,59.88 124.69,64.93 129.54,69.78 129.54,74.65 133.84,78.94 133.84,86.42 133.55,86.71 133.55,88.93 134.25,89.63 134.25,90.58 135.62,91.96 v2(136.4,91.96)
  BOTTOM w0.076: CPU1.BG5 138.39,95.91 138.39,95.42 138.22,95.25 137.96,95.25 137.72,95.01 137.72,93.89 137.67,93.84 137.67,93.2 137.71,93.16 137.71,92.6 137.06,91.96 v2(136.4,91.96)
  BOTTOM w0.114: JDIMM1.49 123.69,57.28 v2(122.95,56.54)
DDR_A_D18: length 50.2
  IN6 w0.081: v2(126.51,57.81) 126.51,59.39 127.53,60.42 127.53,62.2 127.63,62.3 128.12,62.3 128.22,62.4 128.22,62.6 128.12,62.7 127.63,62.7 127.53,62.8 127.53,63 127.63,63.1 128.12,63.1 128.22,63.19 128.22,63.39 128.12,63.49 127.63,63.49 127.53,63.59 127.53,63.79 127.63,63.89 128.57,63.89 128.73,64.04 128.73,64.28 128.63,64.38 128.31,64.38 128.22,64.48 128.22,64.68 128.31,64.78 128.63,64.78 128.73,64.88 128.73,65.08 128.63,65.18 128.31,65.18 128.22,65.27 128.22,65.47 128.31,65.57 128.63,65.57 128.73,65.67 128.73,66.33 131.71,69.31 131.71,73.3 136.02,77.61 136.02,90.85 138.34,93.17 138.34,94.32 v2(139.28,95.26)
  BOTTOM w0.076: CPU1.BF4 139.01,95.54 v2(139.28,95.26)
  BOTTOM w0.114: JDIMM1.63 127.19,58.5 v2(126.51,57.81)
DDR_A_D19: length 50.4
  IN6 w0.081: v2(126.51,56.54) 127.28,57.31 127.28,59.66 128.34,60.72 128.34,62.01 128.48,62.14 128.93,62.14 129.03,62.24 129.03,62.44 128.93,62.54 128.63,62.54 128.53,62.64 128.53,62.84 128.63,62.94 128.93,62.94 129.03,63.04 129.03,66.21 132.01,69.19 132.01,73.17 136.33,77.49 136.33,86.68 136.29,86.72 136.29,90.83 138.61,93.15 138.61,94.32 139.16,94.87 139.43,94.87 139.67,95.11 139.67,95.49 v2(139.29,95.86)
  BOTTOM w0.076: v2(139.29,95.86) 138.97,96.19 CPU1.BF5
  BOTTOM w0.114: JDIMM1.59 126.19,58.72 126.09,58.62 126.09,56.95 v2(126.51,56.54)
DDR_A_D20: length 50.4
  IN6 w0.081: v2(122.95,55.27) 123.83,56.15 123.83,58.45 124.99,59.61 124.99,64.81 129.84,69.65 129.84,74.52 134.14,78.82 134.14,86.56 133.93,86.77 133.93,89.05 134.5,89.62 134.5,90.57 134.99,91.06 v2(135.62,91.06)
  BOTTOM w0.076: v2(135.62,91.06) 136.17,91.06 136.74,91.62 137.21,91.62 138,92.41 138,93.18 137.83,93.34 137.83,93.72 137.92,93.81 137.92,94.05 CPU1.BG2
  BOTTOM w0.114: v2(122.95,55.27) 122.96,55.27 123.94,54.29 JDIMM1.50
DDR_A_D21: length 50.8
  IN6 w0.081: v2(135.17,90.61) 134.69,90.13 134.69,89.54 134.17,89.02 134.17,86.88 134.44,86.61 134.44,78.39 130.25,74.2 130.25,69.63 126.12,65.5 126.12,64.55 126.02,64.46 125.39,64.46 125.29,64.36 125.29,64.16 125.39,64.06 125.96,64.06 126.06,63.96 126.06,63.76 125.96,63.66 125.39,63.66 125.3,63.57 125.3,59.41 124.15,58.26 124.15,55.2 v2(122.95,54)
  BOTTOM w0.076: v2(135.17,90.61) 136.49,90.61 138.2,92.32 138.2,93.37 138.11,93.46 CPU1.BG1
  BOTTOM w0.114: v2(122.95,54) 122.94,53.99 JDIMM1.46
DDR_A_D22: length 50.2
  IN6 w0.081: v2(139.29,93.26) 139.29,93.14 136.72,90.57 136.72,89.31 137.01,89.03 137.01,77.31 132.62,72.92 132.62,68.31 132.52,68.21 132.38,68.21 132.2,68.39 132.06,68.39 131.92,68.25 131.92,68.11 132.24,67.79 132.24,67.65 132.1,67.51 131.96,67.51 131.64,67.83 131.5,67.83 131.36,67.69 131.36,67.55 131.68,67.23 131.68,67.09 129.63,65.03 129.63,61.1 127.88,59.35 127.88,54.5 127.38,54 v2(126.51,54)
  BOTTOM w0.076: CPU1.BF1 138.97,93.59 v2(139.29,93.26)
  BOTTOM w0.114: v2(126.51,54) 126.94,53.56 JDIMM1.62
DDR_A_D23: length 50.7
  IN6 w0.081: v2(139.29,93.91) 138.92,93.53 138.92,93.17 136.48,90.73 136.48,86.79 136.7,86.56 136.7,77.44 132.31,73.05 132.31,69.07 130.85,67.61 130.85,67.47 131.18,67.15 131.18,67.01 131.04,66.87 130.9,66.87 130.6,67.17 130.46,67.17 130.32,67.03 130.32,66.89 130.62,66.59 130.62,66.45 130.45,66.28 130.31,66.28 130,66.58 129.86,66.58 129.72,66.44 129.72,66.3 130.03,66 130.03,65.86 129.33,65.16 129.33,61.22 127.58,59.47 127.58,56.34 v2(126.51,55.27)
  BOTTOM w0.076: CPU1.BF2 138.97,94.24 v2(139.29,93.91)
  BOTTOM w0.114: v2(126.51,55.27) 125.94,54.7 JDIMM1.58
DDR_A_D24: length 49.3
  IN6 w0.081: v2(129.02,57.81) 129.02,58.26 129.15,58.39 129.29,58.39 129.42,58.26 129.58,58.26 129.77,58.45 129.77,58.59 129.63,58.72 129.63,58.87 130.09,59.33 130.23,59.33 130.52,59.05 130.66,59.05 130.8,59.19 130.8,59.33 130.51,59.61 130.51,59.75 130.77,60.01 130.77,63.89 131.61,64.73 131.61,64.87 131.34,65.14 131.34,65.28 131.48,65.42 131.62,65.42 131.89,65.15 132.03,65.15 132.17,65.29 132.17,65.43 131.9,65.7 131.9,65.84 132.04,65.98 132.18,65.98 132.45,65.71 132.59,65.71 132.73,65.85 132.73,65.99 132.46,66.26 132.46,66.4 132.6,66.54 132.74,66.54 133.01,66.27 133.15,66.27 133.29,66.41 133.29,66.55 133.03,66.82 133.03,66.96 133.17,67.1 133.31,67.1 133.41,66.99 133.55,66.99 133.65,67.09 133.65,72.49 138.04,76.88 138.04,90.54 v2(137.95,90.64)
  BOTTOM w0.076: CPU1.BD2 140.63,94 140.35,93.72 140.35,93.34 140.41,93.28 140.41,92.29 139.4,91.28 139.14,91.28 138.5,90.64 v2(137.95,90.64)
  BOTTOM w0.114: v2(129.02,57.81) 128.19,58.64 JDIMM1.67
DDR_A_D25: length 49.3
  IN6 w0.081: v2(129.02,54) 128.62,54.4 128.62,58.28 129.46,59.13 129.46,59.27 129.22,59.51 129.22,59.65 129.36,59.79 129.5,59.79 129.74,59.55 129.88,59.55 130.02,59.69 130.02,59.83 129.81,60.04 129.81,60.18 129.96,60.32 130.1,60.32 130.24,60.18 130.38,60.18 130.47,60.27 130.47,64.84 133.35,67.71 133.35,72.61 137.74,77.01 137.74,89.95 v2(137.5,90.19)
  BOTTOM w0.076: v2(137.5,90.19) 138.63,90.19 139.38,90.94 140.63,92.18 CPU1.BD1
  BOTTOM w0.114: JDIMM1.70 128.94,53.92 v2(129.02,54)
DDR_A_D26: length 49
  IN6 w0.081: v2(132.17,56.54) 133.35,56.54 133.71,56.89 133.71,62.85 133.81,62.95 134.28,62.95 134.38,63.05 134.38,63.25 134.28,63.35 133.81,63.35 133.71,63.45 133.71,63.76 135.98,66.03 135.98,71.42 140.52,75.95 140.52,88.72 140.8,89.01 140.8,94.16 v2(141.86,95.21)
  BOTTOM w0.076: v2(141.86,95.21) 141.53,95.54 CPU1.BC4
  BOTTOM w0.114: v2(132.17,56.54) 131.19,57.51 JDIMM1.79
DDR_A_D27: length 48.7
  IN6 w0.081: v2(132.17,57.81) 133.03,57.81 133.4,58.18 133.4,58.67 133.31,58.77 132.84,58.77 132.74,58.87 132.74,59.06 132.84,59.16 133.31,59.16 133.4,59.26 133.4,59.46 133.31,59.56 132.84,59.56 132.74,59.66 132.74,59.86 132.84,59.96 133.31,59.96 133.4,60.05 133.4,60.25 133.31,60.35 132.84,60.35 132.74,60.45 132.74,60.65 132.84,60.75 133.31,60.75 133.4,60.85 133.4,63.88 135.68,66.16 135.68,71.58 140.21,76.12 140.21,88.86 140.51,89.15 140.51,94.49 v2(141.87,95.86)
  BOTTOM w0.076: v2(141.87,95.86) 141.55,96.19 CPU1.BC5
  BOTTOM w0.114: v2(132.17,57.81) 132.19,57.84 JDIMM1.83
DDR_A_D28: length 49.6
  IN6 w0.081: v2(129.02,55.27) 129.68,55.92 129.68,56.18 130.96,57.47 130.96,58.49 131.39,58.92 131.39,63.66 134.31,66.57 134.31,72.3 138.65,76.63 138.65,90.25 139.29,90.9 v2(139.29,91.99)
  BOTTOM w0.076: v2(139.29,91.99) 139.67,92.37 139.67,92.57 140.02,92.92 140.02,94.05 140.11,94.14 140.11,95.67 CPU1.BD5
  BOTTOM w0.114: JDIMM1.66 127.94,54.19 v2(129.02,55.27)
DDR_A_D29: length 49.7
  IN6 w0.081: v2(129.02,56.54) 129.6,56.54 130.08,57.01 130.08,57.15 129.61,57.61 129.61,57.75 129.75,57.89 129.89,57.89 130.36,57.43 130.5,57.43 130.66,57.59 130.66,58.61 131.1,59.05 131.1,63.78 133.95,66.63 133.95,72.36 138.35,76.76 138.35,90.24 138.85,90.74 v2(138.85,91.54)
  BOTTOM w0.076: CPU1.BD4 140.33,95.24 140.33,94.04 140.18,93.89 140.18,93.18 140.24,93.12 140.24,92.38 139.41,91.54 v2(138.85,91.54)
  BOTTOM w0.114: v2(129.02,56.54) 129.43,56.95 129.43,58.47 129.19,58.71 JDIMM1.71
DDR_A_D30: length 49.3
  IN6 w0.081: v2(141.87,93.25) 141.53,92.91 141.53,89.29 140.82,88.58 140.82,75.82 136.29,71.3 136.29,65.79 134.69,64.19 134.69,62.67 134.59,62.57 134.11,62.57 134.01,62.47 134.01,62.27 134.11,62.18 134.59,62.18 134.69,62.08 134.69,61.88 134.59,61.78 134.11,61.78 134.01,61.68 134.01,61.11 134.69,60.43 134.69,56.29 133.67,55.27 v2(132.17,55.27)
  BOTTOM w0.076: CPU1.BC1 141.53,93.59 v2(141.87,93.25)
  BOTTOM w0.114: v2(132.17,55.27) 131.72,54.82 131.72,53.64 131.44,53.37 JDIMM1.80
DDR_A_D31: length 48.7
  IN6 w0.081: v2(141.86,93.91) 142.45,93.32 142.45,89.64 141.12,88.31 141.12,75.7 136.59,71.17 136.59,65.67 134.99,64.06 134.99,55.19 133.3,53.5 132.67,53.5 v2(132.17,54)
  BOTTOM w0.076: v2(141.86,93.91) 141.53,94.24 CPU1.BC2
  BOTTOM w0.114: v2(132.17,54) 132.44,53.72 JDIMM1.84
DDR_A_D32: length 48.8
  IN6 w0.081: v2(157.82,89.91) 157.5,89.59 157.5,88.03 160.77,84.77 160.77,67.27 157.05,63.56 157.05,58.36 156.74,58.05 156.74,55.52 156.92,55.34 157.68,55.34 157.78,55.24 157.78,55 157.68,54.9 156.91,54.9 156.79,54.77 156.79,54.57 156.89,54.48 157.41,54.48 157.49,54.39 157.49,54.12 157.41,54.04 v2(156.34,54.04)
  BOTTOM w0.076: v2(157.82,89.91) 158.25,90.33 158.25,93.57 CPU1.AB1
  BOTTOM w0.114: JDIMM1.174 156.94,53.43 v2(156.34,54.04)
DDR_A_D33: length 49.3
  IN6 w0.081: v2(156.34,56.58) 156.02,56.58 155.94,56.66 155.94,63.29 160.16,67.52 160.16,84.23 156.6,87.79 156.6,90.33 156.99,90.72 v2(157.31,90.72)
  BOTTOM w0.076: CPU1.AB2 157.95,93.96 157.95,93.47 158.03,93.39 158.03,90.93 157.81,90.72 v2(157.31,90.72)
  BOTTOM w0.114: JDIMM1.169 155.69,58.5 155.52,58.33 154.95,58.33 154.84,58.22 154.84,57.87 154.95,57.76 155.54,57.76 155.65,57.65 155.65,57.31 155.54,57.2 154.95,57.2 154.84,57.09 154.84,56.72 154.98,56.58 v2(156.34,56.58)
DDR_A_D34: length 48.5
  IN6 w0.081: v2(159.7,54.06) 158.6,55.16 158.6,57.88 158.99,58.27 158.99,60.64 158.38,61.25 158.38,63.18 161.97,66.77 161.97,85.75 158.63,89.1 158.63,89.88 158.18,90.32 158.18,93.98 v2(159.41,95.21)
  BOTTOM w0.076: v2(159.41,95.21) 159.08,95.54 CPU1.AA4
  BOTTOM w0.114: JDIMM1.186 159.94,53.81 v2(159.7,54.06)
DDR_A_D35: length 48.8
  IN6 w0.081: v2(159.7,55.33) 160.22,55.85 160.22,60.5 160.3,60.58 160.3,63.82 162.88,66.4 162.88,85.65 159.2,89.32 159.2,90.26 158.8,90.67 158.8,92.72 159.01,92.93 159.53,92.93 159.86,93.26 159.86,95.3 v2(159.4,95.77)
  BOTTOM w0.076: v2(159.4,95.77) 158.98,96.19 CPU1.AA5
  BOTTOM w0.114: JDIMM1.182 158.94,54.58 v2(159.7,55.33)
DDR_A_D36: length 49.2
  IN6 w0.081: v2(156.34,55.31) 155.63,56.01 155.63,63.41 159.86,67.64 159.86,84.15 156.22,87.79 156.22,91.35 v2(157.34,92.47)
  BOTTOM w0.076: CPU1.AB5 157.62,95.58 157.62,93.28 157.7,93.2 157.7,92.82 v2(157.34,92.47)
  BOTTOM w0.114: v2(156.34,55.31) 155.66,54.63 155.66,53.96 155.84,53.78 155.84,52.86 155.94,52.76 JDIMM1.170
DDR_A_D37: length 49.3
  IN6 w0.081: v2(157.34,91.86) 157.74,91.46 157.74,90.46 156.98,89.69 156.98,87.8 160.46,84.32 160.46,67.39 156.75,63.68 156.75,62.96 156.65,62.86 156.34,62.86 156.24,62.76 156.24,62.56 156.34,62.46 156.65,62.46 156.75,62.36 156.75,60.9 156.65,60.8 156.34,60.8 156.24,60.7 156.24,60.5 156.34,60.4 156.65,60.4 156.75,60.3 156.75,60.1 156.65,60 156.34,60 156.24,59.91 156.24,59.71 156.34,59.61 156.65,59.61 156.75,59.51 156.75,59.31 156.65,59.21 156.34,59.21 156.24,59.11 156.24,58.92 156.34,58.82 156.65,58.82 156.75,58.72 156.75,58.49 156.65,58.39 156.43,58.39 156.34,58.29 v2(156.34,57.85)
  BOTTOM w0.076: v2(157.34,91.86) 157.58,91.62 157.76,91.62 157.86,91.72 157.86,93.29 157.78,93.36 157.78,94.25 157.94,94.4 157.94,95.24 CPU1.AB4
  BOTTOM w0.114: v2(156.34,57.85) 156.81,57.85 156.92,57.96 156.92,58.28 156.81,58.39 156.26,58.39 156.16,58.5 156.16,58.72 156.26,58.83 156.59,58.83 156.69,58.94 JDIMM1.173
DDR_A_D38: length 48.9
  IN6 w0.081: v2(159.7,56.6) 159.7,56.54 159.39,56.23 159.08,56.23 158.9,56.41 158.9,56.8 159,56.9 159.19,56.9 159.29,57 159.29,57.2 159.19,57.3 159,57.3 158.9,57.4 158.9,57.65 159,57.75 159.2,57.75 159.29,57.84 159.29,61.09 159.19,61.19 158.9,61.19 158.8,61.29 158.8,61.49 158.9,61.59 159.29,61.59 159.39,61.69 159.39,62.41 159.3,62.51 158.98,62.51 158.89,62.6 158.89,62.8 158.98,62.9 159.3,62.9 159.39,63 159.39,63.77 162.27,66.65 162.27,85.72 158.82,89.17 158.82,90.01 158.37,90.46 158.37,93.56 158.81,94 v2(159.41,94)
  BOTTOM w0.076: CPU1.AA2 159.18,94.24 v2(159.41,94)
  BOTTOM w0.114: v2(159.7,56.6) 159.27,57.02 159.27,58.09 159.22,58.14 159.22,58.32 159.19,58.34 JDIMM1.183
DDR_A_D39: length 49
  IN6 w0.081: v2(159.41,93.4) 159.11,93.69 158.77,93.69 158.56,93.48 158.56,90.59 159.01,90.14 159.01,89.25 162.57,85.68 162.57,66.52 159.7,63.64 159.7,62.66 159.79,62.56 159.9,62.56 160,62.46 160,62.26 159.9,62.16 159.79,62.16 159.7,62.06 159.7,61.8 159.79,61.7 159.9,61.7 160,61.59 160,61.35 159.9,61.25 159.69,61.25 159.59,61.15 159.59,60.9 159.69,60.8 159.84,60.8 159.92,60.72 159.92,60.5 159.82,60.4 159.69,60.4 159.59,60.3 159.59,60.1 159.69,60 159.82,60 159.92,59.9 159.92,59.71 159.82,59.61 159.69,59.61 159.59,59.51 159.59,59.31 159.69,59.21 159.82,59.21 159.92,59.11 159.92,58.91 159.82,58.81 159.69,58.81 159.59,58.71 159.59,58.52 159.69,58.42 159.82,58.42 159.92,58.32 159.92,58.09 v2(159.7,57.87)
  BOTTOM w0.076: v2(159.41,93.4) 159.63,93.18 159.63,93 159.49,92.87 159.27,92.87 159.08,92.68 158.95,92.68 158.85,92.78 158.85,93.47 CPU1.AA1
  BOTTOM w0.114: v2(159.7,57.87) 160.06,57.5 160.34,57.5 160.45,57.61 160.45,58.11 160.24,58.33 159.71,58.33 159.6,58.43 159.6,58.61 159.76,58.77 160.27,58.77 160.39,58.88 160.39,59.05 160.19,59.24 JDIMM1.187
DDR_A_D40: length 49.1
  IN6 w0.081: v2(159.41,91.94) 159.03,91.56 159.03,90.76 159.46,90.33 159.46,89.33 164.07,84.71 164.07,66.56 161.03,63.52 161.03,60.33 160.96,60.25 160.96,54.83 v2(161.66,54.12)
  BOTTOM w0.076: CPU1.V5 160.13,95.58 160.13,95.42 160.13,94.77 160.13,94.12 160.13,92.67 v2(159.41,91.94)
  BOTTOM w0.114: v2(161.66,54.12) 160.94,53.4 JDIMM1.190
DDR_A_D41: length 49.6
  IN6 w0.081: v2(160.31,90.49) 159.97,90.14 159.97,89.35 164.68,84.64 164.68,66.32 162.2,63.84 162.2,61.2 162.05,61.05 162.05,59.95 161.95,59.85 161.72,59.85 161.59,59.72 161.59,59.43 161.68,59.34 161.87,59.34 161.97,59.24 161.97,59 161.87,58.9 161.66,58.9 161.56,58.8 161.56,58.54 161.66,58.44 161.87,58.44 161.97,58.34 161.97,58.03 161.87,57.93 v2(161.66,57.93)
  BOTTOM w0.076: v2(160.31,90.49) 160.46,90.64 160.46,93.96 CPU1.V2
  BOTTOM w0.114: JDIMM1.195 162.19,58.51 162.38,58.33 163.73,58.33 163.84,58.22 163.84,57.9 163.73,57.79 162.81,57.79 162.7,57.68 162.7,56.47 162.59,56.36 162.23,56.36 162.12,56.47 162.12,57.75 161.95,57.93 v2(161.66,57.93)
DDR_A_D42: length 49.1
  IN6 w0.081: v2(161.91,93.37) 161.61,93.37 161.49,93.25 161.49,90.63 167.12,85 167.12,64.95 165.34,63.17 165.34,60.65 165.24,60.54 164.76,60.54 164.66,60.45 164.66,60.24 164.76,60.15 165.24,60.15 165.34,60.05 165.34,59.85 165.24,59.75 164.76,59.75 164.66,59.65 164.66,59.45 164.76,59.35 165.24,59.35 165.34,59.25 165.34,58.81 165.12,58.59 165.12,58.08 v2(165.34,57.87)
  BOTTOM w0.076: CPU1.U1 161.37,93.47 161.37,93.01 161.48,92.9 161.69,92.9 161.91,93.12 v2(161.91,93.37)
  BOTTOM w0.114: JDIMM1.207 165.19,59.12 165.02,58.94 164.62,58.94 164.51,58.83 164.51,58.66 164.61,58.56 165.08,58.56 165.17,58.47 165.17,58.29 165.07,58.18 164.66,58.18 164.51,58.03 164.51,56.99 164.61,56.89 164.75,56.89 164.77,56.92 164.83,56.92 164.92,57.01 164.92,57.5 165.24,57.82 165.29,57.82 v2(165.34,57.87)
DDR_A_D43: length 49.1
  IN6 w0.081: v2(161.93,93.94) 161.48,93.94 161.25,93.71 161.25,90.6 166.82,85.03 166.82,65.07 165.04,63.29 165.04,63.06 164.94,62.96 164.7,62.96 164.59,62.85 164.59,62.61 164.68,62.52 164.92,62.52 165.04,62.39 165.04,62.07 164.85,61.88 164.85,61.57 165.04,61.38 165.04,61.01 164.94,60.9 164.51,60.9 164.36,60.76 164.36,59.23 164.82,58.77 164.82,56.83 165.06,56.6 v2(165.34,56.6)
  BOTTOM w0.076: CPU1.U2 161.63,94.24 v2(161.93,93.94)
  BOTTOM w0.114: JDIMM1.203 164.19,56.06 164.34,55.92 164.61,55.92 164.79,56.1 164.79,56.49 164.9,56.6 v2(165.34,56.6)
DDR_A_D44: length 49.8
  IN6 w0.081: v2(161.66,56.66) 162.09,56.66 162.27,56.84 162.27,59.48 162.5,59.71 162.5,63.71 164.98,66.2 164.98,84.61 160.22,89.37 160.22,89.88 160.37,90.04 v2(160.76,90.04)
  BOTTOM w0.076: CPU1.V1 160.74,91.58 160.92,91.41 161.73,91.41 161.81,91.33 161.81,91.08 161.73,91 160.87,91 160.79,90.93 160.79,90.65 160.87,90.57 161.67,90.57 161.74,90.49 161.74,90.14 161.64,90.04 v2(160.76,90.04)
  BOTTOM w0.114: v2(161.66,56.66) 161.17,56.17 160.85,56.17 160.6,56.42 160.6,56.71 161.19,57.3 JDIMM1.191
DDR_A_D45: length 49.4
  IN6 w0.081: v2(159.41,91.39) 159.41,90.77 159.77,90.4 159.77,89.28 164.38,84.68 164.38,66.44 161.39,63.45 161.39,62.87 161.49,62.77 161.8,62.77 161.9,62.67 161.9,62.45 161.8,62.35 161.53,62.35 161.34,62.16 161.34,60.89 161.44,60.79 161.64,60.79 161.74,60.69 161.74,60.39 161.64,60.29 161.43,60.29 161.26,60.13 161.26,55.8 v2(161.66,55.39)
  BOTTOM w0.076: v2(159.41,91.39) 160.3,92.27 160.3,93.77 160.3,94.94 160.74,95.39 CPU1.V4
  BOTTOM w0.114: v2(161.66,55.39) 162.14,54.92 162.14,53.64 161.94,53.45 JDIMM1.194
DDR_A_D46: length 49.2
  IN6 w0.081: v2(165.34,54.06) 164.22,55.18 164.22,58.51 163.71,59.02 163.71,62.83 166.19,65.3 166.19,85.13 160.72,90.6 160.72,94.65 v2(161.93,95.86)
  BOTTOM w0.076: v2(161.93,95.86) 161.6,96.19 CPU1.U5
  BOTTOM w0.114: v2(165.34,54.06) 165.44,53.95 JDIMM1.208
DDR_A_D47: length 48.9
  IN6 w0.081: v2(165.34,55.33) 164.79,55.33 164.52,55.6 164.52,58.65 164.06,59.1 164.06,62.75 166.52,65.21 166.52,85.07 161,90.59 161,94.28 v2(161.93,95.21)
  BOTTOM w0.076: CPU1.U4 161.6,95.54 v2(161.93,95.21)
  BOTTOM w0.114: v2(165.34,55.33) 164.44,54.43 JDIMM1.204
DDR_A_D48: length 50.4
  IN6 w0.081: v2(167.27,56.61) 167.02,56.36 166.82,56.36 166.68,56.5 166.68,62.62 168.76,64.69 168.76,84.71 163.33,90.14 163.33,90.44 v2(163.72,90.83)
  BOTTOM w0.076: CPU1.R2 162.98,93.96 162.98,92.59 163.36,92.2 163.36,92.1 163.18,91.92 163.18,91.81 163.29,91.7 163.4,91.7 163.58,91.88 163.68,91.88 163.96,91.61 163.96,91.07 v2(163.72,90.83)
  BOTTOM w0.114: JDIMM1.211 166.19,59.09 166.09,58.98 166.09,58.75 166.19,58.64 166.75,58.64 166.86,58.53 166.86,58.2 166.75,58.09 166.19,58.09 166.09,57.98 166.09,57.45 165.93,57.3 165.93,55.96 166.04,55.85 166.65,55.85 166.76,55.96 166.76,56.44 166.93,56.61 v2(167.27,56.61)
DDR_A_D49: length 49.6
  IN6 w0.081: 169.43,86.54 170.26,85.71 170.26,63.52 168.61,61.87 168.61,58.76 169.45,57.92 169.45,55.41 v2(170.8,54.06)
  IN6 w0.097: 169.43,86.54 163.52,92.45 163.52,94.94 v2(164.44,95.86)
  BOTTOM w0.076: CPU1.P5 164.11,96.19 v2(164.44,95.86)
  BOTTOM w0.114: JDIMM1.228 170.44,53.7 v2(170.8,54.06)
DDR_A_D50: length 50
  IN6 w0.081: v2(167.27,55.39) 167,55.39 166.84,55.23 166.84,54.54 166.72,54.43 166.47,54.43 166.38,54.52 166.38,62.74 168.28,64.65 168.28,84.65 162.82,90.12 v2(162.82,91.73)
  BOTTOM w0.076: CPU1.R4 162.96,95.24 162.96,94.38 162.81,94.23 162.81,91.73 v2(162.82,91.73)
  BOTTOM w0.114: JDIMM1.212 166.44,54.65 167.18,55.39 v2(167.27,55.39)
DDR_A_D51: length 49.2
  IN6 w0.081: v2(170.8,55.33) 169.73,56.4 169.73,58.03 168.89,58.87 168.89,61.74 170.56,63.41 170.56,85.84 167.66,88.74 167.58,88.74 163.78,92.54 163.78,94.55 v2(164.44,95.21)
  BOTTOM w0.076: v2(164.44,95.21) 164.11,95.54 CPU1.P4
  BOTTOM w0.114: v2(170.8,55.33) 169.44,53.97 JDIMM1.224
DDR_A_D52: length 49.4
  IN6 w0.081: v2(162.37,92.18) 162.37,90.02 167.98,84.4 167.98,64.78 166.07,62.87 166.07,54.12 166.38,53.82 166.9,53.82 v2(167.2,54.12)
  BOTTOM w0.076: v2(162.37,92.18) 162.37,92.64 162.65,92.92 162.65,95.58 CPU1.R5
  BOTTOM w0.114: v2(167.2,54.12) 167.2,54.1 167.44,53.86 JDIMM1.216
DDR_A_D53: length 49.4
  IN6 w0.081: v2(164.44,93.91) 164.04,93.51 164.04,92.71 169.28,87.47 169.48,87.47 171.37,85.59 171.37,73.61 170.86,73.1 170.86,63.29 169.17,61.6 169.17,58.99 170.03,58.13 170.03,56.96 170.39,56.6 v2(170.8,56.6)
  BOTTOM w0.076: v2(164.44,93.91) 164.11,94.24 CPU1.P2
  BOTTOM w0.114: v2(170.8,56.6) 169.69,56.6 169.55,56.74 169.55,57.01 169.66,57.12 170.08,57.12 170.19,57.23 170.19,57.45 170.08,57.56 169.66,57.56 169.55,57.66 169.55,57.96 169.44,58.07 169.23,58.07 169.12,58.18 169.12,58.46 169.23,58.57 169.59,58.57 169.69,58.68 JDIMM1.225
DDR_A_D54: length 50.2
  IN6 w0.081: v2(164.12,90.42) 163.88,90.18 163.88,90.04 169.06,84.86 169.06,64.57 166.98,62.49 166.98,61.27 167.29,60.96 167.29,60.74 167.19,60.64 167.08,60.64 166.98,60.54 166.98,60.34 167.08,60.24 167.19,60.24 167.29,60.14 167.29,59.95 167.19,59.85 167.08,59.85 166.98,59.75 166.98,59.55 167.08,59.45 167.19,59.45 167.29,59.35 167.29,59.15 167.19,59.05 167.08,59.05 166.98,58.95 166.98,58.76 167.08,58.66 167.19,58.66 167.29,58.56 167.29,57.96 v2(167.27,57.94)
  BOTTOM w0.076: CPU1.R1 163.26,93.13 163.62,92.77 163.62,92.66 163.51,92.54 163.51,92.44 163.62,92.33 163.73,92.33 163.84,92.44 163.95,92.44 164.07,92.32 164.07,92.21 163.95,92.1 163.95,91.99 164.06,91.88 164.17,91.88 164.28,92 164.39,92 164.54,91.85 164.54,91.75 164.23,91.44 164.23,91.33 164.34,91.23 164.45,91.23 164.75,91.53 164.86,91.53 164.97,91.42 164.97,91.32 164.66,91.01 164.66,90.9 164.77,90.79 164.88,90.79 165.18,91.1 165.29,91.1 165.4,90.99 165.4,90.88 165.09,90.58 165.09,90.47 165.2,90.36 165.31,90.36 165.61,90.67 165.72,90.67 165.87,90.52 165.87,90.39 165.36,89.88 165.2,89.88 164.44,90.64 164.34,90.64 v2(164.12,90.42)
  BOTTOM w0.114: JDIMM1.215 167.19,58.94 167.36,58.77 167.67,58.77 167.78,58.66 167.78,58.43 167.67,58.33 167.38,58.33 167.27,58.22 v2(167.27,57.94)
DDR_A_D55: length 49
  IN6 w0.081: v2(164.44,93.27) 164.44,92.73 169.32,87.85 169.53,87.85 171.67,85.71 171.67,73.02 171.57,72.93 171.26,72.93 171.16,72.83 171.16,72.64 171.26,72.54 171.57,72.54 171.67,72.44 171.67,72.25 171.57,72.15 171.26,72.15 171.16,72.06 171.16,71.86 171.26,71.77 171.57,71.77 171.67,71.67 171.67,71.48 171.57,71.38 171.26,71.38 171.16,71.28 171.16,71.09 171.26,71 171.57,71 171.67,70.9 171.67,70.71 171.57,70.61 171.26,70.61 171.16,70.51 171.16,70.24 171.26,70.15 171.55,70.15 171.65,70.05 171.65,69.86 171.55,69.76 171.26,69.76 171.16,69.67 171.16,69.47 171.26,69.38 171.55,69.38 171.65,69.28 171.65,69.09 171.55,68.99 171.26,68.99 171.16,68.89 171.16,68.67 171.26,68.57 171.49,68.57 171.59,68.48 171.59,68.28 171.49,68.19 171.26,68.19 171.16,68.09 171.16,63.17 169.46,61.46 169.46,60.91 169.56,60.82 169.88,60.82 169.97,60.72 169.97,60.53 169.88,60.43 169.57,60.43 169.46,60.31 169.46,60.14 169.56,60.04 169.88,60.04 169.97,59.95 169.97,59.75 169.88,59.66 169.57,59.66 169.46,59.54 169.46,59.21 v2(170.8,57.87)
  BOTTOM w0.076: CPU1.P1 164.12,93.59 v2(164.44,93.27)
  BOTTOM w0.114: JDIMM1.229 170.69,57.97 v2(170.8,57.87)
DDR_A_D56: length 50
  IN6 w0.081: v2(173.15,56.6) 171.92,57.83 171.92,59.5 171.82,59.6 171.62,59.6 171.52,59.7 171.52,59.89 171.62,59.99 171.82,59.99 171.92,60.08 171.92,60.28 171.82,60.37 171.62,60.37 171.52,60.47 171.52,60.66 171.62,60.76 171.82,60.76 171.92,60.86 171.92,61.72 173.19,62.99 173.19,86.92 169.4,90.71 168.56,90.71 167.36,91.91 v2(165.78,91.91)
  BOTTOM w0.076: v2(165.78,91.91) 165.78,92.52 165.53,92.78 165.53,93.03 165.33,93.23 165.33,95.09 CPU1.M4
  BOTTOM w0.114: JDIMM1.233 171.69,58.05 v2(173.15,56.6)
DDR_A_D57: length 49.5
  IN6 w0.081: v2(167.13,90.56) 167.69,90.56 168.36,89.88 169.37,89.88 172.58,86.67 172.58,67.5 172.49,67.41 172.32,67.41 172.22,67.31 172.22,67.12 172.32,67.02 172.49,67.02 172.58,66.93 172.58,66.73 172.49,66.64 172.32,66.64 172.22,66.54 172.22,66.35 172.32,66.25 172.49,66.25 172.58,66.15 172.58,65.93 172.49,65.83 172.32,65.83 172.22,65.74 172.22,65.54 172.32,65.45 172.49,65.45 172.58,65.35 172.58,63.43 170.7,61.55 170.7,59.48 171.31,58.87 171.31,55.17 172.42,54.06 v2(173.15,54.06)
  BOTTOM w0.076: v2(167.13,90.56) 167.13,91.53 166.47,92.19 166.47,92.46 165.9,93.03 165.9,93.46 CPU1.M1
  BOTTOM w0.114: JDIMM1.236 172.44,53.35 v2(173.15,54.06)
DDR_A_D58: length 49.4
  IN6 w0.081: v2(176.71,56.6) 176.23,56.6 175.29,57.54 175.29,67.86 176.1,68.66 176.1,87.79 173.39,90.5
  IN6 w0.097: v2(166.95,95.35) 168.12,95.35 169.28,94.19 169.69,94.19 173.39,90.5
  BOTTOM w0.076: v2(166.95,95.35) 166.86,95.35 166.67,95.54 CPU1.L4
  BOTTOM w0.114: JDIMM1.245 174.69,58.61 v2(176.71,56.6)
DDR_A_D59: length 49.7
  IN6 w0.081: 173.18,90.29 175.8,87.67 175.8,68.79 174.99,67.98 174.99,57.03 176.69,55.33 v2(176.71,55.33)
  IN6 w0.097: v2(166.95,93.91) 169.55,93.91 173.18,90.29
  BOTTOM w0.076: v2(166.95,93.91) 166.62,94.24 CPU1.L2
  BOTTOM w0.114: JDIMM1.246 174.94,53.56 v2(176.71,55.33)
DDR_A_D60: length 49.8
  IN6 w0.081: v2(165.33,92.36) 167.34,92.36 168.73,90.96 169.57,90.96 173.49,87.04 173.49,62.45 172.74,61.7 172.32,61.7 172.22,61.6 172.22,61.08 172.32,60.98 172.84,60.98 172.94,60.88 172.94,60.69 172.84,60.59 172.32,60.59 172.22,60.49 172.22,60.29 172.32,60.19 172.84,60.19 172.94,60.09 172.94,59.89 172.84,59.79 172.32,59.79 172.22,59.69 172.22,59.44 172.32,59.34 172.6,59.34 172.77,59.18 172.77,58.25 v2(173.15,57.87)
  BOTTOM w0.076: v2(165.33,92.36) 165.33,92.92 165.16,93.09 165.16,95.58 CPU1.M5
  BOTTOM w0.114: v2(173.15,57.87) 172.76,58.26 172.76,59.08 172.69,59.14 JDIMM1.237
DDR_A_D61: length 49.8
  IN6 w0.081: v2(166.68,91.01) 167.83,91.01 168.45,90.39 169.29,90.39 172.89,86.8 172.89,63.3 171,61.42 171,59.61 171.61,58.99 171.61,55.76 172.04,55.33 v2(173.15,55.33)
  BOTTOM w0.076: v2(166.68,91.01) 166.68,91.6 166.18,92.1 166.18,92.44 165.7,92.93 165.7,93.1 165.49,93.3 165.49,93.96 CPU1.M2
  BOTTOM w0.114: JDIMM1.232 171.44,53.62 v2(173.15,55.33)
DDR_A_D62: length 49.1
  IN6 w0.081: 173.82,90.93 176.52,88.23 176.52,68.67 175.59,67.74 175.59,67.33 175.69,67.23 176.12,67.23 176.22,67.13 176.22,66.94 176.12,66.84 175.69,66.84 175.59,66.75 175.59,66.52 175.69,66.43 176.12,66.43 176.22,66.33 176.22,66.14 176.12,66.04 175.69,66.04 175.59,65.95 175.59,58.98 v2(176.71,57.87)
  IN6 w0.097: 173.82,90.93 168.85,95.9 v2(166.96,95.9)
  BOTTOM w0.076: v2(166.96,95.9) 166.67,96.19 CPU1.L5
  BOTTOM w0.114: JDIMM1.249 175.69,58.88 v2(176.71,57.87)
DDR_A_D63: length 49.5
  IN6 w0.081: v2(176.71,54.06) 175.79,54.06 175.35,54.5 175.35,56.24 174.69,56.9 174.69,70.57 174.79,70.67 175.17,70.67 175.27,70.77 175.27,70.96 175.17,71.06 174.79,71.06 174.69,71.15 174.69,88.37 172.98,90.08
  IN6 w0.097: 172.98,90.08 169.76,93.3 v2(166.96,93.3)
  BOTTOM w0.076: CPU1.L1 166.67,93.59 v2(166.96,93.3)
  BOTTOM w0.114: JDIMM1.250 175.94,53.29 v2(176.71,54.06)
DDR_A_DQS0: length 57.4
  IN6 w0.081: v2(130.81,94.74) 130.81,95.06 130.74,95.12 130.48,95.12 130.15,94.8 130.15,94.72 127.61,92.18 127.61,86.38 126.09,84.86 126.09,81.75 121.38,77.05 121.38,72.08 116.39,67.09 116.39,65.75 115.85,65.22 115.22,65.22 114.8,64.79 114.8,60.51 114.6,60.31 114.23,60.31 114.1,60.18 114.1,59.86 114.22,59.75 114.63,59.75 114.82,59.56 114.82,59.12 114.63,58.93 114.22,58.93 114.1,58.8 114.1,58.47 114.24,58.34 114.61,58.34 114.8,58.15 114.8,56.67 114.57,56.44 114.29,56.44 v2(114.07,56.22)
  BOTTOM w0.076: CPU1.BP5 133.47,95.96 133.2,96.23 132.77,96.23 132.63,96.09 131.69,96.09 131.46,95.86 131.26,95.86 130.79,95.39 130.79,94.76 v2(130.81,94.74)
  BOTTOM w0.107: 114.57,58.84 114.69,58.96 JDIMM1.13 ; 114.21,56.36 v2(114.07,56.22)
  BOTTOM w0.114: 114.57,58.84 114.57,58.59 114.56,58.58 114.82,58.33 114.82,56.7 114.47,56.36 114.21,56.36
DDR_A_DQS1: length 54.4
  IN6 w0.081: v2(119.19,54.95) 119.47,55.23 119.68,55.23 119.88,55.43 119.88,57.51 119.41,57.97 119.41,59.46 120.7,60.75 120.7,66.03 126.86,72.19 126.86,76.22 131.18,80.54 131.18,90.18 131.98,90.98 132.19,90.98 132.27,90.9 v2(132.27,90.53)
  BOTTOM w0.076: CPU1.BK3 136.06,94.56 136.06,94.14 136.44,93.76 136.44,93.31 133.67,90.53 v2(132.27,90.53)
  BOTTOM w0.107: JDIMM1.34 119.94,52.75
  BOTTOM w0.114: 119.94,52.75 119.83,52.87 119.83,53.35 119.36,53.81 118.98,53.81 118.62,54.17 118.62,54.99 118.78,55.16 118.99,55.16 v2(119.19,54.95)
