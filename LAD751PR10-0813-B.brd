# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2S_DATA_OUT: length 331.1
  TOP w0.107: v2(39.5,31.97) 39.5,32.05 39.06,32.49 39.06,33 RA33.2 ; JIO.18 326.37,18.36 v2(326.45,18.27) ; v2(38.42,12.68) 38.42,12.59 38.24,12.41 UA4.14
  IN2 w0.102: v2(326.45,18.27) 325.46,17.28 325.1,17.28 324.22,16.4 317.01,16.4 312.22,11.61 304.7,11.61 303.74,12.58 291.8,12.58 290.88,13.51 279.34,13.51 277.42,15.42 274.22,15.42 273.61,16.03 268.65,16.03 267.76,16.93 266.8,16.93 266.22,17.51 265.51,17.51 264.16,18.87 259.32,18.87 255.66,15.21 248.61,15.21 248.34,14.94 244.04,14.94 243.74,15.24 234.83,15.24 234.51,14.92 231.11,14.92 230.31,14.12 219.28,14.12 219.02,14.37 216.08,14.37 213.87,12.16 207.8,12.16 206.46,10.81 193.62,10.81 192.31,12.13 191.73,12.7 191.73,13.27 190.94,14.05 186.85,14.05 186.56,13.76 185.64,13.76 180.1,19.3 169.73,19.3 169.2,18.76 127.78,18.76 126.17,17.15 99.4,17.15 96.47,14.22 84.62,14.22 82.98,12.58 55.92,12.58 54.75,13.75 44.7,13.75 42.37,11.42 40.39,11.42 39.54,12.27 38.83,12.27 v2(38.42,12.68)
  IN6 w0.102: v2(39.5,31.97) 38.54,31.01 38.54,28.49 39.89,27.15 39.89,14.64 38.42,13.17 v2(38.42,12.68)
I2S_DATA_OUT_R: length 4.4
  TOP w0.107: RA33.1 38.12,32.59 38.11,32.59 CA40.1 36.71,32.59 36.62,32.5 36.32,32.5 36.22,32.39 v1(36.22,32.26) 36.22,31.77 v2(36.56,31.43)
  BOTTOM w0.107: v2(36.56,31.43) 36.48,31.51 UA1.5
I2S_LRCK: length 333.2
  TOP w0.107: JIO.16 324.75,17.36 324.73,17.38 v2(324.62,17.38) ; v2(39.06,13.18) 39.06,12.41 v1(38.98,12.34) 38.93,12.29 38.93,11.78 38.74,11.59 38.34,11.59 37.97,11.21 UA4.11
  IN2 w0.102: v2(324.62,17.38) 324.62,17.38 324.62,17.13 324.12,16.63 316.91,16.63 312.13,11.84 304.8,11.84 303.83,12.81 291.9,12.81 290.97,13.74 279.43,13.74 277.52,15.65 274.31,15.65 273.08,16.88 268.13,16.88 267.85,17.16 266.9,17.16 266.31,17.74 265.6,17.74 264.25,19.09 259.22,19.09 255.57,15.44 248.52,15.44 248.25,15.17 244.13,15.17 243.84,15.47 234.73,15.47 234.41,15.14 231.01,15.14 230.21,14.34 219.37,14.34 219.12,14.6 215.98,14.6 213.77,12.39 207.71,12.39 206.36,11.04 193.71,11.04 191.96,12.8 191.96,13.36 191.04,14.28 186.76,14.28 186.48,14 185.72,14 180.2,19.53 169.64,19.53 169.1,18.99 127.68,18.99 126.07,17.38 99.31,17.38 96.37,14.45 84.52,14.45 82.88,12.81 56.02,12.81 54.85,13.98 39.85,13.98 v2(39.06,13.18)
  IN6 w0.102: v2(38.87,35.17) 38.36,34.66 38.36,33.81 39.38,32.8 40.73,32.8 41,32.52 41,31.84 40.5,31.33 40.5,28.21 40.12,27.83 40.12,14.24 v2(39.06,13.18)
  BOTTOM w0.107: v2(38.87,35.17) 38.23,34.53 CA37.1 RA30.2
I2S_LRCK_R: length 1.7
  BOTTOM w0.107: UA1.1 36.13,33.11 36.42,33.4 37.06,33.4 37.27,33.61 RA30.1
I2S_OUT: length 334.7
  TOP w0.107: JIO.17 326.67,17.85 v2(327.09,18.27) ; v2(38.49,12.02) 38.36,12.02 37.96,11.61 UA4.12
  IN2 w0.102: v2(327.09,18.27) 326.64,17.83 326.64,17.12 325.31,15.79 324.37,15.79 323.99,16.17 317.14,16.17 312.35,11.38 304.61,11.38 303.64,12.35 291.71,12.35 290.78,13.28 279.24,13.28 277.33,15.19 274.13,15.19 273.52,15.8 263.44,15.8 260.6,18.64 259.41,18.64 255.76,14.98 248.71,14.98 248.44,14.71 247.87,14.71 247.23,14.08 246.66,14.08 246.05,14.69 243.96,14.69 243.64,15.01 234.92,15.01 234.6,14.69 231.2,14.69 230.4,13.89 219.18,13.89 218.93,14.14 216.17,14.14 213.96,11.93 207.9,11.93 206.55,10.59 193.52,10.59 191.5,12.61 188.88,12.61 188.46,13.02 186.06,13.02 180.01,19.07 169.83,19.07 169.29,18.53 127.87,18.53 126.26,16.92 99.5,16.92 96.56,13.99 84.71,13.99 83.07,12.35 55.77,12.35 54.6,13.52 44.79,13.52 42.46,11.19 40.29,11.19 39.44,12.04 38.51,12.04 v2(38.49,12.02)
  IN6 w0.102: v2(38.49,12.02) 37.99,12.52 37.99,13.13 39.57,14.7 39.57,27 38.31,28.25 38.31,31.36 v2(38.92,31.97)
  BOTTOM w0.102: v1(39.61,12.12) 39.51,12.02 v2(38.49,12.02)
  BOTTOM w0.107: v2(38.92,31.97) 39.06,32.11 CA36.1 RA31.2
I2S_OUT_R: length 1.6
  BOTTOM w0.107: UA1.3 36.46,32.31 36.76,32.6 RA31.1
I_SYS: length 188.7
  TOP w0.203: v2(54.49,23.03) PU700.9
  IN1 w0.254: v2(107.32,23.81) 106.46,24.67 106.46,33.49 108.09,35.11 108.09,39.59 108.66,40.16 108.66,41.18 109.21,41.74 109.21,68.18 114.54,73.5 114.54,132.69 v2(115.02,133.17)
  IN6 w0.254: v2(54.49,23.03) 54.49,21.9 56.14,20.25 58.12,20.25 59.96,18.41 63.32,18.41 63.85,17.88 63.85,15.37 64.27,14.95 65.92,14.95 66.3,14.57 71.38,14.57 72.53,15.72 73.52,15.72 74.99,17.18 80.15,17.18 84.32,21.35 96.8,21.35 97.64,22.19 98.69,22.19 100.53,20.35 105.48,20.35 106.12,20.99 106.12,22.6 v2(107.32,23.81)
  BOTTOM w0.254: PR728.2 54.97,22.56 v2(54.49,23.03) ; v2(115.02,133.17) v1(116.72,133.17) 121.14,133.17 121.83,133.85 121.83,134.8 122.26,135.23 PR526.1
IFPAB_RSET: length 16.2
  TOP w0.089: v1(242.91,119.89) 243.06,119.74 v2(243.06,119.26)
  IN2 w0.089: v2(233.94,112) 234.48,112.53 234.49,112.53 234.58,112.62 234.58,115.01 238.83,119.26 v2(243.06,119.26)
  BOTTOM w0.089: RG36.1 v2(243.06,119.26) ; v2(233.94,112) 234.04,111.89 234.04,111 234.2,110.85 UG9.BD23
IFPCD_RSET: length 4.7
  TOP w0.102: RG37.1 232.43,114.18 v1(232.43,112.87) 232.43,111.01 v2(231.97,110.55)
  BOTTOM w0.1: UG9.BD20 v2(231.97,110.55)
IFPEF_RSET: length 5.9
  TOP w0.102: v2(229.87,110.55) 230.27,110.95 230.27,114 229.97,114.3 229.14,114.3 RG38.1
  BOTTOM w0.1: UG9.BD17 v2(229.87,110.55)
IGPU_ENBKL: length 69.1
  TOP w0.102: v2(203.92,9.57) 203.92,7.28 v1(203.79,7.15) 202.12,5.48 UV22.10
  IN4 w0.102: v2(179.65,14.89) 182.34,17.58 189.8,17.58 190.41,18.19 192.77,18.19 193.28,18.7 194.95,18.7 195.39,18.27 198.73,18.27 198.98,18.02 200.71,18.02 201.49,18.8 201.49,19.74 202.23,20.48 203.02,20.48 204.22,21.69 v2(204.22,21.75)
  BOTTOM w0.089: UH1.W35 204.22,22.28 v2(204.22,21.75)
  BOTTOM w0.102: v2(179.65,14.89) 179.65,13.94 184.95,8.64 184.95,6.29 186.24,4.99 200.44,4.99 203.92,8.47 v2(203.92,9.57)
IGPU_ENVDD: length 54.7
  TOP w0.102: UV22.6 193.28,6.13 192.86,6.55 186.74,6.55 v1(181.54,11.76) 179.54,11.76 176.63,14.68 176.63,15.25 v2(176.6,15.27)
  IN4 w0.102: v2(176.6,15.27) 176.63,15.25 176.63,14.68 177.07,14.23 179.56,14.23 182.66,17.33 192.23,17.33 193.42,18.51 194.87,18.51 195.31,18.08 198.46,18.08 199.87,16.67 201.77,16.67 202.42,17.31 202.42,18.6 v2(203.4,19.58)
  BOTTOM w0.089: v2(203.4,19.58) 203.4,19.58 UH1.W42
IGPU_INV_PWM: length 55.1
  TOP w0.102: v2(178.51,14.87) 179.48,13.91 180.65,13.91 v1(186.71,7.84) 187.31,7.24 193,7.24 193.84,8.08 UV22.3
  IN4 w0.102: v2(203.41,22.27) 203.12,22.27 202.53,21.69 201.62,21.69 201.05,21.11 201.05,19.09 200.39,18.43 199.63,18.43 198.67,19.39 198.67,22.08 198.43,22.32 197.62,22.32 197.05,21.75 195.65,21.75 195.4,21.49 195.4,20.56 193.98,19.15 192.92,19.15 192.43,18.65 190.22,18.65 189.61,18.04 180.96,18.04 178.76,15.84 178.76,15.12 v2(178.51,14.87)
  BOTTOM w0.089: v2(203.41,22.27) 203.45,22.27 203.78,21.95 UH1.W36
IGPU_ROM_CS#: length 21.7
  TOP w0.114: UG16.2 195.14,110.78 194.87,111.05 194.87,111.63 195,111.77 195.37,111.77 196.29,112.68 197.64,112.68 198,113.04 198.18,113.04 198.44,113.31 198.44,114.48 199.72,115.76 203.25,115.76 204.75,114.26 207.25,114.26 v1(207.43,114.07) v2(207.95,113.56)
  BOTTOM w0.089: 210.82,114.14 RG147.2
  BOTTOM w0.114: 210.82,114.14 UG15.1 208.53,114.14 v2(207.95,113.56)
IGPU_ROM_SCLK: length 1.6
  BOTTOM w0.114: UG15.6 RG148.1
IGPU_ROM_SI: length 1.6
  BOTTOM w0.114: UG15.5 RG149.1
IGPU_ROM_SO: length 27.1
  TOP w0.114: UG16.5 194.89,109.28 194.53,108.92 194.53,107.59 v1(194.97,107.16) 194.97,106.89 195.45,106.41 197.85,106.41 201.02,109.57 201.02,112.12 201.96,113.06 204.93,113.06 206.28,111.71 208.26,111.71 209.61,113.07 211.66,113.07 v2(212.16,113.57)
  BOTTOM w0.089: v2(212.16,113.57) 212.62,113.12 RG146.1
IGPU_ROM_SO_R: length 3.1
  BOTTOM w0.089: RG146.2 211.83,112.94 v1(212.81,111.96)
  BOTTOM w0.114: UG15.2 211.25,112.87 211.31,112.94 RG146.2
IMVP_VR_ON: length 390.8
  TOP w0.114: v2(313.98,19.87) 313.98,19.56 313.64,19.22 313.37,19.22 312.34,18.19 311.67,18.19 311.22,18.64 311.22,19.26 311.1,19.39 311.1,19.71 310.71,20.1 309.7,20.1 CE38.1 308.56,19.51 308.46,19.41 UE5.121 ; v2(321.19,40.15) 320.83,40.52 320.83,42.21 321.19,42.57 Q7.6
  IN3 w0.127: v2(313.98,19.87) 314.84,20.73 314.84,29.53 321.21,35.9 321.21,37.85 321.6,38.23 321.6,39.74 v2(321.19,40.15) ; v2(122.85,133.13) 122.85,127.25 125.99,124.11 125.99,121.52 124.98,120.5 124.98,115.98 124.34,115.35 124.34,113.11 122.34,111.1 122.34,99.99 117.23,94.89 117.23,91.78 116.06,90.61 116.06,73.5 103.76,61.2 103.76,59 102.37,57.61 102.37,55.21 101.63,54.47 101.63,52.34 98.75,49.46 v2(98.75,47.47)
  IN6 w0.081: v2(98.75,47.47) 98.75,47.15 105.85,40.05 111.66,40.05 112.88,38.83 119.89,38.83 122.75,35.97 158.31,35.97 159.27,36.93 174.37,36.93 174.71,37.27 179.83,37.27 185.62,43.06 185.62,51.58 188.75,54.71 192.71,54.71 196.62,58.62 199.82,58.62 202.11,56.32 208.33,56.32 211.01,53.65 211.01,51.59 213.34,49.26 226.88,49.26 227.34,48.81 230.93,48.81 233.09,46.64 241.87,46.64 242.56,47.34 248.95,47.34 250.33,45.96 256.96,45.96 257.66,45.26 269.08,45.26 274.47,39.87 287.45,39.87 289.04,41.45 302.75,41.45 304.73,43.43 310.66,43.43 312.64,41.45 319.89,41.45 v2(321.19,40.15)
  BOTTOM w0.114: PR523.1 122.85,134.91 v2(122.85,133.13)
IN1_PEQ#: length 5.7
  BOTTOM w0.114: UV21.52 203.66,133.38 203.77,133.5 RV633.2 204.96,132.48 RV629.1 205.61,133 206.72,133 206.91,133.19 RV628.1
IN2_PEQ#: length 17.2
  IN1 w0.081: v2(203.76,126.17) 203.76,126.69 204.63,127.56 204.63,133.99 v2(204.1,134.53)
  BOTTOM w0.114: UV21.51 203.55,133.78 204.1,134.33 v2(204.1,134.53) 204.48,134.53 204.61,134.4 RV632.2 ; RV631.1 206.9,126.27 206.29,125.66 206.29,124.72 RV630.1 205.96,124.6 204.49,124.6 203.76,125.33 v2(203.76,126.17)
INTRUDER#: length 1.3
  TOP w0.089: v2(216.88,34.2) 216.84,34.24 RH531.1
  BOTTOM w0.089: UH1.BE11 216.71,34.37 v2(216.88,34.2)
INV_PWM: length 227.1
  TOP w0.102: JEDP.36 169.12,178.54 168.16,177.57 168.16,173.7 169.43,172.43 169.43,171.36 v2(168.86,170.78) ; RV8.1 170.2,160.27 v2(170.2,157.93) ; v2(177.24,15.27) 177.3,15.27 v1(178.41,14.16) 179.02,13.55 180.53,13.55 187.07,7.01 193.09,7.01 193.51,7.43 UV22.4
  IN4 w0.102: v2(168.86,170.78) 169.02,170.61 169.02,168.78 169.82,167.98 169.82,158.9 170.2,158.52 170.2,157.94 v2(170.2,157.93) 170.56,157.58 172.35,157.58 172.69,157.23 175.36,157.23 175.87,157.74 178.72,157.74 178.79,157.66 180.17,157.66 181.43,156.4 181.43,155.29 182.38,154.33 186.08,154.33 190.85,149.56 190.85,148.72 194.34,145.23 194.34,137.21 193.92,136.79 193.92,130.25 193.3,129.63 193.3,128.5 192.61,127.82 192.61,124.12 187.5,119.01 187.5,115.74 186.32,114.56 186.32,111.84 185.01,110.54 185.01,99.31 184.82,99.12 184.82,94.16 186.62,92.35 186.62,82.27 185.56,81.21 185.56,72.43 186.14,71.85 186.14,67.78 185.89,67.53 185.89,58.64 187.97,56.56 v2(187.97,56.1)
  IN6 w0.102: v2(180.41,42.34) 180.93,42.34 184.32,45.73 184.32,52.65 187.77,56.1 v2(187.97,56.1)
  BOTTOM w0.102: v2(177.24,15.27) 177.24,22.07 172.86,26.45 172.86,35.53 174.32,36.99 179.87,36.99 180.83,37.94 180.83,41.92 v2(180.41,42.34)
ISEN1: length 3.4
  BOTTOM w0.203: PU6000.20 273.61,135.39 v1(272.43,134.21) 271.65,133.43 PR6026.2
ISEN1_GT: length 36.3
  TOP w0.102: v2(141.42,137.96) 141.07,137.61 v1(141.07,137.41)
  TOP w0.254: v2(141.42,137.96) 141.67,137.96 142.09,138.38 PR587.2 142.34,138.32 PR589.2 ; v2(122.31,142.42) 121.92,142.42 PC528.2
  IN1 w0.254: v2(141.42,137.96) 140.47,137.01 140.47,133.9 139.9,133.32 132.59,133.32 128.15,137.76 125.48,137.76 125.23,137.51 122.18,137.51 120.66,139.03 120.66,141.26 121.82,142.42 v2(122.31,142.42)
  BOTTOM w0.203: PU500.9 122.88,142.08 122.55,142.42 v2(122.31,142.42)
ISEN1_VCORE: length 55.1
  TOP w0.254: 158.67,134.16 158.66,134.18 PR558.2 158.2,135.05 157.8,134.66 v1(155.13,134.66) 154.65,134.66 v2(154.59,134.59) ; 158.67,134.16 PR561.2 ; 158.67,134.16 PR560.2 ; PC527.1 127.7,145.55 v2(127.7,145.26)
  IN6 w0.254: v2(127.7,145.26) 127.58,145.38 127.58,147.74 128.02,148.18 129.47,148.18 133.47,144.18 133.99,144.18 136.05,142.12 136.05,131.96 137.9,130.11 152.97,130.11 154.01,131.14 154.01,134.34 154.26,134.59 v2(154.59,134.59)
  BOTTOM w0.203: v2(127.7,145.26) 127.7,145.07 127.47,144.84 PU500.21
ISEN2: length 5.8
  BOTTOM w0.102: v1(273.94,131.07) 273.07,131.93 273.07,132.62 PR6027.2
  BOTTOM w0.203: PU6000.19 274.01,135.31 272.81,134.11 272.81,134.05 272.6,133.84 PR6027.2
ISEN2_GT: length 45.8
  TOP w0.254: PC525.2 122.24,142.99 v2(122.25,143) ; PR598.2 150.47,138.32 PR596.2 148.79,138.34 v1(148.34,137.89) 148.15,137.7 v2(148.15,137.07)
  IN1 w0.254: v2(148.15,137.07) 147.64,136.56 141.24,136.56 140.85,136.18 140.85,133.74 139.8,132.68 131.52,132.68 128.09,136.11 121.74,136.11 120.27,137.59 120.27,141.5 121.77,143 v2(122.25,143)
  BOTTOM w0.203: PU500.10 122.95,142.48 122.43,143 v2(122.25,143)
ISEN2_VCORE: length 65.7
  TOP w0.102: v1(129.37,146.15) 129.18,145.96 PC526.1
  TOP w0.254: v2(164.04,135.1) 164.12,135.18 PR568.2 167.14,135.13 167.14,134.35 PR571.2 PR570.2 ; v2(128.34,145.32) 128.34,145.81 PC526.1
  IN6 w0.254: v2(128.34,145.32) 129.16,146.15 130.42,146.15 133.15,143.42 133.67,143.42 135.29,141.8 135.29,131.32 137.33,129.28 153.39,129.28 156.79,132.68 158.12,132.68 161.46,129.34 163.07,129.34 163.71,129.98 163.71,131.79 164.34,132.43 164.34,134.8 v2(164.04,135.1)
  BOTTOM w0.203: PU500.22 127.87,144.67 128.34,145.13 v2(128.34,145.32)
ISEN3: length 2.4
  BOTTOM w0.203: PU6000.18 274.41,135.17 v1(273.77,134.54) 273.57,134.33 PR6028.2
ISEN3_VCORE: length 71.6
  TOP w0.102: v1(172.97,134.16) PR581.2
  TOP w0.254: PR581.2 PR580.2 175.14,135.05 PR578.2 v2(174.25,135.1)
  IN6 w0.254: v2(129.55,145.15) 129.55,144.56 130.18,143.92 130.36,143.92 130.95,143.33 131.41,143.33 132.09,142.65 133.36,142.65 134.53,141.48 134.53,130.75 136.76,128.52 154.43,128.52 155.42,129.51 160.22,129.51 161.21,128.52 171.79,128.52 172.22,128.94 172.22,133.51 172.98,134.27 173.42,134.27 v2(174.25,135.1)
  BOTTOM w0.203: v2(129.55,145.15) 128.86,145.15 128.27,144.56 PU500.23
  BOTTOM w0.254: v2(129.55,145.15) 130.03,145.62 PC524.1
ISEN4: length 3.2
  BOTTOM w0.203: PU6000.17 274.81,134.87 v1(275.05,134.63) 275.34,134.33 PR6070.2 PR6030.2
ISEN5: length 3
  BOTTOM w0.203: PU6000.16 275.21,135.27 275.81,134.66 v1(276.36,134.66) 276.48,134.55 276.48,133.89 PR6032.2
ISENSEP_L: length 3.2
  TOP w0.203: UA4.25 32.65,14.25 32.77,14.37 32.77,14.57
  TOP w0.508: 32.77,14.57 32.89,14.69 32.89,14.69 33.12,14.91 33.12,14.92 33.34,15.14 RA58.2 RA77.1
ISENSEP_L_R: length 19.6
  TOP w0.127: v2(33.92,16.99) v1(33.92,17.79)
  IN1 w1.016: 37.47,3.59 34.97,3.59 33.98,4.57 33.98,5.3 32.97,6.32 31.57,6.32 30.55,7.33 30.55,13.43 32.86,15.74 33.4,15.74
  vias: v2(33.34,16.99) v2(37.85,2.58) v2(38.48,2.58)
ISENSEP_R: length 5.7
  TOP w0.127: v1(27.59,16.28) 27.96,15.91 RA80.1
  TOP w0.203: 30.87,13.88 31.25,13.88 31.45,13.67 UA4.28
  TOP w0.508: RA80.1 28.63,15.08 RA63.2 28.85,14.88 29.85,13.88 30.87,13.88
ISENSEP_R_R: length 15.6
  IN1 w1.016: 28.77,15.53 28.83,15.47 28.65,15.28 28.65,7.91 29.22,7.33 29.22,6.11 30.64,4.69 31.35,4.69 31.46,4.79 32.01,4.79 32.53,4.27 32.53,2.58
  vias: v1(32.04,1.91) v2(28.49,16.42) v2(29.09,16.42) v2(31.73,1.43) v2(32.33,1.43)
ISUMN_GT: length 59.3
  TOP w0.254: PR597.1 151.42,136.47 150.94,135.99 149.87,135.99 149.61,136.24 v2(149.61,137.58) ; PR588.1 143.32,136.23 143.07,135.99 141.8,135.99 141.74,136.05 v2(141.42,136.05)
  TOP w0.508: v2(119.83,142.28) 120.01,142.1 PC528.1 PC525.1 v1(120.68,144.48) 120.68,147.37 120.88,147.58 PH502.2
  IN1 w0.254: v2(119.83,142.28) 119.75,142.2 119.75,137.4 121.48,135.67 127.89,135.67 131.26,132.3 140.26,132.3 141.42,133.46 v2(141.42,136.05) 148.09,136.05 v2(149.61,137.58)
  BOTTOM w0.508: PC523.1 PR538.1 120.5,144.5 PR540.1 120.29,143.63 119.83,143.18 v2(119.83,142.28) 119.47,141.92 PC517.2 PC516.2 PR535.2
ISUMN_SA: length 91.3
  TOP w0.254: v2(131.21,136.29) 130.38,136.29 130.15,136.06 PC511.1
  IN2 w0.254: v2(187.05,135.49) 187.06,135.49 187.52,135.03 187.52,127.55 183.67,123.7 168.94,123.7 167.52,125.13 154.69,125.13 153.23,126.59 140.53,126.59 140.32,126.8 139.68,127.45 134.66,127.45 134.18,127.92 134.18,128.44 v2(134.08,128.54)
  IN4 w0.254: v2(134.08,128.54) 134.18,128.64 134.18,136.94 133.74,137.38 132.3,137.38 v2(131.21,136.29)
  BOTTOM w0.254: v2(187.05,135.49) 187.39,135.49 v1(187.71,135.17) 188.01,134.86 188.01,133.68 187.54,133.2 PH501.1 PR5027.1 ; v2(131.21,136.29) 131.22,136.31 133.1,136.31 133.67,136.88 133.67,137.93 133.13,138.48 PR528.1 133.09,138.49 PR524.2 PC512.1 PC510.1 PR529.1
ISUMN_VCORE: length 85.4
  TOP w0.254: PR542.1 PC530.1 PC531.1 127.23,146.94 PC527.2 PC526.2 v2(128.19,147.56) ; PR579.1 176.08,133.25 175.39,132.56 171.26,132.56 v1(170.9,132.92) 170.45,133.37 PR569.1 168.03,133.32 167.45,132.75 v2(163.84,132.75) 160.11,132.75 PR559.1
  IN6 w0.254: v2(128.19,147.56) 129.55,147.56 133.31,143.8 133.83,143.8 135.67,141.96 135.67,131.57 137.52,129.72 153.29,129.72 156.63,133.06 158.28,133.06 161.62,129.72 162.91,129.72 163.33,130.14 163.33,132.24 v2(163.84,132.75)
  BOTTOM w0.254: v2(163.84,132.75) 163.84,131.92 163.38,131.47 PH503.1 ; PR541.2 128.21,146.02 PR543.2 129.99,146.94 PC524.2 130.03,147.81 PC529.1 128.49,147.86 v2(128.19,147.56)
ISUMP_GT: length 59.2
  TOP w0.102: v1(124.04,149.19) 123.58,148.73 v2(123.58,148.45)
  TOP w0.254: PR586.1 142.31,139.28 PR572.2 v2(141.42,138.59) ; v2(149.61,138.97) 150.18,138.97 150.58,139.38 PR595.1 ; PR534.1 v2(123.58,148.45)
  IN1 w0.254: v2(123.58,148.45) 123.58,147.35 121.17,144.94 121.17,144.24 121.74,143.67 122.69,143.67 123.33,143.03 123.33,142.08 122.63,141.38 v2(121.67,141.38) 121.15,140.86 121.15,139.12 122.37,137.89 124.79,137.89 125.04,138.14 128.47,138.14 132.85,133.77 139.58,133.77 139.96,134.15 139.96,137.57 140.98,138.59 v2(141.42,138.59) 141.61,138.59 143.26,136.94 146.82,136.94 148.86,138.97 v2(149.61,138.97)
  BOTTOM w0.203: v2(121.67,141.38) 122.18,141.38 122.28,141.28 PU500.7
  BOTTOM w0.254: v2(121.67,141.38) 121.67,141.41 121.43,141.65 PC517.1 PC516.1 PR535.1
ISUMP_SA: length 85.9
  TOP w0.254: PR5003.2 186.72,132.81 186.95,132.81 187.15,133.02 PR582.2 v1(187.2,134.16) 187.2,134.61 v2(187.04,134.78)
  IN2 w0.254: v2(134.67,128.54) 134.57,128.44 134.57,128.08 134.82,127.83 139.87,127.83 140.61,127.08 153.28,127.08 154.85,125.51 167.68,125.51 169.1,124.09 183.51,124.09 187.14,127.71 187.14,134.68 v2(187.04,134.78)
  IN4 w0.254: v2(134.67,128.54) 134.57,128.64 134.57,138.21 132.41,140.37 131.42,140.37 131.36,140.31 v2(131.2,140.31)
  BOTTOM w0.203: PU500.32 131.02,140.48 v2(131.2,140.31)
  BOTTOM w0.254: PR530.2 187.51,134.31 v2(187.04,134.78) ; v2(131.2,140.31) 131.27,140.24 PC512.2 PC510.2 PR529.2
ISUMP_VCORE: length 82.1
  TOP w0.254: v2(164.02,135.73) 166.57,135.73 PR567.1 ; PR544.2 PR542.2 PC530.2 PC531.2 126.43,146.02 126.69,145.77 v2(126.69,145.39) ; PR577.1 174.75,136.23 v2(174.25,135.73) ; PR557.1 158.47,136.26 PR562.2 157.43,135.23 v1(156.56,135.23) v2(154.59,135.23)
  IN6 w0.254: v2(126.69,145.39) 126.69,147.54 127.71,148.56 129.63,148.56 133.63,144.56 134.15,144.56 136.43,142.27 136.43,132.12 138.06,130.49 152.82,130.49 153.63,131.3 153.63,134.65 154.2,135.23 v2(154.59,135.23) 157.8,135.23 158.31,135.73 v2(164.02,135.73) 170.43,135.73 170.87,135.3 173.44,135.3 173.88,135.73 v2(174.25,135.73)
  BOTTOM w0.203: v2(126.69,145.39) 126.67,145.37 PU500.19
IVSENSE_L: length 3.2
  TOP w0.203: 32.14,14.64 32.25,14.53 UA4.26
  TOP w0.508: RA59.2 32.45,15.33 RA78.1 31.56,15.17 32.1,14.64 32.14,14.64
IVSENSE_R: length 3
  TOP w0.203: UA4.29 29.98,12.41 29.6,12.8
  TOP w0.508: 29.6,12.8 29.34,13.06 RA81.1 RA64.2
JKSI0: length 43.6
  TOP w0.102: v2(209.74,6.51) 211.11,7.88 216.58,7.88 217.71,9.01 222.29,9.01 222.51,9.24 v1(222.51,11.27) 222.51,13.67 228.25,19.4 228.56,19.72 230.28,19.72 230.97,19.02 v2(230.97,18.81)
  BOTTOM w0.102: JKB.30 208.97,5.98 209.13,6.14 209.37,6.14 v2(209.74,6.51)
  BOTTOM w0.107: v2(230.97,18.81) 231.71,19.55 231.71,29.47 RE471.1
JKSI1: length 46.4
  BOTTOM w0.102: RE474.1 227.11,32.2 226.79,31.88 226.79,30.51 226.29,30 226.29,29.36 226.56,29.09 226.56,27.51 v1(225.97,26.91) 225.84,26.78 225.84,24.91 225.04,24.11 225.04,21.09 227.62,18.51 228.13,18.51 229.43,17.2 229.43,16.27 230.39,15.32 230.39,13.47 229.72,12.81 216.56,12.81 214.67,10.91 211.42,10.91 209.47,8.96 JKB.29
JKSI2: length 38.9
  TOP w0.102: v2(210.32,6.49) 210.32,6.49 211.48,7.65 216.67,7.65 217.8,8.79 222.38,8.79 222.84,9.25 v1(222.84,9.44) 222.84,13.67 228.34,19.17 228.61,19.44 228.61,19.44 228.66,19.49 230.18,19.49 230.39,19.28 v2(230.39,18.8)
  BOTTOM w0.102: JKB.28 209.97,6.14 v2(210.32,6.49)
  BOTTOM w0.107: v2(230.39,18.8) 230.39,18.81 231.47,19.89 231.47,26.47 RE466.1
JKSI3: length 42.2
  BOTTOM w0.102: JKB.27 210.47,9.16 v1(211.33,10.02) 212,10.68 214.76,10.68 216.66,12.58 229.82,12.58 230.62,13.37 230.62,15.41 229.66,16.37 229.66,17.3 228.21,18.75 227.7,18.75 225.27,21.19 225.27,24.02 226.07,24.82 226.07,26.54 226.79,27.27 226.79,28.65 227.11,28.96 RE467.1
JKSI4: length 34.3
  TOP w0.102: v2(210.97,6.57) v4(211.43,6.11) 211.54,6 212.04,6 212.48,6.45 212.48,6.7 212.98,7.19 216.86,7.19 217.99,8.33 222.57,8.33 223.4,9.16 223.4,13.58 228.11,18.29 229.02,18.29 v2(229.74,19.02)
  BOTTOM w0.102: v2(210.97,6.57) JKB.26
  BOTTOM w0.107: v2(229.74,19.02) 230.12,19.4 230.65,19.4 231.24,19.99 231.24,23.46 RE461.1
JKSI5: length 37.8
  BOTTOM w0.102: JKB.25 211.47,8.92 213,10.46 214.87,10.46 216.76,12.35 229.92,12.35 230.85,13.28 230.85,15.5 229.89,16.46 229.89,17.39 228.3,18.98 227.8,18.98 225.5,21.28 225.5,21.89 225.5,22.25 v4(225.8,22.55) 226.7,23.45 226.7,25.05 227.11,25.47 RE460.1
JKSI6: length 29.1
  TOP w0.102: v2(211.97,6.57) 212.83,7.42 216.76,7.42 217.9,8.56 222.48,8.56 223.17,9.25 223.17,13.68 228.25,18.75 v4(228.56,18.75) 228.87,18.75 v2(229.16,19.04)
  BOTTOM w0.102: v2(211.97,6.57) JKB.24 ; RE455.1 230.68,20.48 229.62,20.48 229.16,20.01 v2(229.16,19.04)
JKSI7: length 34.8
  BOTTOM w0.102: RE454.1 226.42,22.49 225.73,21.79 225.73,21.38 227.89,19.21 228.4,19.21 230.12,17.49 230.12,16.55 231.09,15.59 231.09,13.19 230.01,12.11 216.86,12.11 214.97,10.23 213.33,10.23 v4(213.17,10.07) 212.94,10.07 212.47,9.6 JKB.23
JKSI8: length 46.4
  TOP w0.102: v2(212.97,6.57) 214.76,4.78 v1(224,4.78) 226.61,4.78 231.35,9.52 231.35,10.74 237.03,16.42 237.03,18 v2(237.73,18.7)
  BOTTOM w0.102: v2(212.97,6.57) JKB.22
  BOTTOM w0.107: v2(237.73,18.7) 237.73,25.2 237.65,25.28 237.65,27.07 237.46,27.26 237.46,29.92 237.04,30.35 RE396.1
JKSI9: length 41.4
  BOTTOM w0.102: JKB.21 213.47,9.04 214.34,9.91 v1(215.06,9.91) 217.03,11.88 230.1,11.88 230.51,12.29 231.31,13.09 231.31,15.68 230.6,16.4 230.6,17.87 231.94,19.2 231.94,30.24 232.7,30.99 232.7,32.06 232.84,32.2 RE399.1
JKSI10: length 41.5
  TOP w0.102: v2(213.97,6.57) 215.43,5.11 v1(221.92,5.11) 226.62,5.11 231.12,9.61 231.12,10.84 236.8,16.51 236.8,18.36 v2(237.14,18.7)
  BOTTOM w0.102: 237.28,27.11 237.42,26.97 237.42,25.18 ; v2(213.97,6.57) JKB.20
  BOTTOM w0.107: v2(237.14,18.7) 237.42,18.98 237.42,25.18 ; RE476.1 237.28,27.11
JKSI11: length 37.3
  BOTTOM w0.102: RE480.1 232.72,28.96 232.17,28.41 232.17,19.11 230.83,17.77 230.83,16.49 231.54,15.78 231.54,13 230.74,12.2 230.58,12.03 230.58,12.02 230.2,11.65 217.26,11.65 v1(217.05,11.44) 214.47,8.85 JKB.19
JKSI12: length 36.4
  TOP w0.102: v2(236.56,18.7) 236.56,16.6 230.79,10.83 v1(230.79,10.26) 230.79,9.61 226.63,5.44 216.1,5.44 v2(214.97,6.57)
  BOTTOM w0.102: v2(214.97,6.57) JKB.18
  BOTTOM w0.107: v2(236.56,18.7) 237.11,19.25 237.11,23.76 237,23.87 RE482.1
JKSI13: length 33.6
  BOTTOM w0.102: RE486.1 232.63,25.72 232.4,25.49 232.4,19.01 231.06,17.68 231.06,16.59 231.77,15.87 231.77,12.76 231.67,12.66 v1(231.67,12.65) 230.44,11.42 217.57,11.42 216.34,10.19 216.34,9.54 215.47,8.67 JKB.17
JKSI14: length 31.3
  TOP w0.102: v2(215.97,6.57) 216.87,5.67 226.39,5.67 v1(229.38,8.66) 230.45,9.73 230.45,10.81 235.97,16.34 v2(235.97,18.7)
  BOTTOM w0.102: RE488.1 236.74,19.46 v2(235.97,18.7) ; v2(215.97,6.57) JKB.16
JKSI15: length 29.9
  BOTTOM w0.102: JKB.15 216.47,8.65 217.27,9.45 217.27,10.24 218.21,11.18 226.38,11.18 226.63,10.93 v1(228.32,10.93) 230.42,10.93 232,12.51 232,15.97 231.29,16.68 231.29,17.58 232.62,18.92 232.62,22.32 232.79,22.49 RE492.1
JKSI16: length 36.4
  TOP w0.102: RE495.1 232.66,30.45 232.41,30.2 232.41,22.08 231.91,21.58 231.91,19.18 230.65,17.91 228.05,17.91 224.28,14.14 v1(224.28,12.53) 224.28,8.85 223.53,8.1 218.56,8.1 v2(216.97,6.51)
  BOTTOM w0.102: v2(216.97,6.51) JKB.14
JKSI17: length 40.7
  TOP w0.102: RE498.1 236.77,32.2 237.11,31.86 237.11,31.08 237.94,30.25 237.94,22.89 234.65,19.6 234.65,16.7 227.64,9.68 v1(227.5,9.68) 226.95,9.68 v2(226.89,9.62)
  BOTTOM w0.102: v2(226.89,9.62) 226.83,9.62 225.5,10.95 218.35,10.95 217.83,10.43 217.83,9.24 217.47,8.88 JKB.13
JKSI18: length 31.8
  TOP w0.102: RE502.1 232.64,26.46 232.64,21.93 232.14,21.42 232.14,19.08 230.74,17.69 228.15,17.69 224.61,14.15 v1(224.61,10.7) 224.61,8.86 223.62,7.87 219.33,7.87 v2(217.97,6.51)
  BOTTOM w0.102: JKB.12 v2(217.97,6.51)
JKSI19: length 39.3
  TOP w0.102: RE503.1 236.77,28.96 237.71,28.02 237.71,23.04 236.9,22.22 233.9,22.22 232.83,21.14 232.83,18.8 231.03,17 228.43,17 226.26,14.82 v1(226.26,12.08) v2(226.26,9.62)
  BOTTOM w0.102: JKB.11 218.47,8.71 218.06,9.12 218.06,10.34 218.44,10.72 225.16,10.72 v2(226.26,9.62)
JKSI20: length 28.1
  TOP w0.102: v2(218.97,6.57) 220.04,7.64 223.72,7.64 224.94,8.86 v1(224.94,8.97) 224.94,14.16 228.24,17.46 230.84,17.46 232.37,18.99 232.37,21.33 233.05,22.02 RE507.1
  BOTTOM w0.102: v2(218.97,6.57) JKB.10
JKSI21: length 33.1
  TOP w0.102: RE510.1 236.77,25.79 237.11,25.45 237.11,22.75 236.8,22.45 233.81,22.45 232.6,21.23 232.6,18.89 230.93,17.23 228.34,17.23 225.62,14.51 v1(225.62,14.13) v2(225.62,9.62)
  BOTTOM w0.102: v2(225.62,9.62) 224.76,10.49 221.19,10.49 220.67,9.97 220.67,9.14 220.39,8.86 219.58,8.86 219.47,8.75 JKB.9
JKSO0: length 61.6
  TOP w0.102: QE54.6 225.94,24.67 226.01,24.74 226.44,24.74 226.7,24.48 226.7,23.69 226.98,23.42 ; v2(219.97,6.57) 220.81,7.41 224.94,7.41 226.01,8.48 226.76,8.48 234.88,16.6 234.88,19.5 238.17,22.79 238.17,30.34 237.34,31.17 237.34,32.83 235.78,34.39 232.74,34.39 v1(232.14,33.79) 232.14,30.91 231.71,30.49 231.71,26.4 231.41,26.09 230.58,26.09 230.48,25.99 230.48,25.58 230.34,25.45 QE49.6
  TOP w0.107: 226.98,23.42 228.12,23.42 228.5,23.8 228.5,25.26 228.69,25.45 QE49.6
  BOTTOM w0.102: v2(219.97,6.57) JKB.8
JKSO1: length 29.8
  TOP w0.102: QE54.3 224.64,26.33 224.48,26.5 224.15,26.5 223.74,26.08 223.16,26.08 222.75,25.67 222.75,24.82 223.05,24.52 223.05,23.11 222.36,22.43 222.36,21.89 221.59,21.12 221.59,20.01 221.83,19.76 225.24,19.76 225.94,20.46 QE50.6 226.61,20 226.61,18.78 v1(224.57,16.74) 221.08,13.24 v2(221.08,9.62)
  BOTTOM w0.107: JKB.7 220.47,8.61 221.08,9.22 v2(221.08,9.62)
JKSO2: length 57.8
  TOP w0.102: QE55.6 226.48,27.11 226.89,26.7 228.29,26.7 228.61,27.02 228.61,28.58 228.71,28.69 QE51.6 230.4,28.69 230.47,28.76 230.47,29.23 230.58,29.33 230.98,29.33 231,29.34 231,29.34 231.24,29.58 231.24,30.66 231.68,31.1 231.68,33.45 231.24,33.9 231.24,34.47 231.38,34.61 235.88,34.61 237.57,32.92 237.57,31.32 238.4,30.49 238.4,22.7 235.11,19.41 235.11,16.51 226.85,8.25 226.1,8.25 224.93,7.08 v1(223.38,7.08) 221.48,7.08 v2(220.97,6.57)
  BOTTOM w0.102: v2(220.97,6.57) JKB.6
JKSO3: length 78.5
  TOP w0.102: QE55.3 224.64,29.34 224.48,29.5 222.97,29.5 222.86,29.6 222.86,33.91 223.08,34.13 229.17,34.13 230.11,35.07 236.07,35.07 238.03,33.11 238.03,31.51 238.86,30.68 238.86,22.51 235.57,19.22 235.57,16.32 230.22,10.97 230.22,10.09 v2(229.75,9.62)
  TOP w0.107: QE52.6 229.64,22.21 229.42,21.99 229.42,20.72 228.86,20.16 227.52,20.16 227.28,19.92 227.28,18.94 221.66,13.33 v4(221.66,12.91) v2(221.66,9.62)
  BOTTOM w0.102: v2(229.75,9.62) 229.24,9.11 225.56,9.11 224.41,10.26 222.3,10.26 v2(221.66,9.62)
  BOTTOM w0.107: JKB.5 221.47,8.9 221.66,9.09 v2(221.66,9.62)
JKSO4: length 56.6
  TOP w0.102: QE56.6 224.54,29.81 224.67,29.69 225.78,29.69 226.03,29.94 227.91,29.94 228.27,29.58 229.23,29.58 229.42,29.78 229.42,31.77 229.58,31.92 QE53.6 v1(229.92,33.97) 229.92,34.55 230.21,34.84 235.97,34.84 237.8,33.02 237.8,31.41 238.63,30.58 238.63,22.6 235.34,19.31 235.34,16.41 226.95,8.02 226.2,8.02 224.68,6.51 v2(221.97,6.51)
  BOTTOM w0.102: v2(221.97,6.51) JKB.4
JRTC1: length 2.4
  TOP w0.102: PR2.1 v1(292.81,39.66)
  TOP w0.254: PR2.1 293.53,40.08 PD5.2
JTAG_TCLK: length 3.8
  BOTTOM w0.089: T10.1 235.62,117.37 235.62,116.1 235.41,115.89 235.41,115.62 235.07,115.28 UG9.BK24
JTAG_TDI: length 4.9
  BOTTOM w0.089: UG9.BM23 234.37,117.08 232.37,119.08 232.37,119.62 T12.1
JTAG_TDO: length 3.1
  BOTTOM w0.089: UG9.BM24 234.76,116.76 234.76,117.24 T13.1
JTAG_TMS: length 4.3
  BOTTOM w0.089: T11.1 231.89,118.83 234.03,116.68 234.03,116.26 234.37,115.92 UG9.BL23
JTAG_TRST#: length 5.8
  TOP w0.089: v4(232.85,119.41) 233.09,119.17 v2(233.59,119.17)
  BOTTOM w0.089: UG9.BL24 235.07,115.97 235.38,116.28 235.38,117.15 234.12,118.41 234.12,118.64 v2(233.59,119.17) 233.12,119.64 RG518.1
KB_LED_B1_DRV#: length 25
  TOP w0.102: v2(168.16,9.05) v1(168.16,11.88) 168.16,12.53 174.65,19.02 182.82,19.02 183.49,19.69 UE4.5
  BOTTOM w0.102: JKBBL.5 167.82,8.71 v2(168.16,9.05)
KB_LED_B2_DRV#: length 30.6
  TOP w0.102: UE4.9 186.1,17.78 186,17.89 184.51,17.89 184.06,18.34 175.23,18.34 169.53,12.64 v1(169.53,10.24) 169.53,9.39 169.64,9.28 169.64,6.61 169.18,6.15 166.81,6.15 v2(166.32,6.64)
  BOTTOM w0.102: v2(166.32,6.64) JKBBL.8
KB_LED_B3_DRV#: length 33.9
  TOP w0.102: UE4.14 188.6,16.4 188.35,16.15 184.84,16.15 v1(184.18,16.81) 183.35,17.64 175.52,17.64 170.57,12.7 170.57,9.11 v2(170.57,9.11)
  BOTTOM w0.102: v2(170.57,9.11) 170.57,9.75 170.14,10.18 165.6,10.18 164.82,9.39 JKBBL.11
KB_LED_B4_DRV#: length 40.2
  TOP w0.102: UE4.17 190.8,18.19 190.89,18.1 190.89,17.69 190.78,17.59 190.78,17.59 188.65,15.45 184.43,15.45 182.94,16.94 175.84,16.94 172.82,13.92 172.82,7.81 v1(172.72,7.71) 170.48,5.46 164.49,5.46 v2(163.32,6.64)
  BOTTOM w0.102: v2(163.32,6.64) JKBBL.14
KB_LED_B5_DRV#: length 300.9
  TOP w0.102: UE8.21 306.72,39.46 v2(306.52,39.66) ; v2(73.45,16.72) v1(74.27,16.72)
  IN2 w0.102: v2(73.45,16.72) 73.61,16.57 96.6,16.57 100.15,20.11 116.21,20.11 125.71,29.61 186.37,29.61 187.28,30.51 188.23,30.51 189.49,31.78 194.58,31.78 195.27,32.48 198.46,32.48 199.93,33.95 202.9,33.95 203.1,34.15 205.57,34.15 206.32,34.89 206.32,35.59 206.85,36.12 207.86,36.12 209.1,37.36 209.97,37.36 210.37,37.76 213.7,37.76 216.89,34.57 217.03,34.57 217.1,34.5 218.95,34.5 220.3,33.15 223.33,33.15 226.74,36.57 229.62,36.57 229.9,36.29 231.44,36.29 231.96,36.81 238.82,36.81 241.78,33.85 241.78,30.53 242.82,29.48 248.28,29.48 249.11,28.66 268.48,28.66 269.45,27.68 274.55,27.68 275.44,26.79 277.08,26.79 285.73,18.15 298.31,18.15 299.32,19.16 302.17,19.16 304.01,21 308.19,21 309.65,22.46 309.65,23.63 310.07,24.05 v2(310.07,24.77)
  IN3 w0.102: v2(306.52,39.66) 307.49,38.69 307.49,32.52 308.45,31.55 308.45,27.21 310.07,25.6 v2(310.07,24.77)
  BOTTOM w0.107: JKB3.2 64.43,7.05 64.59,6.89 72.65,6.89 73.53,7.77 73.53,10.18 73.99,10.64 73.99,16.19 v2(73.45,16.72)
KB_LED_G1_DRV#: length 28.1
  TOP w0.102: v2(168.32,6.78) 167.73,7.38 167.73,12.43 174.65,19.35 v1(181.25,19.35) 182.82,19.35 183.67,20.19 UE4.4
  BOTTOM w0.102: v2(168.32,6.78) JKBBL.4
KB_LED_G2_DRV#: length 26.9
  TOP w0.102: v2(169.24,9.05) 169.02,9.26 169.02,10.92 169.03,10.92 169.03,12.6 v1(171.28,14.86) 174.99,18.57 184.16,18.57 184.53,18.19 UE4.8
  BOTTOM w0.102: JKBBL.7 166.82,9.18 167.37,9.72 168.56,9.72 v2(169.24,9.05)
KB_LED_G3_DRV#: length 33.2
  TOP w0.102: UE4.11 187.1,16.57 186.92,16.39 185.07,16.39 183.58,17.88 175.42,17.88 170.34,12.8 170.34,9.45 169.97,9.08 v1(169.97,8.3) 169.97,6.62 169.28,5.92 166.03,5.92 v2(165.32,6.64)
  BOTTOM w0.102: v2(165.32,6.64) JKBBL.10
KB_LED_G4_DRV#: length 35.3
  TOP w0.102: v2(171.47,9.31) v1(171.47,11.21) 171.47,12.93 175.71,17.17 183.03,17.17 184.52,15.68 188.55,15.68 189.6,16.74 UE4.16
  BOTTOM w0.102: v2(171.47,9.31) 170.37,10.41 164.94,10.41 163.82,9.28 JKBBL.13
KB_LED_G5_DRV#: length 310.7
  TOP w0.102: v2(74.23,17.59) v1(75.92,17.59) ; UE8.20 v2(307.22,41.05)
  IN2 w0.102: v2(311.35,24.78) 310.68,25.46 309.78,25.46 309.19,24.87 309.19,22.65 308,21.46 303.82,21.46 302,19.63 299.15,19.63 298.12,18.61 285.91,18.61 284.69,19.83 280.55,23.97 280.55,25.18 280.02,25.71 278.87,25.71 277.34,27.25 275.63,27.25 274.74,28.14 269.64,28.14 268.67,29.12 249.3,29.12 248.47,29.94 243.46,29.94 242.96,30.45 242.96,33.32 239.01,37.27 231.77,37.27 231.25,36.75 230.09,36.75 229.81,37.03 226.55,37.03 223.14,33.61 220.49,33.61 218.59,35.51 217.47,35.51 216.24,36.74 216.24,38.07 215.53,38.78 210.86,38.78 209.82,37.75 208.38,37.75 208.24,37.89 207.74,37.89 206.45,36.59 206.45,36.26 205.94,35.75 205.94,35.05 205.42,34.53 202.94,34.53 202.74,34.33 199.77,34.33 198.96,33.51 195.66,33.51 194.39,32.24 189.3,32.24 188.04,30.97 187.09,30.97 186.18,30.07 123.63,30.07 114.13,20.57 99.96,20.57 96.41,17.02 75.36,17.02 74.8,17.59 v2(74.23,17.59)
  IN3 w0.102: v2(311.35,24.78) 310.97,25.17 310.97,26.12 310.18,26.91 310.18,31.81 308.87,33.12 308.87,38.08 308.62,38.33 308.62,40.16 307.73,41.05 v2(307.22,41.05)
  BOTTOM w0.107: JKB3.3 63.93,5.97 64.28,6.32 72.75,6.32 74,7.57 74,9.93 74.53,10.46 74.53,17.29 v2(74.23,17.59)
KB_LED_R1_DRV#: length 27.9
  TOP w0.102: v2(167.27,9.05) 167.27,12.31 174.65,19.68 v1(179.27,19.68) 182.83,19.68 183.84,20.69 UE4.3
  BOTTOM w0.102: JKBBL.3 168.82,8.96 168.33,9.46 167.67,9.46 v2(167.27,9.05)
KB_LED_R2_DRV#: length 28.5
  TOP w0.102: v2(167.33,6.64) 167.58,6.38 168.49,6.38 168.79,6.68 168.79,10.21 168.79,10.22 168.79,12.84 174.75,18.79 183.06,18.79 v1(183.44,19.18) 183.72,19.46 184.54,19.46 184.81,19.19 UE4.6
  BOTTOM w0.102: v2(167.33,6.64) 167.32,6.63 JKBBL.6
KB_LED_R3_DRV#: length 29.4
  TOP w0.102: v2(169.93,9.62) v1(169.93,12.39) 169.93,12.72 175.33,18.11 183.68,18.11 185.17,16.62 186.45,16.62 186.6,16.77 UE4.10
  BOTTOM w0.102: JKBBL.9 165.82,9.32 166.45,9.95 169.6,9.95 v2(169.93,9.62)
KB_LED_R4_DRV#: length 36.8
  TOP w0.102: UE4.15 189.1,16.57 188.45,15.92 184.61,15.92 183.12,17.41 175.61,17.41 171.06,12.86 v1(171.06,6.8) 171.06,6.37 170.38,5.69 165.26,5.69 v2(164.32,6.64)
  BOTTOM w0.102: v2(164.32,6.64) JKBBL.12
KB_LED_R5_DRV#: length 302.8
  TOP w0.102: v1(307.62,40.11) v2(307.62,39.59) 307.72,39.5 UE8.19
  IN2 w0.102: v2(73.81,17.18) 74.2,16.8 96.5,16.8 100.05,20.34 116.12,20.34 125.62,29.84 186.28,29.84 187.18,30.74 188.13,30.74 189.4,32.01 194.48,32.01 195.14,32.67 198.38,32.67 199.85,34.14 202.82,34.14 203.02,34.34 205.49,34.34 206.13,34.97 206.13,35.67 206.77,36.31 207.78,36.31 209.03,37.56 209.03,37.55 209.9,37.55 210.29,37.95 213.77,37.95 216.96,34.76 217.15,34.76 217.2,34.71 219.06,34.71 220.39,33.38 223.23,33.38 226.65,36.8 229.71,36.8 229.99,36.52 231.34,36.52 231.86,37.04 238.91,37.04 242.73,33.22 242.73,30.35 243.37,29.71 248.38,29.71 249.2,28.89 268.57,28.89 269.55,27.91 274.65,27.91 275.54,27.02 277.18,27.02 284.14,20.06 285.82,18.38 298.21,18.38 299.24,19.41 302.09,19.41 303.91,21.23 308.09,21.23 309.42,22.55 309.42,24.77 309.88,25.23 310.3,25.23 v2(310.74,24.78)
  IN3 w0.102: v2(307.62,39.59) 307.72,39.5 307.72,32.61 308.68,31.65 308.68,27.84 310.74,25.78 v2(310.74,24.78)
  BOTTOM w0.107: v2(73.81,17.18) 74.26,16.74 74.26,10.57 73.76,10.08 73.76,7.67 72.75,6.66 63.81,6.66 63.43,7.04 JKB3.4
KB_RST#: length 130.5
  TOP w0.089: v2(212.35,30.89) 211.42,31.83 v1(210.05,31.83) 209,31.83 RH518.1
  TOP w0.102: v2(302.4,15.54) 302.09,15.85 302.09,16.74 302.03,16.8 302.03,17.54 302.39,17.89 303.19,17.89 303.69,18.39 303.69,20.35 305.99,22.65 305.99,24.4 306.27,24.68 306.27,26.09 305.94,26.42 RE646.1
  IN2 w0.102: v2(212.35,30.89) 212.99,31.53 214.45,31.53 214.86,31.11 214.86,31.11 215.24,30.73 215.63,30.73 215.97,30.39 218.07,30.39 218.68,29.78 219.45,29.78 219.96,29.26 221.74,29.26 224.99,26.01 224.99,24.84 225.23,24.59 225.23,22.84 225.47,22.61 226.11,22.61 227.25,21.46 227.25,19.49 227.81,18.93 228.33,18.93 229.44,17.82 234.56,17.82 235.54,16.84 245.14,16.84 246.44,18.14 246.44,19.75 245.94,20.24 245.94,22.7 247.96,24.71 256.23,24.71 257.17,23.77 257.17,23.26 259.75,20.68 268.15,20.68 269.24,19.59 271.48,19.59 271.81,19.26 275.53,19.26 279.91,14.88 294.97,14.88 295.18,15.09 296.1,15.09 296.66,14.54 301.39,14.54 v2(302.4,15.54)
  BOTTOM w0.089: UH1.AT17 212.22,31.02 v2(212.35,30.89)
KSI0: length 203.2
  TOP w0.102: v2(280.02,36.77) 280.02,34.08 279.81,33.86 279.81,32.63 280.51,31.93 280.51,30.42 281.3,29.64 281.3,19.47 283.79,16.99 283.79,16.63 286.66,13.76 v1(288.6,13.76) 290.03,13.76 290.37,13.41 UE5.55
  TOP w0.107: RE630.1 v2(143.26,9.86)
  IN1 w0.102: v2(280.02,36.77) 279.62,37.18 279.27,37.18 278.65,36.56 273.94,36.56 266.27,44.23 250.56,44.23 247.56,41.23 245.34,41.23 243.62,39.5 240.26,39.5 236.89,36.13 236.89,32.73 235.35,31.19 235.35,29.9 235.24,29.79 234.22,29.79 232.65,31.36 v2(228.99,31.36)
  IN4 w0.089: 197.77,16.4 199.01,15.16 199.05,15.16
  IN4 w0.102: v2(143.26,9.86) 149.57,16.16 173.15,16.16 175.69,13.62 180.67,13.62 183.51,16.47 193.58,16.47 193.97,16.07 195.94,16.07 196.27,16.4 197.77,16.4 ; 199.05,15.16 199.51,14.7 205.18,14.7 205.45,14.97 207.25,14.97 209.42,12.8 218.3,12.8 220,14.5 220,17.14 223.17,20.31 223.17,22.05 225.78,24.66 226.57,24.66 227.92,26.01 227.92,28.18 228.38,28.63 228.38,30.75 v2(228.99,31.36)
  BOTTOM w0.102: RE469.2 228.04,32.78 QE42.3 228.24,31.92 228.8,31.36 v2(228.99,31.36)
KSI0_R: length 8
  TOP w0.102: v2(141.47,7.5) 141.45,7.5 140.41,6.46 v1(140.41,6.03)
  TOP w0.107: v2(141.47,7.5) 142.47,8.5 RE630.2
  BOTTOM w0.107: JKB2.6 141.38,7.41 v2(141.47,7.5) 141.38,7.59 JKB2.5
KSI1: length 203.3
  TOP w0.102: v2(279.44,36.77) 279.79,36.42 279.79,34.17 279.58,33.96 279.58,32.53 280.28,31.83 280.28,30.33 281.07,29.54 281.07,19.38 283.56,16.89 283.56,16.53 286.67,13.42 290.04,13.42 290.44,13.01 UE5.56
  TOP w0.107: RE632.1 v2(144.53,9.86)
  IN1 w0.102: v2(228.99,30.77) 229.1,30.88 232.81,30.88 234.13,29.56 235.33,29.56 235.58,29.81 235.58,31.1 237.12,32.64 237.12,36.04 240.35,39.28 243.71,39.28 245.44,41 247.65,41 250.65,44 266.17,44 273.84,36.33 278.99,36.33 v2(279.44,36.77)
  IN4 w0.102: v2(144.53,9.86) 150.61,15.93 173.06,15.93 175.6,13.39 180.76,13.39 183.61,16.24 193.54,16.24 193.89,15.88 195.73,15.88 197.15,14.47 206.07,14.47 207.97,12.57 218.39,12.57 220.23,14.41 220.23,17.05 223.4,20.22 223.4,21.95 225.88,24.43 226.67,24.43 228.15,25.91 228.15,28.08 228.61,28.54 228.61,30.39 v2(228.99,30.77)
  BOTTOM w0.102: v1(229.98,34.03) RE470.2 229.98,32.71 229.42,32.15 229.42,31.2 v2(228.99,30.77) 229.13,30.62 QE42.6
KSI1_R: length 5.9
  TOP w0.102: v1(142.95,7.27) 143.24,7.27 v2(143.47,7.5)
  TOP w0.107: v2(143.47,7.5) 143.85,7.87 143.91,7.87 RE632.2
  BOTTOM w0.107: JKB2.9 143.38,7.59 v2(143.47,7.5) 143.38,7.41 JKB2.10
KSI2: length 197.4
  TOP w0.102: UE5.57 290.51,12.61 289.94,13.18 286.58,13.18 283.33,16.43 283.33,16.8 280.83,19.29 280.83,29.44 280.05,30.23 280.05,31.73 279.35,32.43 279.35,34.82 v2(279.38,34.85) ; v1(145.61,10.33) 145.87,10.08 v2(145.87,9.86)
  TOP w0.107: RE634.1 v2(145.87,9.86)
  IN1 w0.102: v2(229.02,28.23) 232.81,28.23 234.51,26.52 235.09,26.52 237.8,29.24 237.8,32.94 241.71,36.85 244.47,36.85 245.5,37.87 245.5,39.21 246.6,40.32 247.94,40.32 250.94,43.31 265.89,43.31 273.56,35.64 278.59,35.64 v2(279.38,34.85)
  IN4 w0.102: v2(145.87,9.86) 146.46,10.45 148.03,10.45 153.29,15.7 172.96,15.7 175.5,13.16 180.86,13.16 183.7,16.01 193.49,16.01 193.85,15.65 195.64,15.65 197.05,14.24 205.97,14.24 207.87,12.34 218.62,12.34 220.52,14.24 220.52,17.01 223.63,20.12 223.63,21.86 225.97,24.2 226.76,24.2 228.38,25.82 228.38,27.59 v2(229.02,28.23)
  BOTTOM w0.102: v2(229.02,28.23) 228.56,28.69 QE41.3 228.04,29.14 228.13,29.23 RE464.2
KSI2_R: length 5.7
  TOP w0.102: v1(146.06,7.19) 145.87,7.38 145.59,7.38 v2(145.47,7.5)
  TOP w0.107: RE634.2 145.87,7.9 v2(145.47,7.5)
  BOTTOM w0.107: JKB2.13 145.38,7.59 v2(145.47,7.5) 145.38,7.41 JKB2.14
KSI3: length 198.2
  TOP w0.102: v2(146.5,9.86) 147.09,9.86 v1(147.41,10.17) ; UE5.58 290.58,12.21 289.85,12.95 286.48,12.95 283.1,16.33 283.1,16.7 280.6,19.2 280.6,29.34 278.75,31.2 v2(278.75,34.85)
  TOP w0.107: RE635.1 v2(146.5,9.86)
  IN1 w0.102: v2(278.75,34.85) 278.18,35.41 273.46,35.41 265.79,43.09 251.03,43.09 248.04,40.09 246.7,40.09 245.73,39.11 245.73,37.78 244.57,36.62 243.34,36.62 241.32,34.6 241.32,31.66 241.12,31.45 238.99,31.45 238.03,30.49 238.03,29.14 235.18,26.3 234.42,26.3 233.07,27.64 v2(229.02,27.64)
  IN4 w0.102: v2(229.02,27.64) 228.61,27.24 228.61,25.72 226.86,23.97 226.07,23.97 224.71,22.61 224.71,20.87 220.75,16.91 220.75,14.14 218.71,12.11 207.78,12.11 205.88,14.01 196.96,14.01 195.54,15.42 193.81,15.42 193.45,15.78 183.8,15.78 180.95,12.94 175.41,12.94 172.87,15.48 153.38,15.48 147.76,9.86 v2(146.5,9.86)
  BOTTOM w0.102: QE41.6 229.27,27.39 v2(229.02,27.64) 229.42,28.05 229.42,28.98 229.98,29.53 RE463.2
KSI3_R: length 6
  TOP w0.102: v2(146.47,7.5) 146.5,7.53 RE635.2 147.44,8.5 v1(147.61,8.34)
  BOTTOM w0.107: JKB2.15 146.38,7.59 v2(146.47,7.5) 146.38,7.41 JKB2.16
KSI4: length 209
  TOP w0.107: RE633.1 v2(145.17,9.86) ; UE5.59 290.47,11.81 290.19,12.1 v1(289.56,12.1) 289.49,12.1 289.18,11.78 v2(289.18,11.65)
  IN1 w0.102: v2(229.02,24.99) 232.74,24.99 234.42,23.31 235.21,23.31 235.4,23.5 235.4,23.79 238.72,27.11 238.72,30.21 239.28,30.77 241.4,30.77 243.24,32.6 243.24,33.27 244.8,34.83 244.8,35.88 246.89,37.97 248.36,37.97 249.44,39.04 249.44,40.52 251.32,42.4 265.51,42.4 273.18,34.73 277.47,34.73 278.21,33.99 284.35,33.99 284.83,34.47 285.18,34.47 v2(285.63,34.02)
  IN4 w0.102: v2(229.02,24.99) 228.23,24.99 226.05,22.8 225.75,22.8 224.94,21.99 224.94,20.78 223.05,18.89 223.05,16.12 218.81,11.88 207.68,11.88 205.78,13.78 196.86,13.78 195.45,15.2 193.71,15.2 193.36,15.55 183.89,15.55 181.05,12.71 175.31,12.71 172.77,15.25 153.48,15.25 147.68,9.45 145.58,9.45 v2(145.17,9.86)
  BOTTOM w0.102: v2(229.02,24.99) 228.56,25.45 QE40.3 228.04,25.88 228.13,25.97 RE459.2
  BOTTOM w0.107: v2(285.63,34.02) 285.5,33.9 285.5,32.23 286.21,31.52 286.21,31.41 287.78,29.84 288.38,29.84 291.09,27.14 291.09,12.35 289.94,11.21 289.63,11.21 289.19,11.65 v2(289.18,11.65) 288.76,11.65 287.31,10.21 285.38,10.21 285.11,9.94 JEC.4
KSI4_R: length 6.2
  TOP w0.102: v1(144.47,6.38) v2(144.47,7.5)
  TOP w0.107: v2(144.47,7.5) 145.17,8.2 RE633.2
  BOTTOM w0.107: JKB2.11 144.38,7.59 v2(144.47,7.5) 144.38,7.41 JKB2.12
KSI5: length 209.2
  TOP w0.102: v1(143.72,10.37) 143.9,10.19 v2(143.9,9.86)
  TOP w0.107: RE631.1 v2(143.9,9.86) ; UE5.60 290.47,11.41 290.23,11.65 v2(289.81,11.65)
  IN1 w0.102: v2(285,34.02) 284.73,33.76 278.11,33.76 277.37,34.5 273.09,34.5 265.41,42.17 251.42,42.17 249.67,40.42 249.67,38.25 245.58,34.17 244.46,34.17 243.47,33.17 243.47,32.51 241.5,30.54 239.37,30.54 238.95,30.11 238.95,27.01 235.63,23.7 235.63,23.41 235.31,23.08 234.32,23.08 233,24.4 v2(229.02,24.4)
  IN4 w0.102: v2(143.9,9.86) 144.53,9.22 147.78,9.22 153.57,15.02 172.68,15.02 175.22,12.48 181.14,12.48 183.99,15.32 192.08,15.32 194.09,13.32 196.3,13.32 196.54,13.55 205.69,13.55 207.59,11.65 218.9,11.65 223.27,16.02 223.27,18.8 225.16,20.68 225.16,21.89 225.84,22.57 226.14,22.57 227.97,24.4 v2(229.02,24.4)
  BOTTOM w0.102: RE457.2 229.98,26.26 229.42,25.7 229.42,24.81 v2(229.02,24.4) 229.27,24.15 QE40.6
  BOTTOM w0.107: v2(285,34.02) 285,32.39 285.97,31.42 285.97,31.09 290.85,26.22 290.85,12.69 v2(289.81,11.65) 289.4,12.06 288.83,12.06 287.22,10.44 JEC.5
KSI5_R: length 7.6
  TOP w0.102: v1(142.12,5.75) 142.12,7.15 v2(142.47,7.5)
  TOP w0.107: RE631.2 143.37,7.97 142.94,7.97 v2(142.47,7.5)
  BOTTOM w0.107: JKB2.7 142.38,7.59 v2(142.47,7.5) 142.38,7.41 JKB2.8
KSI6: length 112.4
  TOP w0.102: v2(286.99,32.35) v1(286.99,33.16)
  TOP w0.107: UE5.61 290.26,11.01 290.06,11.21 289.61,11.21 v2(289.17,10.76)
  IN1 w0.102: v2(286.99,32.35) 286.59,32.76 285.72,32.76 285.35,32.39 280.04,32.39 279.59,32.85 273.45,32.85 265.04,41.25 251.79,41.25 250.59,40.05 250.59,33.83 247.75,30.98 243.24,30.98 243,30.74 243,28.46 235.85,21.32 233.87,21.32 233.43,21.75 v2(229.02,21.75)
  BOTTOM w0.102: RE452.2 228.13,22.66 228.04,22.58 QE39.3 228.56,22.21 v2(229.02,21.75)
  BOTTOM w0.107: JEC.2 285.24,8.94 286.01,9.72 287.48,9.72 288.53,10.76 v2(289.17,10.76) 289.58,10.35 290.1,10.35 291.55,11.81 291.55,27.79 288.94,30.41 288.43,30.41 286.99,31.85 v2(286.99,32.35)
KSI7: length 100.7
  TOP w0.102: v2(286.41,32.35) v1(286.41,31.33)
  TOP w0.107: v2(289.82,10.76) 289.97,10.61 UE5.62
  IN1 w0.102: v2(229.02,21.16) 229.37,21.52 233.34,21.52 233.77,21.09 235.95,21.09 244.9,30.04 255.63,30.04 256.85,31.26 263.96,31.26 264.55,31.85 264.55,32.34 264.65,32.44 264.65,32.46 265.31,33.12 272.3,33.12 272.8,32.61 279.5,32.61 279.95,32.16 286.22,32.16 v2(286.41,32.35)
  BOTTOM w0.102: QE39.6 229.27,20.91 v2(229.02,21.16) 229.42,21.57 229.42,22.46 229.98,23.02 RE451.2 ; v2(286.41,32.35) 286.5,32.27 286.5,31.59 287.91,30.17 288.38,30.17
  BOTTOM w0.107: 288.38,30.17 291.32,27.24 291.32,12.06 290.03,10.76 v2(289.82,10.76) 289.75,10.76 289.34,11.17 288.61,11.17 287.41,9.97 285.63,9.97 285.1,9.44 JEC.3
KSI8: length 82.3
  TOP w0.102: UE5.47 290.5,16.61 290.33,16.44 288.6,16.44 283.95,21.09 283.52,21.09 283.16,21.45 283.16,22.33 283.31,22.47 v1(283.31,23.18) 283.31,23.3 283.16,23.45 283.16,32.6 v2(282.96,32.8)
  IN3 w0.102: v2(282.96,32.8) 282.56,33.2 277.86,33.2 277.06,34.01 273.47,34.01 265.17,42.31 251.23,42.31 249.06,40.13 249.06,38.83 246.39,36.16 245.46,36.16 244.67,35.38 244.67,34.43 243.47,33.23 243.47,32.93 241.9,31.36 238.89,31.36 238.83,31.3 235.11,31.3 v2(234.95,31.46)
  BOTTOM w0.102: v2(234.95,31.46) 234.49,31.92 QE29.3 233.95,32.35 234.03,32.44 RE398.2
KSI9: length 83.4
  TOP w0.102: UE5.48 288.36,16.21 v1(287.81,16.76) 283.71,20.86 283.42,20.86 282.93,21.35 282.93,32.25 v2(282.38,32.8)
  IN3 w0.102: v2(234.95,30.88) 235.14,31.07 238.92,31.07 238.99,31.13 242,31.13 243.7,32.83 243.7,33.08 244.93,34.31 245.72,34.31 249.28,37.87 249.28,40.04 251.33,42.08 265.07,42.08 273.37,33.78 275.01,33.78 276.4,32.39 281.97,32.39 v2(282.38,32.8)
  BOTTOM w0.102: QE29.6 235.2,30.62 v2(234.95,30.88) 235.34,31.27 235.34,31.28 235.36,31.3 235.36,32.18 235.89,32.71 RE400.2
KSI10: length 86.7
  TOP w0.102: v2(281.63,35.27) 281.92,34.99 281.92,31.3 282.7,30.51 282.7,21.26 283.59,20.37 v1(283.73,20.37) 288.29,15.81 UE5.49
  IN1 w0.102: v2(281.63,35.27) 280.81,36.1 273.75,36.1 266.08,43.77 250.75,43.77 247.75,40.77 245.53,40.77 243.63,38.87 243.63,38.37 243.71,38.29 243.71,37.46 243.56,37.31 241.52,37.31 237.35,33.13 237.35,32.54 235.81,31.01 235.81,29.09 v2(234.95,28.23)
  BOTTOM w0.102: v2(234.95,28.23) 234.49,28.69 QE43.3 233.95,29.12 234.03,29.2 RE475.2
KSI11: length 88.5
  TOP w0.102: UE5.50 v1(289.23,15.41) 288.22,15.41 285.39,18.25 285.38,18.25 282.47,21.17 282.47,30.41 281.68,31.2 281.68,34.61 v2(281.02,35.27)
  IN1 w0.102: v2(234.95,27.64) 235.3,28 235.88,28 237.58,29.7 237.58,33.03 241.62,37.08 244.03,37.08 244.58,37.63 244.58,39.25 245.88,40.55 247.85,40.55 250.84,43.54 265.98,43.54 273.65,35.87 280.42,35.87 v2(281.02,35.27)
  BOTTOM w0.102: RE477.2 235.89,29.47 235.36,28.94 235.36,28.06 235.34,28.04 235.34,28.04 v2(234.95,27.64) 235.2,27.39 QE43.6
KSI12: length 89.8
  TOP w0.102: UE5.51 286.85,15.01 v1(285.57,16.29) 285.56,16.3 285.42,16.3 284.72,17 284.72,17.78 282.24,20.26 282.24,30.32 281.45,31.11 281.45,34.23 v2(280.43,35.25)
  IN1 w0.102: v2(234.95,24.99) 235.66,25.7 235.66,26.45 238.26,29.05 238.26,30.4 239.09,31.22 241.21,31.22 241.55,31.56 241.55,33.32 243.59,35.36 243.59,36 243.98,36.39 244.66,36.39 246.71,38.43 246.71,39.48 247.09,39.86 248.13,39.86 251.13,42.86 265.7,42.86 273.37,35.19 277.66,35.19 278.4,34.45 279.63,34.45 v2(280.43,35.25)
  BOTTOM w0.102: RE481.2 234.03,25.97 233.95,25.88 QE44.3 234.49,25.45 v2(234.95,24.99)
KSI13: length 91.5
  TOP w0.102: UE5.52 290.42,14.61 290.35,14.68 v1(287.05,14.68) 286.71,14.68 284.49,16.91 284.49,17.69 282,20.17 282,30.22 281.21,31.01 281.21,33.85 v2(280.45,34.62)
  IN1 w0.102: v2(234.95,24.4) 235.69,24.4 238.49,27.2 238.49,30.3 239.18,30.99 241.31,30.99 241.78,31.47 241.78,33.22 243.82,35.27 243.82,35.91 244.08,36.16 244.76,36.16 246.79,38.2 248.26,38.2 249.21,39.14 249.21,40.61 251.23,42.63 265.6,42.63 273.27,34.96 277.56,34.96 278.3,34.22 280.05,34.22 v2(280.45,34.62)
  BOTTOM w0.102: RE483.2 235.89,26.23 235.36,25.7 235.36,24.82 235.34,24.8 235.34,24.8 v2(234.95,24.4) 235.2,24.15 QE44.6
KSI14: length 89.3
  TOP w0.102: v2(280.81,32.8) 280.98,32.62 280.98,30.91 281.77,30.12 281.77,19.94 v1(283.37,18.34) 284.26,17.45 284.26,16.81 286.72,14.35 290.3,14.35 290.44,14.21 UE5.53
  IN1 w0.102: v2(280.81,32.8) 280.3,33.3 277.92,33.3 277.18,34.04 272.9,34.04 265.23,41.71 251.6,41.71 250.14,40.24 250.14,38.08 245.75,33.7 245.75,32.29 245.31,31.85 243.45,31.85 242.54,30.93 242.54,28.65 236.08,22.19 235.03,22.19 v2(234.58,21.75)
  BOTTOM w0.102: RE487.2 234.03,22.66 233.95,22.58 QE45.3 234.37,22.21 234.58,22 v2(234.58,21.75)
KSI15: length 89.7
  TOP w0.102: UE5.54 290.3,13.81 289.99,14.12 286.62,14.12 284.01,16.74 284.01,17.23 v1(281.79,19.45) 281.53,19.71 281.53,30.03 280.75,30.81 280.75,32.27 v2(280.22,32.8)
  IN1 w0.102: v2(280.22,32.8) 279.94,33.07 277.83,33.07 277.09,33.81 272.8,33.81 265.13,41.48 251.7,41.48 250.36,40.15 250.36,37.98 245.98,33.6 245.98,32.2 245.4,31.62 243.55,31.62 242.77,30.84 242.77,28.56 235.96,21.75 v2(235.18,21.75)
  BOTTOM w0.102: RE489.2 235.89,22.99 235.18,22.29 v2(235.18,21.75) 235.18,21.01 235.28,20.91 QE45.6
KSI16: length 83
  TOP w0.102: UE5.45 290.66,17.41 290.14,16.9 289.07,16.9 v1(285.58,20.4) 284.36,21.61 284.36,23.03 283.64,23.75 283.64,33.1 283.09,33.64 283.09,35.14 v2(281.46,36.77)
  TOP w0.107: v2(235.89,33.43) RE493.2 235.89,32.4 235.85,32.36 QE46.3
  IN3 w0.102: v2(281.46,36.77) 281.04,36.35 279.73,36.35 278.65,35.28 273.99,35.28 265.69,43.58 249.89,43.58 246.61,40.3 246.61,38.18 245.86,37.43 238.66,37.43 235.89,34.66 v2(235.89,33.43)
KSI17: length 85.9
  TOP w0.102: UE5.46 290.58,17.01 290.24,16.67 288.83,16.67 v1(286.58,18.92) 284.13,21.37 284.13,22.93 283.4,23.66 283.4,33 282.15,34.26 282.15,35.33 280.81,36.68 v2(280.81,36.77)
  TOP w0.107: QE46.6 234.32,30.62 234.51,30.81 234.51,31.62 v2(234.95,32.05) 234.83,32.16 234.45,32.16 234.03,32.58 RE494.2
  IN1 w0.102: v2(234.95,32.05) 235.35,32.46 235.35,34.92 240.16,39.73 243.52,39.73 245.25,41.46 247.47,41.46 250.46,44.46 268.02,44.46 273.69,38.79 279.71,38.79 280.81,37.69 v2(280.81,36.77)
