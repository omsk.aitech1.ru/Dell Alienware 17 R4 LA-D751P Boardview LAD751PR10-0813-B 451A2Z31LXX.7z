# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N32424758: length 1.3
  TOP w0.102: v2(241.12,43.47) v1(241.12,44.04)
  TOP w0.254: PC803.1 241.31,43.28 v2(241.12,43.47)
N32424883: length 1.7
  BOTTOM w0.102: v1(249.88,40.75) 248.88,41.75 PR806.2
N32424887:
  vias: v1(244.74,41.75)
N32425629: length 1.3
  BOTTOM w0.102: PC807.1 v1(122.61,112.16)
N32425635: length 13.8
  TOP w0.254: v2(123.95,115.74) 123.95,118.96 124.54,119.55 124.54,121.56 123.95,122.15 123.95,122.9 123.38,123.48 v1(121.99,123.48) v2(121.26,123.48)
  BOTTOM w0.254: PR5015.1 121.17,121.97 PR5012.2 121.22,122.01 PC818.2 121.22,123.43 v2(121.26,123.48) ; PU509.14 123.84,115.85 123.95,115.74 v2(123.95,115.74)
N32425773: length 2.1
  BOTTOM w0.254: PR5012.1 121.2,121.07 PR5014.2 122.16,121.13 PR5017.1
N32425904: length 2.6
  BOTTOM w0.254: PU509.13 124.08,116.3 PR5034.2 PR5033.1
N32426094: length 4.7
  BOTTOM w0.102: PR5008.1 124.58,119.33 v1(124.99,119.74)
  BOTTOM w0.254: PR5008.1 124.58,118.59 PC590.1 PR5007.2 124.19,117.2 PU509.11
N32426131: length 1.3
  BOTTOM w0.102: v1(117.83,112.24) 118.31,112.72 PR5010.2
N32548345: length 110.7
  TOP w0.089: 215.02,120.26 v1(215.6,120.26) 216.43,119.44 216.43,117.58 217.29,116.72 v2(218.27,116.72)
  TOP w0.102: v2(197.95,117.75) 199.27,117.75 204.16,122.64 208.1,122.64 208.81,121.93 211.71,121.93 213.37,120.26 215.02,120.26
  TOP w0.254: UG29.4 280.42,141.94 280.93,141.43 v2(281.22,141.43)
  IN4 w0.089: v2(218.27,116.72) 218.27,117.09 218.67,117.49 221.5,117.49 222.75,116.24 225.19,116.24 225.69,116.75 228.18,116.75 229.51,118.07 229.51,119.79 228.9,120.4 228.9,120.56
  IN4 w0.102: v2(281.22,141.43) 280.36,141.43 279.74,140.81 279.74,135.58 279.05,134.89 279.05,130.67 276.96,128.58 265.17,128.58 262.41,125.83 239.66,125.83 236.53,122.69 230.06,122.69 228.9,121.53 228.9,120.56
  BOTTOM w0.102: v2(197.95,117.75) 197.9,117.8 RG1.2
N32794300: length 2.4
  TOP w0.102: v2(226.07,152.11) 226.07,152.28 v1(226.45,152.66)
  TOP w0.254: PR6202.1 225.98,152.03 v2(226.07,152.11)
  BOTTOM w0.305: PU6200.2 226.22,151.97 v2(226.07,152.11)
N32795713: length 3.5
  BOTTOM w0.254: PC6203.1 223.47,148.2 223.27,148.39 PR6204.2 223.83,149.5 PU6200.24
N32805176: length 14.2
  TOP w0.254: v2(281.19,140.05) 282.72,141.59 282.72,144.76 282.03,145.46 v1(281.58,145.46) 279.76,145.46 279.49,145.18 v2(279.49,145.02)
  BOTTOM w0.254: PC6015.1 v2(281.19,140.05) PR6063.2 ; v2(279.49,145.02) 279.49,144.75 279.09,144.35 PR6040.2 279.92,143.43 279.92,142.18 279.65,141.92 PR6045.2
N32805666: length 3.2
  BOTTOM w0.203: PU6000.25 271.79,138.07 v1(271.62,137.9) 271.31,137.9 271.04,137.64 PC6001.1
  BOTTOM w0.254: PR6007.2 270.67,137.65 PC6001.1
N32805668: length 2.1
  BOTTOM w0.102: PR6005.2 268.25,138.55 v1(267.86,138.17)
  BOTTOM w0.254: PR6005.2 269.74,138.55 PR6007.1
N32805796: length 4.8
  BOTTOM w0.254: PR6022.2 269.04,144.82 268.79,144.57 v1(268.79,144.56) 268.79,143.93 PR6019.1 PC6007.1 PC6005.1
N32805986: length 1.8
  BOTTOM w0.254: PC6017.2 PR6018.1 PR6016.1
N32806265: length 5.7
  BOTTOM w0.203: PR6024.1 271.92,143.53 271.92,142.84 v1(272.42,142.34) 273.61,141.15 PU6000.31
  BOTTOM w0.254: PR6022.1 PC6011.2 PR6024.1
N32806285: length 47.4
  TOP w0.203: v2(247.99,123.53) v1(247.99,122.85) PR6021.1 PR6023.1
  IN2 w0.254: v2(247.99,123.53) 258.25,123.53 259.22,124.5 262.22,124.5 263.8,126.08 263.8,126.65 264.38,127.22 264.99,127.22 269.57,131.79 269.57,139.86 v2(271.64,141.93)
  IN6 w0.254: v2(273.31,145.64) 271.79,144.11 271.79,142.08 v2(271.64,141.93)
  BOTTOM w0.254: PR6068.1 271.53,145.43 PR6024.2 PC6009.1 PC6010.2 v2(273.31,145.64)
N32806326: length 3.1
  BOTTOM w0.102: PC6005.2 268.4,141.65 268.4,142.93 v1(268.55,143.08)
  BOTTOM w0.254: PC6005.2 269.72,141.17 PR6017.2
N32806527: length 1.8
  TOP w0.102: v2(281.19,139.15) 281.66,139.15 v1(281.69,139.11)
  BOTTOM w0.254: PR6038.2 281.21,139.12 v2(281.19,139.15) PR6031.2
N32806709: length 3
  BOTTOM w0.102: PR6015.1 267.29,139.38 v1(266.63,138.72)
  BOTTOM w0.254: PR6015.1 267.86,139.73 268.21,139.39 PR6016.2
N32856423: length 0.9
  BOTTOM w0.102: v2(227.96,152.1) 227.96,152.81 v1(228.1,152.95)
N32856454: length 0.8
  TOP w0.102: v2(228.6,152.08) 228.6,152.05 228.72,151.93 v1(228.72,151.37)
N32856474: length 1.3
  TOP w0.102: PC6202.1 229.8,154.15 v1(229.96,154.3)
N32858912: length 1.7
  BOTTOM w0.305: PR6201.1 224.37,150.5 PU6200.26
N32868572: length 2.8
  BOTTOM w0.254: PC6216.1 PR6211.2 209.79,149.19 210.09,149.5 210.59,149.5
  BOTTOM w0.305: 210.59,149.5 PU6201.24
N32868706: length 2.3
  BOTTOM w0.305: PU6201.26 211.31,151.32 210.97,151.67 210.55,151.67 210.42,151.54 PR6208.1
N32868738: length 2.1
  BOTTOM w0.305: PR6209.1 211.65,152.93 212.49,152.09 212.49,151.77 212.56,151.69 PU6201.2
N32872459: length 1.4
  TOP w0.102: PR6114.2 241.14,152.86 v1(240.19,153.82)
  vias: v2(241.43,152.11)
N32872467: length 1
  TOP w0.102: v1(242.66,151.39) 242.39,151.66 242.39,151.76 v2(242.02,152.13)
N32872469: length 1.6
  TOP w0.102: PC6115.1 243.21,154.27 v1(243.71,154.77)
N32872562: length 3.6
  TOP w0.102: v1(238.26,149.43) 238.06,149.64 v2(237.75,149.64)
  TOP w0.254: PC6116.1 PR6113.2 237.24,150.15 v2(237.75,149.64)
  BOTTOM w0.305: PU6101.24 237.83,149.56 v2(237.75,149.64)
N32872704: length 3
  BOTTOM w0.102: PR6110.1 236.97,150.42 v1(236.97,149.38)
  BOTTOM w0.305: PU6101.26 238.03,150.56 237.77,150.83 PR6110.1
N32872742: length 2.4
  TOP w0.254: v2(239.78,152.18) 239.68,152.08 PR6111.1
  BOTTOM w0.102: v2(239.78,152.18) v1(239.78,153)
  BOTTOM w0.305: v2(239.78,152.18) 239.78,152.11 239.93,151.97 PU6101.2
N32872879: length 0.8
  BOTTOM w0.102: v2(255.21,152.18) v1(255.21,152.96)
N32872885: length 0.9
  TOP w0.102: v2(255.81,152.19) 256.33,151.68 v1(256.33,151.54)
N32873027: length 3.7
  TOP w0.127: v1(252.12,149.37) 251.79,149.7 v2(251.53,149.7)
  TOP w0.254: v2(251.53,149.7) 251.02,150.21 PR6106.2 PC6103.1
  BOTTOM w0.305: v2(251.53,149.7) 251.61,149.63 PU6100.24
N32873161: length 2.7
  BOTTOM w0.102: v1(250.8,149.77) 251.15,150.12 PR6103.1
  BOTTOM w0.305: PU6100.26 251.7,150.63 251.43,150.9 PR6103.1
N32873197: length 2.4
  TOP w0.254: PR6104.1 253.49,152.02 v2(253.71,152.24)
  BOTTOM w0.102: v1(253.4,152.94) 253.69,152.65 253.69,152.26 v2(253.71,152.24)
  BOTTOM w0.305: v2(253.71,152.24) PU6100.2
N32889750: length 2.6
  BOTTOM w0.102: PR6061.1 281.81,141.81 v1(282.15,142.16)
  BOTTOM w0.254: PR6053.2 PR6061.1
N32890192: length 3.3
  TOP w0.102: v2(279.03,139.67) v1(279.7,139.67)
  TOP w0.254: v2(279.03,139.67) 278.64,139.29 PC6016.2
  BOTTOM w0.203: PR6063.1 279.27,139.67 v2(279.03,139.67) PU6000.2
N32892915: length 1.1
  TOP w0.203: PC6426.2 299.31,55.92 PR6411.1
N32894520: length 3.3
  TOP w0.203: PU6400.9 303.04,55.82 v1(302.46,56.41) 302.31,56.56 PR6419.2 302.27,57.35 PR6420.1
N33144860: length 2.8
  BOTTOM w0.102: v1(272.21,147.02) PR6068.2
  BOTTOM w0.254: PC6011.1 270.65,145.46 PR6068.2
N33334796: length 3.4
  TOP w0.102: v1(281.44,149.47) PR6069.2
  TOP w0.254: PR6069.2 279.64,149.47 279.23,149.88 PQ8203.5 PQ8203.6
N33344185: length 19.3
  TOP w0.254: PR215.1 104.99,50.25 104.66,49.92 102.32,49.92 101.58,50.65 101.58,50.79 PR213.1 101.14,50.73 101.14,49.27 v1(100.52,48.65) 97.47,48.65 94.9,46.08 v2(94.9,45.32)
  BOTTOM w0.203: PR207.1 95.02,45.43 v2(94.9,45.32) 94.9,45.05 94.65,44.8 PU201.6
  BOTTOM w0.254: PR207.1 PR205.1
N33410668: length 4.6
  TOP w0.102: v1(107.9,55.77) PC218.1
  TOP w0.254: PC218.1 107.27,54.03 PQ202.5 106.54,54.03 106.17,53.66 PR214.2
N33410683: length 3.3
  TOP w0.102: PR215.2 104.99,52.23 105.56,51.66 v1(105.56,50.31)
  TOP w0.254: PQ202.3 104.99,52.3 PR215.2
N33410698: length 4.6
  TOP w0.254: PR212.2 PC217.1 v1(103.17,53.18) 103.17,53.58 103.63,54.03 PQ202.2
N33410700: length 8.5
  TOP w0.254: PR213.2 101.39,54.13 v1(101.7,54.44) 102.29,55.04 104.5,55.04 104.64,55.18 106.64,55.18 106.89,54.92 PQ202.6
N33549118: length 2.2
  TOP w0.089: RG564.1 220.58,112.87 v1(221.02,112.43) v2(221.5,111.95)
  BOTTOM w0.1: v2(221.5,111.95) 221.5,111.82 UG9.BE5
N40259586: length 297
  TOP w0.102: v2(322.27,32.95) 322.27,32.37 v1(322.4,32.24) ; v2(318.4,53.37) RT108.1 RT109.2
  IN4 w0.102: v2(322.27,32.95) 321.78,33.45 292.8,33.45 291.13,35.12 282.74,35.12 281.45,33.83 278.41,33.83 277.58,34.65 272.93,34.65 265.86,41.73 259.6,41.73 259.02,42.3 249.16,42.3 246.94,40.08 239.69,40.08 239.16,39.55 238.72,39.55 237.05,41.22 234.07,41.22 233.43,40.57 230.47,40.57 229.46,39.55 226.12,39.55 222.64,43.03 218.02,43.03 217.5,42.51 214.68,42.51 213.6,43.6 211.54,43.6 210.4,44.74 203.51,44.74 201.31,46.94 201.31,50.06 201.85,50.6 201.85,59.26 200.77,60.34 200.77,62.6 197.93,65.44 190.58,65.44 188.74,67.28 188.74,67.96 188.2,68.51 188.2,72.72 187.78,73.15 187.78,80.47 188.71,81.4 188.71,93.19 187.49,94.41 187.49,96.51 186.88,97.12 186.88,98.27 187.07,98.46 187.07,109.04 193.33,115.3 193.33,121.03 196.02,123.72 196.02,124.59 196.74,125.31 196.74,129.26 198.07,130.58 198.07,139.57 197.03,140.6 197.03,146.35 193.54,149.84 193.54,151.94 192.16,153.32 192.16,157.63 194.19,159.66 196.13,159.66 197.39,160.92 198.41,160.92 198.78,160.55 199.8,160.55 v2(200.4,161.14)
  BOTTOM w0.089: UT4.D6 200.66,161.4 v2(200.4,161.14)
  BOTTOM w0.102: v2(322.27,32.95) 322.1,33.13 322.1,35.6 321.26,36.44 321.26,37.91 321.57,38.23 321.57,39.12 319.93,40.76 319.93,42.75 319.36,43.33 319.36,44.34 320.09,45.07 320.09,49.35 318.18,51.26 318.18,53.16 v2(318.4,53.37)
N41521526: length 7.4
  TOP w0.102: RE85.1 310.07,10.95 CE51.1 309.57,9.53 309.57,8.82 310.42,7.97 310.42,7.36 QE2.2 309.15,4.76 v1(309.1,4.71)
N46084233: length 5.8
  BOTTOM w0.102: RX2.1 231.25,164.98 v1(231.06,164.79) 230.46,164.19 228.54,164.19 228.43,164.29 QX2.2
N72585933: length 1.8
  TOP w0.102: PR202.2 v1(99.39,35.59)
N121507165: length 5.2
  TOP w0.089: v1(130.77,109.93) 131.08,110.23 v2(131.33,110.23)
  BOTTOM w0.076: RH57.2 129.87,108.62 130.43,109.18 130.43,109.73 130.93,110.24 131.32,110.24 v2(131.33,110.23) 131.7,110.23 132.13,110.66 132.61,110.66 CPU1.BR25
N121507167: length 4.3
  BOTTOM w0.076: RH58.2 130.88,111.38 133.27,111.38 133.59,111.06 CPU1.BP25
N121507169: length 5.2
  BOTTOM w0.076: CPU1.BT29 132.06,113.91 131.71,113.91 131.32,114.29 v1(130.91,114.29) 130.79,114.41 129.47,114.41
  BOTTOM w0.107: 129.47,114.41 128.47,114.41 128.01,114.88 RH166.2
N124752685: length 2.6
  TOP w0.127: v1(154.66,55.88) 155.34,55.2 CH101.2
  TOP w0.508: CH101.2 RH211.1
N124753277: length 2.2
  TOP w0.127: v1(154.44,36.24) RH212.1
  TOP w0.508: RH212.1 CH100.2
N125073340: length 2.8
  BOTTOM w0.102: T1.1 174.3,116.82 173.88,117.25 CPU1.A33
N198830997: length 3.5
  BOTTOM w0.102: UV21.48 201.52,135.42 RV23.2 203.21,137.12 v1(203.21,137.28)
N210149060: length 1.2
  BOTTOM w0.203: C2506.1 64.28,12.43 64.29,12.43 U17.12
N210149650: length 1.3
  BOTTOM w0.203: C2507.1 65.2,12.32 65.09,12.43 U17.10
N212152397: length 7.2
  TOP w0.254: PR2.2 294.86,39.06 295.28,38.64 295.28,37.37 v1(295.06,37.15) 294.84,36.93 293.76,36.93 293.44,36.61 v2(293.44,35.72)
  BOTTOM w0.254: JRTC1.1 292.69,36.47 v2(293.44,35.72)
N213961754: length 5.9
  TOP w0.254: PQ8.2 76.7,7.51 77.01,7.81 PR28.2 78.12,7.06 v1(78.24,7.06) 80.75,7.06 81.01,7.31 PC14.2
N321758540: length 4.1
  BOTTOM w0.076: 196.65,160.27 196.73,160.35 196.73,160.48 197.13,160.88 197.16,160.88 197.6,161.32 198.52,161.32 198.66,161.18 UT4.C2
  BOTTOM w0.089: 196.22,159.99 196.37,159.99 196.65,160.27
  BOTTOM w0.102: T65.1 195.91,159.77 196.12,159.99 196.22,159.99
N321758730: length 2.6
  TOP w0.102: T62.1 200.41,162.36 v2(199.14,162.36)
  BOTTOM w0.089: UT4.F4 199.35,162.57 v2(199.14,162.36)
N321759750: length 1.3
  TOP w0.102: T71.1 200.76,164.72 v2(200.76,164.08)
  BOTTOM w0.089: v2(200.76,164.08) 200.66,163.98 UT4.H6
N321761570: length 1.2
  TOP w0.102: T70.1 201.18,161.27 v2(200.98,161.07)
  BOTTOM w0.089: UT4.D7 201.16,161.25 v2(200.98,161.07)
N321762300: length 1.3
  TOP w0.102: v2(203.78,163.17) 203.78,163.29 T120.1
  BOTTOM w0.102: v2(203.78,163.17) 203.67,163.07 UT4.G11
N321762480: length 3
  BOTTOM w0.076: 197.25,159.68 197.25,160.43 197.46,160.64 197.51,160.64 197.69,160.82 198.51,160.82 198.66,160.67 UT4.B2
  BOTTOM w0.089: 197.25,159.68 T64.1
N321762710: length 1.3
  TOP w0.102: v2(199.14,162.94) 199.22,162.94 T63.1
  BOTTOM w0.089: UT4.G4 199.27,163.07 v2(199.14,162.94)
N321763770: length 2.2
  TOP w0.102: T114.1 203.91,162.16 203.91,161.7
  TOP w0.107: 203.91,161.7 v2(203.91,161.64)
  BOTTOM w0.076: UT4.D10 202.66,161.6 202.88,161.82 203.73,161.82
  BOTTOM w0.089: 203.73,161.82 203.78,161.77
  BOTTOM w0.102: 203.78,161.77 v2(203.91,161.64)
N321764100: length 2.2
  BOTTOM w0.076: UT4.E10 202.66,162.1 202.87,162.32 203.75,162.32 203.78,162.29
  BOTTOM w0.102: T121.1 204.29,162.29 203.78,162.29
N321764180: length 2.9
  BOTTOM w0.076: UT4.G10 202.66,163.12 202.85,163.32 203.34,163.32 203.61,163.59 203.78,163.59
  BOTTOM w0.102: T122.1 205.05,164.14 204.92,164.01
  BOTTOM w0.107: 204.92,164.01 204.52,163.62 203.81,163.62 203.78,163.59

## Copper pours and planes (outline as drawn)
1.2V_B+ on TOP (solid shape): 93.04,36.23 93.04,33.05 93.16,32.93 93.42,32.93 93.54,32.8 93.54,32.04 93.48,31.97 90.33,31.97 89.95,32.35 88.02,32.35 87.77,32.61 87.77,33.81 87.32,34.26 87.32,35.34 87.45,35.47 89.16,35.47 89.73,36.04 89.73,37.18 89.86,37.31 91.96,37.31
1V8_ENP on BOTTOM (solid shape): 228.52,39.65 228.52,39.48 227.27,38.23 223.78,38.23 223.73,38.28 223.73,38.82 223.76,38.85 226.77,38.85 227.64,39.72 228.45,39.72
3/5V_B+ on TOP (solid shape): 46.45,42.12 53.94,42.12 55.32,40.74 55.32,33.77 55.31,33.76 55.29,33.62 55.31,33.49 55.32,33.48 55.32,33.18 55.31,33.18 55.29,33.04 55.31,32.9 55.32,32.89 55.32,32.59 55.31,32.58 55.29,32.44 55.31,32.31 55.32,32.3 55.32,31.66 55.25,31.59 53.6,31.59 53.35,31.34 53.35,30.35 53.35,30.26 52.78,29.69 50.43,29.69 49.98,30.13 49.98,31.97 50.91,32.9 51.14,32.9 51.47,33.23 51.47,37.32 50.78,38.01 47.57,38.01 47.25,37.68 44.12,37.68 43.82,37.98 43.82,39.84 44.17,40.18 45.18,40.18 45.59,40.6 45.59,41.99 45.72,42.12 46.44,42.12
3/5V_B+ on BOTTOM (solid shape): 55.19,40.55 55.19,36.54 54.87,36.23 51,36.23 50.55,36.67 50.55,40.86 51.32,41.62 54.11,41.62
3VS on BOTTOM (solid shape): 70.31,15.22 70.31,14.74 69.76,14.74 69.76,14.19 70.31,14.19 70.31,13.94 69.76,13.94 69.76,13.39 70.31,13.39 70.31,11.23 69.97,10.89 66.99,10.89 66.47,11.41 65.9,11.41 65.69,11.61 65.69,12.18 65.39,12.49 65.39,13.38 65.45,13.44 66.02,13.44 66.28,13.7 66.28,14.4 66.42,14.54 68.19,14.54 68.97,15.31 70.22,15.31
5VS on BOTTOM (solid shape): 60.31,14.53 62.31,14.53 63.4,13.44 63.93,13.44 63.99,13.38 63.99,12.49 63.79,12.29 63.79,11.68 63.66,11.55 61.2,11.55 59.88,12.87 59.4,12.87 59.4,13.39 58.9,13.39 58.9,12.87 58.6,12.87 58.6,13.39 58.1,13.39 58.1,12.87 57.15,12.87 56.91,13.12 56.91,14.6 57.07,14.76 60.08,14.76
+0.6VS on TOP (solid shape): 179.9,52.48 179.9,50.51 179.43,50.04 179.43,47.88 179.08,47.53 178.44,47.53 178.06,47.91 178.06,50.51 178.25,50.71 178.51,50.71 178.7,50.9 178.7,52.42 178.95,52.67 179.71,52.67
+0.6VS on TOP (solid shape): 179.96,41.82 180.03,41.79 180.06,41.72 180.42,41.4 180.77,41.72 180.81,41.79 180.87,41.82 181.05,41.82 181.62,41.24 181.62,34.26 181.3,33.94 179.78,33.94 179.65,34.07 179.65,39.4 179.46,39.59 179.46,40.1 179.02,40.55 179.02,41.69 179.14,41.82
+0.6VS on BOTTOM (solid shape): 179.78,41.69 179.78,40.93 179.46,40.61 178.76,40.61 178.06,39.91 178.06,38.77 177.81,38.77 177.81,40.93 178.7,41.82 179.65,41.82
+0.6VS on BOTTOM (solid shape): 93.8,52.2 93.8,51.02 93.67,50.9 91.77,50.9 91.45,51.21 91.45,52.21 91.59,52.35 93.65,52.35
+0.6VS on BOTTOM (solid shape): 178.1,52.58 178.1,50.79 178.25,50.64 178.51,50.64 178.82,50.32 178.82,49.69 178.44,49.31 178.06,49.31 177.81,49.56 177.81,52.6 177.9,52.69 178,52.69
+0.6VS on IN2 (solid shape): 94.28,52.63 94.28,51.6 93.51,50.83 91.51,50.83 91.19,51.15 91.19,52.93 91.66,53.4 93.52,53.4
+0.6VS on IN2 (solid shape): 179.15,51.86 179.15,49.65 178.72,49.22 177.88,49.22 177.6,49.51 177.6,50.33 177.61,50.42 177.6,50.5 177.6,51.87 177.73,52 179.01,52
+0.6VS on IN6 (solid shape): outline of 305 points within 175.78,39.85 179.78,51.09
+0.6VSP on BOTTOM (solid shape): 92.88,50.2 93.32,50.2 93.32,50.73 93.77,50.73 93.86,50.64 93.86,49.18 93.29,48.61 92.21,48.61 91.83,48.23 91.83,46.64 91.95,46.52 91.95,46.51 92.4,46.06 92.4,45.17 92.34,45.1 92.25,45.1 92.19,45.16 92.19,45.95 91.88,46.26 91.27,46.26 90.88,45.86 90.88,45.1 91.07,44.91 91.53,44.91 91.59,44.85 91.59,44.75 91.53,44.69 90.67,44.69 90.31,45.05 90.31,46.44 90.37,46.5 90.37,46.51 90.69,46.83 90.69,50.58 90.84,50.73 92.88,50.73
+0.9V_CIO on TOP (solid shape): 180.14,164.01 180.33,163.9 180.52,164.01 180.79,164.01 180.84,163.95 180.91,163.91 180.96,163.9 181.1,163.76 181.1,163.42 180.99,163.31 180.28,163.31 180.15,163.18 179.71,163.18 179.55,163.02 179.52,162.99 179.46,162.93 179.24,162.93 179.21,162.98 179.17,163.01 179.13,163.04 179.06,163.06 179.04,163.09 179.03,163.25 178.94,163.39 178.92,163.4 178.92,163.46 178.95,163.5 179.01,163.56 179.13,163.56 179.14,163.55 179.35,163.48 179.56,163.55 179.58,163.56 180.03,164.01
+0.9V_CIO on BOTTOM (solid shape): 180.91,163.9 180.91,163.71 180.97,163.65 181.45,163.65 181.48,163.62 181.48,163.23 181.42,163.17 180.45,163.17 180.23,162.95 179.75,162.95 179.65,162.85 179.65,162.37 179.59,162.31 179.2,162.31 179.13,162.37 179.13,163.26 179.32,163.45 179.43,163.46 179.54,163.5 179.55,163.51 180.27,163.51 180.38,163.61 180.38,163.94 180.47,164.03 180.78,164.03
+0.9V_DP on TOP (solid shape): 179.14,165.53 179.14,164.45 179.05,164.36 179.03,164.36 178.9,164.32 178.82,164.21 178.81,164.2 178.63,164.2 178.54,164.29 178.51,164.32 178.2,164.63 178.2,164.78 178.39,164.97 178.39,165.24 178.24,165.4 178.24,165.48 178.29,165.53 178.32,165.56 178.47,165.71 178.47,165.82 178.62,165.98 178.69,165.98
+0.9V_DP on TOP (solid shape): 181.42,162.74 181.42,162.73 181.47,162.67 181.53,162.63 181.53,162.62 181.57,162.58 181.57,162.42 181.74,162.25 181.74,162.11 181.71,162.08 181.68,162.04 181.58,162.04 181.52,162.1 181.44,162.18 181.3,162.19 181.19,162.18 181.16,162.15 181.05,162.07 180.96,162.16 180.66,162.29 180.36,162.18 180.33,162.16 180.3,162.18 180.27,162.2 180.25,162.24 180.26,162.27 180.35,162.55 180.18,162.79 180.15,162.8 180.15,162.93 180.28,163.05 181.1,163.05
+0.9V_DP on BOTTOM (solid shape): 176.28,154.28 176.28,152.83 176.24,152.78 174.16,152.78 173.94,153 173.94,154.27 173.94,154.36 174,154.43 176.13,154.43
+0.9V_DP on BOTTOM (solid shape): 181.75,162.82 181.81,162.82 181.82,162.82 181.94,162.8 182.06,162.82 182.09,162.82 182.15,162.76 182.15,162.3 182.11,162.26 181.26,162.26 181.22,162.22 180.89,162.22 180.71,162.29 180.53,162.27 180.5,162.26 180.39,162.37 180.39,162.69 180.67,162.97 181.59,162.97
+0.9V_DP on BOTTOM (solid shape): 178.71,166.06 178.8,166.06 178.95,165.92 178.95,165.89 178.98,165.89 179,165.87 179.4,165.87 179.71,165.56 179.71,165.55 179.97,165.4 180.26,165.5 180.4,165.5 180.65,165.4 180.91,165.5 181.05,165.5 181.23,165.41 181.42,165.42 181.51,165.41 181.56,165.32 181.56,165.01 181.5,164.96 180.98,164.96 180.9,164.88 180.64,164.88 180.57,164.8 180.51,164.78 179.19,164.78 179.16,164.75 179.08,164.75 179.08,164.67 179.07,164.66 179.07,164.4 178.89,164.22 178.47,164.22 178.45,164.25 178.45,164.75 178.37,164.75 178.37,164.94 178.38,164.95 178.41,165.11 178.38,165.26 178.37,165.27 178.37,165.94 178.49,166.06
+0.9V_DP on IN2 (solid shape): outline of 545 points within 174.13,153.74 182.44,162.97
+0.9V_DP on IN5: 180.39,162.27 180.22,162.44 180.22,163.65 179.69,164.18 178.61,164.18 178.51,164.28 178.51,165.39 181.17,165.39 181.17,163.76 181.58,163.35 181.56,163.33 181.56,162.27
+0.9V_LVR_OUT on BOTTOM (solid shape): 183.78,169.07 183.78,168.04 183.75,168.02 183.65,167.94 183.58,167.83 183.58,167.82 183.56,167.8 183.56,167.45 183.65,167.35 183.65,166.44 183.35,166.15 182.95,166.15 182.95,166.33 182.95,166.37 182.94,166.41 182.94,166.82 182.95,166.91 182.94,167 182.94,167.23 182.27,167.23 181.7,166.66 181.63,166.63 181.56,166.66 181.05,166.66 181.05,166.16 181.08,166.12 180.98,166.02 180.98,165.91 180.96,165.86 180.95,165.8 180.78,165.63 180.49,165.63 180.36,165.75 180.36,165.81 180.35,165.85 180.35,166.86 180.88,166.86 180.88,167.35 181.22,167.35 181.3,167.35 181.38,167.35 181.88,167.35 181.96,167.35 182.06,167.35 182.08,167.37 182.21,167.45 182.29,167.58 182.29,167.59 182.38,167.67 182.38,169.07 182.44,169.13 183.71,169.13
+0.9V_PCIE on TOP (solid shape): 188.03,159.32 188.03,157.01 188.08,156.96 188.08,156.61 188.02,156.55 187.69,156.55 187.59,156.64 187.59,159.31 187.65,159.36 188,159.36
+0.9V_PCIE on TOP (solid shape): 183.66,165.53 183.9,165.42 184.15,165.53 184.31,165.53 184.35,165.5 184.35,165.39 184.29,165.33 184.24,165.26 184.15,165.17 184.15,165.03 183.99,164.87 183.99,164.68 183.99,164.67 184.01,164.66 184.13,164.54 184.14,164.38 184.37,164.15 184.37,164.09 184.33,164.05 184.29,164.01 183.52,164.01 183.46,164.06 182.95,164.58 182.26,164.58 182.25,164.61 181.96,164.79 181.67,164.62 181.61,164.61 181.55,164.64 181.49,164.7 181.49,165.1 181.52,165.18 181.59,165.2 181.7,165.21 181.8,165.28 182.11,165.28 182.28,165.2 182.45,165.28 182.5,165.28 182.57,165.34 182.65,165.37 182.72,165.33 182.87,165.21 183.05,165.23 183.07,165.25 183.25,165.42 183.27,165.43 183.39,165.45 183.5,165.53
+0.9V_PCIE on BOTTOM (solid shape): 183.59,165.32 184.1,165.32 184.16,165.26 184.16,164.37 184.2,164.33 184.2,164.18 184.26,164.12 184.67,164.12 184.79,163.99 184.79,163.61 184.73,163.54 184.22,163.54 184.16,163.61 184.16,163.93 184.04,164.04 183.52,164.04 183.46,164.1 183.38,164.14 183.37,164.14 183.33,164.18 183.02,164.18 182.89,164.31 182.89,164.62 182.85,164.66 182.85,164.74 182.77,164.74 182.7,164.81 182.62,164.82 181.87,164.82 181.75,164.94 181.75,165.26 181.87,165.39 183.52,165.39
+0.9V_PCIE on IN2 (solid shape): outline of 392 points within 181.24,156.35 189.81,165.57
+0.9V_PCIE on IN5: 187.76,156.5 187.59,156.66 187.59,160.73 186.55,161.77 184.2,161.77 182.36,163.61 182.04,163.61 181.68,163.97 181.68,165.39 188.18,165.39 189.68,163.88 189.68,157.24 188.94,156.5
+0.9V_SVR on TOP (solid shape): 180.11,166.15 180.1,166.04 180.12,166 180.12,165.81 180.24,165.68 180.19,165.63 180.18,165.63 180.05,165.51 180.05,165.3 180.22,165.13 180.22,164.98 180.13,164.88 180.1,164.75 180.11,164.72 180.03,164.64 179.58,164.64 179.52,164.7 179.52,166.17 179.58,166.23 180.03,166.23
+0.9V_SVR on TOP (solid shape): 181.36,168.59 181.55,168.4 181.55,168.28 181.68,168.15 181.73,168.09 181.8,168.05 181.83,168.01 181.96,168.01 182.44,167.53 182.44,167.31 182.33,167.2 180.34,167.2 180.22,167.33 180.22,167.45 180.31,167.58 180.33,167.74 180.33,167.77 180.36,167.8 180.41,167.82 180.44,167.83 180.52,167.9 180.56,168.01 180.56,168.03 180.73,168.2 180.85,168.2 181.25,168.59
+0.9V_SVR on BOTTOM (solid shape): 174,173.46 174,173.18 174.47,172.71 175.24,172.71 175.36,172.59 175.36,170.85 175.27,170.76 175.25,170.78 171.05,170.78 170.92,170.66 170.92,170.41 170.78,170.26 169.99,170.26 169.78,170.47 169.78,173.33 170.02,173.57 173.88,173.57
+0.9V_SVR on BOTTOM (solid shape): 179.46,169.96 179.46,169.64 179.46,169.64 179.46,169.52 179.53,169.45 181.65,169.45 181.74,169.35 181.74,168.63 181.64,168.16 182.11,168.02 182.21,168.02 182.25,167.93 182.25,167.72 182.01,167.48 180.67,167.48 180.48,167.67 180.48,168.37 180.31,168.53 180.26,168.61 180.18,168.66 180.1,168.74 179.66,168.74 179.58,168.67 179.58,168.4 179.58,168.4 179.23,168.4 179.21,168.41 179.21,168.49 179.05,168.65 179.05,169.98 179.06,169.99 179.43,169.99
+0.9V_SVR on IN2 (solid shape): outline of 990 points within 169.82,167.42 184.03,175.06
+0.9V_SVR on IN3 (solid shape): outline of 257 points within 179.17,165.09 182.71,169.08
+0.9V_USB on IN2 (solid shape): outline of 323 points within 182.43,156.5 187.39,163.35
+1.0VS_VGAP on BOTTOM (solid shape): 242.99,46.77 242.99,44.59 242.38,43.97 241.21,43.97 241.15,44.03 241.15,44.72 240.97,44.9 238.62,44.9 237.5,43.78 237.5,42.32 237.37,42.2 236.04,42.2 235.8,42.44 235.8,44.57 235.53,44.83 233.69,44.83 233.12,45.4 233.12,46.16 233.13,46.16 235.42,46.16 235.42,46.15 236.15,46.88 241.2,46.88 241.28,46.96 242.81,46.96
+1.2V_DDR on TOP (solid shape): 128.84,28.44 120.84,28.44 120.84,36.44 128.84,36.44
+1.2V_DDR on TOP (solid shape): outline of 31094 points within 97.58,23.02 174.07,102.36
+1.2V_DDR on BOTTOM (solid shape): 129.36,98.11 129.36,96.14 129.07,95.84 128.4,95.84 128.3,95.94 128.3,96.74 128.46,96.9 128.46,98.13 128.54,98.21 129.26,98.21
+1.2V_DDR on BOTTOM (solid shape): outline of 84 points within 138.4,59.07 154.97,64.07
+1.2V_DDR on BOTTOM (solid shape): outline of 198 points within 98.56,31.02 110.88,41.37
+1.2V_DDR on IN2 (solid shape): outline of 283 points within 98.56,31.02 110.88,41.37
+1.2V_DDR on IN5: 108.76,36.42 108.28,36.9 108.28,44.76 111.38,47.86 111.38,77.07 119.33,85.02 119.33,85.93 119.31,85.94 119.31,95.98 119.93,96.59 122.77,96.59 122.88,96.7 122.88,95.3 130.33,87.85 170.99,87.85 173.47,90.33 179.07,84.74 179.01,37.49 179.01,37.1 178.32,36.42
+1.2V_VCCPLL_OC on BOTTOM (solid shape): 130.37,102.39 130.37,101.91 130.28,101.82 129.64,101.82 129.29,101.46 129.29,99.71 129.17,99.6 128.55,99.6 128.47,99.68 128.47,102.32 128.73,102.58 130.18,102.58
+1.2V_VCCPLL_OC on IN6 (solid shape): outline of 1259 points within 137.08,99.48 169.75,103.54
+1.2VP on TOP (solid shape): 97.35,23.21 97.16,23.02 94.31,23.02 93.73,23.59 93.73,28.73 94.12,29.12 94.43,29.12 97.04,31.72 97.35,31.72
+1.2VP on BOTTOM (solid shape): outline of 292 points within 89.99,25.11 98.34,37.24
+1.8VS on TOP (solid shape): 41.08,32.53 41.08,32.52 41.17,32.44 41.17,31.55 41.13,31.51 40.14,31.51 39.86,31.79 39.86,32.49 40.14,32.77 40.84,32.77
+1.8VS on TOP (solid shape): 37.22,15.65 37.22,15.21 37.16,15.15 36.58,15.15 36.46,15.02 36.46,14.83 36.15,14.52 36.15,14.26 35.96,14.07 35.96,12.99 35.89,12.93 35.79,12.93 35.74,12.98 35.74,14.03 35.64,14.13 35.64,14.51 35.52,14.63 35.19,14.63 35.19,14.63 35.15,14.6 35.14,14.6 35.01,14.51 34.92,14.38 34.92,14.37 34.88,14.33 34.88,14.13 34.69,13.94 34.53,13.94 34.34,13.75 34.34,12.96 34.3,12.93 34.19,12.93 34.14,12.98 34.14,13.85 34.37,14.08 34.37,14.4 34.48,14.52 34.49,14.52 34.8,14.83 34.81,14.83 34.81,15.67 34.86,15.72 37.16,15.72
+1.8VS on BOTTOM (solid shape): 195.37,114.83 195.37,114.17 195.49,114.05 195.79,114.05 195.93,113.9 195.93,113.32 195.94,113.31 195.94,113.2 195.96,113.17 195.96,112.47 195.91,112.41 194.07,112.41 193.73,112.75 193.73,114.42 193.89,114.59 193.9,114.59 194.27,114.95 195.25,114.95
+1.8VS on BOTTOM (solid shape): 34.93,22.17 34.93,21.06 34.15,20.29 32.52,20.29 31.44,21.37 31.44,22 31.44,22.09 31.48,22.13 31.9,22.13 31.91,22.12 31.91,21.75 32.4,21.25 34.08,21.25 34.35,21.52 34.35,22.14 34.4,22.19 34.91,22.19
+1.8VS on BOTTOM (solid shape): 211.23,58.4 211.23,57.44 211.72,56.95 212.63,56.95 213.18,56.4 213.18,51.95 214.04,51.09 216.18,51.09 217.38,49.88 221.76,49.88 222.91,48.72 222.91,46.86 222.03,45.98 222.03,45.46 222,45.42 221.64,45.42 221.64,45.95 221.14,45.95 221.14,45.42 220.84,45.42 220.84,45.95 220.34,45.95 220.34,45.42 219.97,45.42 219.96,45.43 219.96,46.44 220.08,46.56 220.89,46.56 221.3,46.97 221.3,47.45 220.65,48.1 215.2,48.1 212.45,50.85 212.45,51.25 210.71,52.98 210.71,54.25 208.86,56.1 208.86,56.82 202.65,63.04 201.34,63.04 199.7,64.68 199.7,65.49 199.89,65.67 203.96,65.67
+1.8VS on IN1 (solid shape): outline of 292 points within 32.91,20.11 41.17,32.67
+1.8VS on IN2 (solid shape): 54.82,11.82 54.82,11.61 54.31,11.11 53.3,11.11 52.93,11.47 52.93,12.21 53.11,12.39 54.25,12.39
+1.8VS on IN2 (solid shape): 327.57,12.91 327.57,12.03 327.5,11.97 325.65,11.97 325.48,12.14 325.48,12.97 325.65,13.14 327.34,13.14
+1.8VS on IN2 (solid shape): 272.45,14.93 272.45,13.93 272.25,13.73 268.74,13.73 268.55,13.92 268.55,14.73 270.36,14.73 270.36,14.67 270.37,14.62 270.39,14.57 270.41,14.52 270.44,14.48 270.47,14.44 270.52,14.41 270.56,14.38 270.61,14.36 270.66,14.35 270.72,14.34 270.77,14.35 270.82,14.36 270.87,14.38 270.92,14.41 270.96,14.44 271,14.48 271.03,14.52 271.05,14.57 271.07,14.62 271.07,14.67 271.07,14.73 271.07,14.78 271.05,14.83 271.03,14.88 271,14.92 270.96,14.96 270.92,15 270.87,15.02 270.82,15.04 270.77,15.05 270.72,15.06 270.66,15.05 270.61,15.04 270.56,15.02 270.52,15 270.47,14.96 270.44,14.92 270.41,14.88 270.39,14.83 270.37,14.78 270.36,14.73 268.55,14.73 268.55,14.89 268.83,15.17 272.21,15.17
+1.8VS on IN3 (solid shape): 328.24,12.71 328.24,12.06 328.14,11.96 326.37,11.96 326.2,12.14 326.2,12.69 326.45,12.95 328,12.95
+1.8VS on IN3 (solid shape): 224.21,47.77 224.21,46.3 224.03,46.13 221.3,46.13 221.22,46.21 221.22,46.91 221.28,46.97 221.28,47.84 221.4,47.97 224.02,47.97
+1.8VS on IN3 (solid shape): 297.66,57.14 297.66,56.79 297.57,56.55 297.66,56.32 297.66,54.76 297.66,54.48 297.63,54.41 297.56,54.38 297.25,54.17 297.3,53.79 297.32,53.73 297.3,53.66 297.25,53.29 297.56,53.08 297.63,53.05 297.66,52.98 297.66,52.22 293.26,47.82 277.34,47.82 277.21,47.95 277.21,48.94 277.41,49.14 278.16,49.14 278.74,48.57 280.03,48.57 280.11,48.48 288.67,48.48 288.76,48.57 293.16,48.57 293.42,48.83 293.54,48.83 296.49,51.77 296.49,57.32 296.67,57.5 297.3,57.5
+1.8VS on IN3 (solid shape): outline of 206 points within 327.57,47.64 334.53,50.27
+1.8VS on IN3 (solid shape): outline of 810 points within 307.34,49.46 321.1,60.79
+1.8VS on IN4 (solid shape): 53.55,12.66 54.05,12.66 54.25,12.45 54.25,11.89 54.14,11.78 53.07,11.78 52.28,12.57 52.28,12.85 52.62,13.19 53.02,13.19
+1.8VS on IN4 (solid shape): 202.61,63.57 202.61,63.27 202.06,62.72 201.53,62.72 199.45,64.8 199.45,65.34 199.86,65.74 200.44,65.74
+1.8VS on IN4 (solid shape): 41.3,32.49 41.3,31.27 41.16,31.13 40.08,31.13 39.86,31.36 39.86,31.92 39.86,31.97 39.86,32.36 40.23,32.74 41.05,32.74
+1.8VS on IN4 (solid shape): 195.84,115.09 195.84,113.38 195.03,112.57 193.73,112.57 193.47,112.83 193.28,112.83 193.18,112.94 192.99,112.94 192.54,113.38 192.54,113.71 194.06,115.22 195.72,115.22
+1.8VS on IN5: 197.94,86.43 195.27,89.1 195.27,98.51 194.06,99.71 194.06,114.61 194.26,114.8 199.21,114.8 199.21,103.82 199.74,103.28 206.6,103.28 206.83,103.05 206.83,94.37 205.88,93.42 205.88,63.19 205.88,63.19 205.88,57.14 214.91,48.11 223.31,48.11 223.34,48.09 223.34,45.72 222.92,45.31 214.17,45.31 197.94,61.54
+1.8VSP on BOTTOM (solid shape): 227.46,48.23 227.46,44.62 227.29,44.44 223.26,44.44 222.78,43.96 222.78,43.96 222.78,42.3 222.72,42.23 220.76,42.23 220.68,42.25 220.61,42.24 219.97,42.88 219.97,45.28 219.99,45.29 222.17,45.29 223.11,46.23 225.02,46.23 225.26,46.14 225.49,46.23 225.52,46.23 225.85,46.56 225.85,48.17 225.95,48.26 227.42,48.26
+1.35VS_B+ on TOP (solid shape): 260.93,25.24 260.93,23.84 260.74,23.65 260.74,23.02 260.55,22.83 259.79,22.83 259.66,22.96 257.69,22.96 257.44,22.7 256.93,22.7 256.8,22.83 256.8,23.27 256.66,23.41 256.66,23.62 256.61,23.62 256.61,25.18 256.87,25.43 260.74,25.43
+1.35VS_B+ on BOTTOM (solid shape): outline of 93 points within 255.85,21.11 261.56,31.27
+1.35VS_VGA on TOP (solid shape): outline of 57216 points within 189.81,46.01 287.09,118.26
+1.35VS_VGA on BOTTOM (solid shape): 271.53,62.64 271.53,59.47 271.28,59.21 267.6,59.21 267.22,59.6 267.22,62.64 267.6,63.02 271.15,63.02
+1.35VS_VGA on BOTTOM (solid shape): 248.56,105.32 248.56,104.49 248.49,104.4 248.46,104.31 248.45,104.29 248.26,104.09 248.21,104.06 248.18,104.03 247.96,104.03 247.83,104.16 247.67,104.17 247.52,104.16 247.42,104.06 247.19,104.06 247.1,104.15 247.1,104.39 247.48,104.78 247.63,104.78 248.27,105.43 248.45,105.43
+1.35VS_VGA on BOTTOM (solid shape): 270.77,48.42 270.77,45.63 270.32,45.17 269.59,45.17 269.59,45.73 268.84,45.73 268.84,45.17 268.39,45.17 268.39,45.73 267.64,45.73 267.64,45.17 264.31,45.17 264.31,45.69 263.56,45.69 263.56,45.15 263.11,45.15 263.11,45.7 262.36,45.7 262.36,45.15 261.59,45.15 261.06,45.69 261.06,48.36 261.31,48.61 270.58,48.61
+1.35VS_VGA on BOTTOM (solid shape): 247.14,91.29 247.18,91.36 247.26,91.39 247.27,91.39 247.33,91.35 247.35,91.28 247.56,90.95 247.93,91.07 248.17,91.07 248.21,91.04 248.46,90.79 248.46,90.77 248.51,90.67 248.59,90.58 248.59,89.82 248.5,89.71 248.45,89.58 248.45,89.56 248.34,89.45 247.78,89.45 247.77,89.45 247.67,89.47 247.57,89.45 247.56,89.45 247.24,89.45 247.14,89.55
+1.35VS_VGA on BOTTOM (solid shape): 229.6,88.35 229.68,88.31 229.7,88.23 229.7,88.19 229.69,88.15 229.65,88.07 229.56,88.05 229.18,87.89 229.29,87.49 229.29,87.3 228.93,86.94 228.87,86.9 228.82,86.85 227.97,86.85 227.96,86.88 227.89,86.98 227.78,87.05 227.77,87.05 227.59,87.22 227.59,87.53 227.69,87.75 227.59,87.97 227.59,88.25 227.69,88.35
+1.35VS_VGA on BOTTOM (solid shape): 246.02,88.2 246.02,87.95 245.95,87.75 246.02,87.55 246,87.08 245.89,86.97 245.87,86.97 245.73,86.94 245.62,86.85 244.77,86.85 244.76,86.88 244.69,86.98 244.58,87.05 244.57,87.05 244.35,87.27 244.35,87.49 244.41,87.54 244.46,87.61 244.53,87.67 244.62,87.64 244.63,87.63 245.06,87.56 244.99,87.99 244.99,87.99 244.93,88.04 244.94,88.07 244.94,88.12 244.93,88.17 244.95,88.26 245.03,88.3 245.92,88.3
+1.35VS_VGA on BOTTOM (solid shape): 226.53,97.69 226.57,97.61 226.57,93.67 226.45,93.55 226.3,93.55 226.25,93.61 226.16,93.61 226.15,93.61 225.91,93.66 225.71,93.53 225.51,93.53 225.12,93.92 225.12,94.85 225.16,94.91 225.18,94.99 225.43,95.24 225.46,95.26 225.66,95.26 225.74,95.18 225.8,95.18 225.81,95.17 226.19,95.22 226.25,95.6 226.25,95.61 226.25,95.64 226.12,95.76 225.97,95.77 225.84,95.76 225.78,95.71 225.74,95.67 225.71,95.64 225.48,95.64 225.27,95.85 225.27,95.86 225.2,95.97 225.1,96.04 225.07,96.05 225.07,96.9 225.14,96.98 225.18,97.07 225.18,97.09 225.43,97.34 225.45,97.35 225.72,97.35 225.75,97.32 225.87,97.21 226.15,97.21 226.3,97.36 226.3,97.63 226.31,97.67 226.34,97.68 226.39,97.69 226.43,97.7
+1.35VS_VGA on BOTTOM (solid shape): 225.74,101.53 225.97,101.43 226.19,101.53 226.47,101.53 226.57,101.42 226.57,98.39 226.53,98.31 226.43,98.3 226.36,98.32 226.29,98.32 226.26,98.31 226.21,98.37 226.21,98.37 225.78,98.44 225.85,98.01 225.88,97.98 225.89,97.93 225.84,97.9 225.7,97.75 225.47,97.75 225.17,98.05 225.17,98.06 225.12,98.15 225.05,98.22 225.05,99 225.52,99.47 225.71,99.47 226.28,99.57 225.83,99.94 225.82,99.93 225.79,99.93 225.73,99.87 225.45,99.87 225.17,100.15 225.17,100.16 225.13,100.23 225.07,100.3 225.07,101.1 225.12,101.15 225.16,101.21 225.47,101.53
+1.35VS_VGA on BOTTOM (solid shape): 225.8,93.04 225.8,92.85 225.8,92.44 226.21,92.53 226.21,92.54 226.26,92.59 226.29,92.58 226.36,92.58 226.43,92.6 226.53,92.59 226.57,92.51 226.57,89.5 226.44,89.37 226.19,89.37 225.97,89.47 225.75,89.37 225.41,89.37 225.37,89.4 225.33,89.41 225.21,89.53 225.19,89.53 225.14,89.57 225.14,90.62 225.2,90.71 225.22,90.81 225.23,90.83 225.35,90.95 225.36,90.96 225.43,90.99 225.49,91.03 225.69,91.03 225.74,90.98 225.74,90.96 225.76,90.94 225.8,90.94 225.81,90.93 225.97,90.89 226.13,90.93 226.14,90.94 226.17,90.94 226.3,91.07 226.3,91.11 226.3,91.12 226.33,91.25 226.3,91.38 226.29,91.41 226.22,91.5 226.13,91.57 226.11,91.58 225.9,91.6 225.71,91.49 225.48,91.49 225.14,91.83 225.14,92.72 225.19,92.79 225.21,92.86 225.22,92.87 225.52,93.17 225.66,93.17
+1.35VS_VGA on BOTTOM (solid shape): 248.64,103.18 248.64,102.44 248.62,102.43 248.52,102.34 248.46,102.23 248.46,102.21 248.21,101.96 248.17,101.93 247.93,101.93 247.35,101.75 247.93,101.57 248.17,101.57 248.21,101.54 248.27,101.5 248.45,101.32 248.46,101.3 248.49,101.19 248.57,101.1 248.57,100.25 248.51,100.18 248.47,100.11 248.47,100.1 248.27,99.9 248.21,99.86 248.17,99.83 247.93,99.83 247.35,99.65 247.93,99.47 248.17,99.47 248.21,99.44 248.27,99.4 248.39,99.28 248.39,99.27 248.45,99.16 248.54,99.07 248.54,98.1 248.51,98.07 248.48,98.04 248.21,97.76 248.17,97.73 247.93,97.73 247.88,97.79 247.81,97.84 247.75,97.91 247.78,98 247.79,98.01 247.86,98.44 247.43,98.37 247.43,98.37 247.38,98.31 247.31,98.32 247.26,98.31 247.18,98.34 247.14,98.41 247.14,102.4 247.63,102.88 247.65,102.88 247.91,103.04 247.87,103.33 247.84,103.4 247.87,103.47 247.99,103.6 248.22,103.6
+1.35VS_VGA on BOTTOM (solid shape): 244.21,88.3 244.29,88.26 244.31,88.17 244.31,88.15 244.27,88.09 244.2,88.07 243.87,87.86 243.99,87.49 243.99,87.25 243.71,86.96 243.69,86.96 243.61,86.93 243.54,86.87 243.35,86.88 242.66,86.88 242.65,86.9 242.58,86.99 242.48,87.05 242.47,87.05 242.25,87.27 242.25,87.49 242.07,88.07 241.89,87.49 241.89,87.32 241.88,87.28 241.53,86.94 241.48,86.91 241.44,86.87 241.26,86.88 240.78,86.88 240.59,86.87 240.54,86.92 240.47,86.95 240.15,87.27 240.15,87.49 239.97,88.07 239.79,87.49 239.79,87.3 239.43,86.94 239.37,86.9 239.32,86.85 238.52,86.85 238.45,86.91 238.38,86.95 238.37,86.95 238.17,87.15 238.15,87.17 238.09,87.23 238.08,87.24 238.05,87.28 238.05,87.49 238.11,87.54 238.16,87.61 238.23,87.67 238.32,87.64 238.34,87.62 238.76,87.56 238.7,87.98 238.69,87.99 238.63,88.05 238.64,88.07 238.64,88.12 238.63,88.17 238.65,88.26 238.73,88.3
+1.35VS_VGA on BOTTOM (solid shape): 247.14,97.59 247.18,97.66 247.26,97.69 247.27,97.69 247.33,97.65 247.35,97.58 247.56,97.25 247.93,97.37 248.17,97.37 248.21,97.34 248.46,97.09 248.46,97.07 248.51,96.97 248.59,96.88 248.59,96.12 248.5,96.02 248.46,95.9 248.45,95.88 248.27,95.7 248.21,95.66 248.17,95.63 247.93,95.63 247.35,95.45 247.93,95.27 248.17,95.27 248.21,95.24 248.27,95.2 248.62,94.85 248.62,94.03 248.52,93.95 248.46,93.83 248.46,93.81 248.21,93.56 248.17,93.53 247.93,93.53 247.35,93.35 247.93,93.17 248.17,93.17 248.23,93.13 248.29,93.09 248.3,93.09 248.35,93.04 248.35,93.02 248.42,92.86 248.56,92.75 248.59,92.74 248.59,91.92 248.51,91.83 248.46,91.73 248.46,91.71 248.21,91.46 248.17,91.43 247.93,91.43 247.88,91.49 247.81,91.54 247.75,91.61 247.78,91.7 247.79,91.71 247.86,92.14 247.43,92.07 247.43,92.07 247.38,92.01 247.31,92.02 247.26,92.01 247.18,92.04 247.14,92.11
+1.35VS_VGA on BOTTOM (solid shape): 231.12,88.3 237.91,88.3 237.99,88.26 238.01,88.17 238.01,88.15 237.97,88.09 237.9,88.07 237.57,87.86 237.69,87.49 237.69,87.28 237.66,87.25 237.65,87.23 237.37,86.95 237.36,86.95 237.29,86.91 237.22,86.85 236.37,86.85 235.95,87.27 235.95,87.49 235.77,88.07 235.59,87.49 235.59,87.3 235.14,86.85 234.27,86.85 234.26,86.88 234.19,86.98 234.08,87.05 234.07,87.05 233.85,87.27 233.85,87.49 233.67,88.07 233.49,87.49 233.49,87.27 233.17,86.95 233.16,86.95 233.09,86.91 233.02,86.85 232.17,86.85 231.75,87.27 231.75,87.49 231.57,88.07 231.39,87.49 231.39,87.3 231.03,86.94 230.98,86.91 230.94,86.87 230.75,86.88 230.07,86.88 229.89,87.05 229.65,87.3 229.65,87.49 229.77,87.63 229.78,87.82 229.8,87.88 229.85,87.88 229.88,87.87 229.91,87.84 229.91,87.81 230.21,87.49 230.4,87.88 230.4,87.89 230.4,88.09 230.33,88.16 230.32,88.23 230.34,88.31 230.42,88.35 231.07,88.35
+1.35VS_VGA on IN1 (solid shape): outline of 1168 points within 224.67,86.45 238.01,101.6
+1.35VS_VGA on IN1 (solid shape): outline of 1245 points within 238.03,86.45 248.97,104.5
+1.35VS_VGA on IN1 (solid shape): outline of 2977 points within 190.31,86.53 206.86,102.09
+1.35VS_VGA on IN1 (solid shape): outline of 18116 points within 190.31,45.92 286.58,120.45
+1.35VS_VGA on IN2 (solid shape): outline of 16056 points within 188.29,46.01 287.28,117.71
+1.35VS_VGA on IN3 (solid shape): outline of 41776 points within 190.45,51.21 288.17,119.29
+1.35VS_VGA_PGOOD on TOP (solid shape): 277.45,146.63 277.45,145.27 277.36,145.24 277.28,145.18 277.02,145.27 276.77,145.14 276.59,145.14 276.42,145.24 276.23,145.23 276.14,145.31 276.14,146.29 276.36,146.5 276.37,146.5 276.55,146.68 277.4,146.68
+1.35VS_VGAP on BOTTOM (solid shape): 262.96,45.02 263.71,45.02 263.71,45.54 264.16,45.54 264.16,45.02 267.79,45.02 267.79,45.54 268.24,45.54 268.24,45.02 268.99,45.02 268.99,45.54 269.44,45.54 269.44,45.03 270.31,45.03 270.71,44.63 270.71,39.47 269.88,38.64 265.88,38.64 263.6,36.35 253.12,36.35 252.17,37.31 252.17,40.42 254.58,42.83 254.58,44.8 254.96,45.18 260.98,45.18 261.14,45.02 262.51,45.02 262.51,45.54 262.96,45.54
+1V8_AON on BOTTOM (solid shape): 207.11,123.17 207.11,121.58 206.99,121.46 205.45,121.46 205.34,121.57 205.34,123.2 205.41,123.27 207,123.27
+1V8_AON on BOTTOM (solid shape): 201.39,114.98 201.39,114.84 201.21,114.67 201.21,113.55 200.76,113.1 200.76,112.61 200.55,112.39 199.58,112.39 199.35,112.48 199.11,112.39 198.72,112.39 198.47,112.49 198.22,112.39 197.45,112.39 197.35,112.49 197.35,113.17 197.62,113.45 198.3,113.45 198.42,113.33 199.23,113.33 199.3,113.4 199.3,114.07 199.69,114.46 200.06,114.46 200.22,114.62 200.29,114.68 200.35,114.75 200.77,115.17 201.2,115.17
+1V8_AON on BOTTOM (solid shape): 193.15,111.33 193.83,110.65 194.12,110.65 194.21,110.74 194.38,110.74 194.79,111.16 195.02,111.16 195.02,111.15 195.93,111.15 195.98,111.11 195.98,109.94 195.58,109.54 195.58,108.75 195.4,108.57 193.33,108.57 193.25,108.62 193.24,108.71 193.04,109.18 192.58,108.98 192.51,108.92 192.41,108.95 192.1,109.26 192.1,111.04 192.47,111.42 193.15,111.42
+1V8_AON on BOTTOM (solid shape): outline of 186 points within 201.96,106.44 205.42,114.61
+1V8_AON on IN2 (solid shape): outline of 5955 points within 192.68,105.94 225.75,124.68
+1V8_AON on IN4 (solid shape): 235.91,120.34 235.91,119.68 235.72,119.48 235.35,119.93 235.04,119.44 234.76,119.44 234.68,119.51 234.68,120.33 235.06,120.71 235.54,120.71
+1V8_AON on IN5: 217.81,110.75 217.79,110.78 199.72,110.78 199.72,121.78 200.14,122.21 206.47,122.21 206.6,122.08 217.84,122.08 218.26,121.66 218.26,115.81 218.77,115.31 218.77,111.71
+1V8_MAIN on TOP (solid shape): 204.67,107.54 205.84,107.54 205.99,107.39 205.99,106.53 205.82,106.36 205.48,106.36 205.29,106.56 204.57,106.56 204.05,107.08 201.51,107.08 201.42,107.16 201.42,107.97 201.5,108.05 204.16,108.05
+1V8_MAIN on TOP (solid shape): 230.89,116.87 230.89,116.49 231.21,116.17 232.61,116.17 233.09,115.69 233.09,112.19 232.95,112.05 232.95,111.1 233.15,110.9 233.56,110.9 233.69,110.78 233.69,110.4 233.56,110.27 232.61,110.27 232.55,110.33 232.55,110.93 232.57,110.96 232.57,112.66 232.69,112.87 232.57,113.08 232.57,114.24 232.55,114.26 232.55,115.73 232.43,115.85 230.27,115.85 229.82,116.3 229.82,116.92 229.88,116.98 230.79,116.98
+1V8_MAIN on TOP (solid shape): outline of 209 points within 235.97,108.2 240.67,110.8
+1V8_MAIN on TOP (solid shape): outline of 1433 points within 210.08,101.9 227.62,111.29
+1V8_MAIN on BOTTOM (solid shape): 199.29,110.97 199.29,110.31 199.06,110.08 199.06,109.75 199.13,109.67 199.13,109.48 198.94,109.29 197.9,109.29 197.75,109.44 197.75,109.61 197.76,109.68 197.75,109.76 197.75,109.88 197.52,110.11 197.48,110.11 197.35,110.24 197.35,111.09 197.41,111.15 199.11,111.15
+1V8_MAIN on BOTTOM (solid shape): 226.54,107.72 226.54,102.1 226.4,101.95 226.22,101.95 225.97,102.07 225.72,101.95 225.47,101.95 225.22,102.2 225.21,102.21 225.16,102.3 225.07,102.37 225.07,103.23 225.52,103.67 225.71,103.67 226.29,103.85 225.71,104.03 225.49,104.03 225.09,104.42 225.09,104.6 225.22,104.72 225.22,105 225.09,105.13 225.09,105.35 225.44,105.7 225.44,105.75 225.47,105.77 225.71,105.77 226.29,105.95 225.71,106.13 225.47,106.13 225.44,106.15 225.44,106.18 225.17,106.45 225.14,106.51 225.14,107.45 225.59,107.9 226.37,107.9
+1V8_MAIN on BOTTOM (solid shape): outline of 89 points within 235.89,108.62 240.99,111.03
+1V8_MAIN on IN1 (solid shape): outline of 3989 points within 191.73,102.45 236.65,115.76
+1V8_MAIN on IN2 (solid shape): outline of 3503 points within 225.34,100.37 240.99,111.22
+1V8_MAIN on IN5: 199.95,103.79 199.72,104.02 199.72,109.72 200.27,110.27 217.58,110.27 217.81,110.04 217.81,107.26 214.34,103.79
+1V_MPHY on TOP (solid shape): outline of 2450 points within 191.94,16.67 203.85,31.96
+1V_MPHY on BOTTOM (solid shape): 195.26,19.05 195.42,18.89 195.42,18.74 195.33,18.65 195.2,18.65 195,18.44 194.6,18.44 194.43,18.27 194.43,16.53 194.73,16.23 195.23,16.23 195.38,16.38 195.38,17.89 195.53,18.04 195.53,18.27 195.66,18.4 195.76,18.4 195.84,18.39 196,18.23 196,18.03 195.98,18.02 195.85,17.82 195.92,17.6 195.92,15.53 195.6,15.21 192.99,15.21 192.55,15.65 192.55,17.36 193.18,17.99 194.2,19.01 194.52,19.01 194.76,18.87 195,19.03 195.01,19.05
+1V_PCH on TOP (solid shape): outline of 2305 points within 189.98,29.07 203.11,43.25
+1V_PCH on BOTTOM (solid shape): 209.94,37.33 210.35,37.33 210.48,37.2 210.48,36.95 210.4,36.87 210.11,36.87 210.06,36.92 209.78,36.92 209.68,36.95 209.57,36.94 209.41,37.27 209.04,37.23 208.98,37.23 208.97,37.24 208.54,37.24 208.39,37.38 208.39,37.48 208.48,37.57 209.7,37.57
+1V_PCH on IN2 (solid shape): outline of 1297 points within 200.03,27.91 211.53,34.36
+1V_PCH on IN3 (solid shape): outline of 1531 points within 203.29,27.92 211.07,42.63
+1V_PCH_PRIM on TOP (solid shape): outline of 1497 points within 202.52,26.18 208.55,42.33
+1VALW on TOP (solid shape): 184.02,80.46 184.02,79.06 183.89,78.94 182.75,78.94 182.5,78.68 182.5,74.36 182.11,73.98 177.1,73.98 176.65,74.43 176.65,77.76 177.4,77.76 177.4,76.99 177.99,76.99 177.99,76.84 177.4,76.84 177.4,76.08 177.77,76.08 178.36,75.49 178.67,75.49 178.89,75.71 178.89,76.67 179.64,77.41 179.64,78.87 179.51,79 178.43,79 178.18,78.75 178.18,78.17 178.11,78.11 178.01,78.11 177.65,77.76 176.65,77.76 176.65,80.27 177.03,80.65 183.83,80.65
+1VALW on TOP (solid shape): outline of 990 points within 184.25,30.49 205.6,50.88
+1VALW on BOTTOM (solid shape): 241.18,29.37 241.95,29.37 242.9,28.43 248.79,28.43 249.12,28.1 249.12,26.69 249.06,26.64 249.01,26.58 248.36,26.58 248.36,27.03 247.65,27.03 247.65,26.58 247.16,26.58 247.16,27.03 246.45,27.03 246.45,26.58 245.4,26.58 245.07,26.8 244.74,26.58 243.15,26.58 243.15,27.03 242.45,27.03 242.45,26.58 241.95,26.58 241.95,27.03 241.25,27.03 241.25,26.58 239.85,26.58 239.57,26.85 239.57,29.22 239.72,29.37 239.88,29.37 240.05,29.54 240.1,29.6 240.13,29.66 240.15,29.69 240.86,29.69
+1VALW on IN6 (solid shape): outline of 827 points within 232.74,24.87 246.83,36.01
+1VALW on IN5: 237.92,26.96 237.16,27.72 188.9,27.72 179.52,37.1 179.52,37.49 179.57,78.07 186.47,78.07 187.27,77.27 187.27,48.38 195.61,40.04 237.39,40.04 239.78,37.65 239.78,34.66 241.05,33.39 241.05,27.7 240.31,26.96
+1VALWP on BOTTOM (solid shape): 240.57,26.38 241.35,26.38 241.35,26.38 241.85,26.38 241.85,26.38 242.55,26.38 242.55,26.38 243.05,26.38 243.05,26.38 243.83,26.38 243.83,26.38 244.72,26.38 245.07,26.09 245.42,26.38 245.78,26.38 245.78,26.38 246.56,26.38 246.56,26.38 247.05,26.38 247.05,26.38 247.76,26.38 247.76,26.38 248.25,26.38 248.25,26.38 248.89,26.38 248.96,26.3 248.98,26.26 248.98,25.96 250.45,24.48 250.45,18.13 249.75,17.43 247.86,17.43 247.68,17.61 247.68,18.59 247.68,18.59 247.68,19.48 247.53,19.63 247.53,20.42 246.32,21.62 243.1,21.62 243.01,21.67 243,21.76 242.66,22.22 242.32,21.76 242.3,21.66 242.22,21.62 239.46,21.62 239.32,21.76 238.24,21.76 238.07,21.93 238.07,24.92 239.53,26.38 240.57,26.38
+1VALWP_B+ on TOP (solid shape): 259.6,22.45 259.6,19.21 259.74,19.07 259.74,19.06 259.75,19.06 259.79,19.02 260.36,19.02 260.49,18.89 260.49,14.38 260.22,14.12 259.5,14.12 259.5,14.65 259.06,14.65 259.06,14.12 258.77,14.12 258.77,15.08 258.96,15.27 258.96,16.86 259,16.93 259.08,16.95 259.51,17.3 259.08,17.65 259,17.67 258.96,17.75 258.96,18.89 258.33,19.52 256.86,19.52 256.77,19.56 256.68,19.57 256.64,19.6 255.23,19.6 255.22,19.62 255.22,21.86 255.48,22.13 257.37,22.13 257.95,22.7 259.34,22.7
+1VALWP_PGOOD on TOP (solid shape): 308.08,19.9 308.08,19.72 308,19.64 306.27,19.64 305.62,18.99 305.62,18.7 305.44,18.52 305.18,18.52 305.05,18.65 305.05,19.55 305.36,19.86 305.89,19.86 306,19.96 308.02,19.96
+2.5V_MEM on TOP (solid shape): 179.61,63.29 179.61,58.15 179.42,57.96 178.02,57.96 177.89,58.09 177.89,63.36 178.08,63.55 179.35,63.55
+2.5V_MEM on TOP (solid shape): 180.92,49.63 180.92,46.07 180.73,45.88 180.29,45.88 179.84,46.32 179.21,46.32 178.82,46.7 178.82,47.02 179.65,47.85 179.65,49.82 179.84,50.01 180.54,50.01
+2.5V_MEM on BOTTOM (solid shape): 180.41,46.94 179.79,46.32 177.66,46.32 177.53,46.45 177.53,48.61 177.76,48.84 179.14,48.84 179.42,49.12 180.41,49.12
+2.5V_MEM on BOTTOM (solid shape): 179.96,60.61 179.96,58 179.73,57.77 177.76,57.77 177.55,57.98 177.55,58.37 177.53,58.39 177.53,60.85 177.63,60.95 179.62,60.95
+2.5V_MEM on BOTTOM (solid shape): 107.42,46.13 107.77,45.84 108.12,46.13 109.99,46.13 110.44,45.69 110.44,44.55 109.93,44.04 109.17,44.04 104.53,39.4 103.32,39.4 103.13,39.6 103.13,39.95 103.66,39.95 103.66,40.46 103.13,40.46 103.13,40.75 103.66,40.75 103.66,41.26 103.13,41.26 103.13,42.45 106.82,46.13
+2.5V_MEM on IN6 (solid shape): 111.2,47.28 111.2,46.32 110.56,45.69 110.56,44.99 110.05,44.48 109.23,44.48 108.97,44.74 108.97,46.83 109.55,47.4 111.07,47.4
+2.5V_MEM on IN6 (solid shape): 180.22,49.05 180.22,47.66 179.21,46.64 178.7,46.64 178.25,47.09 178.25,47.59 179.14,48.48 179.14,49.12 179.21,49.18 180.09,49.18
+2.5V_MEMP on BOTTOM (solid shape): 101.86,44.6 101.86,42.9 102.24,42.51 102.69,42.51 103,42.2 103,41.73 103,41.73 103,41.15 103,41.13 103.52,41.13 103.52,40.88 103,40.88 103,40.86 103,40.35 103,40.33 103.52,40.33 103.52,40.13 103.47,40.08 103,40.08 103,40.06 103,39.61 102.92,39.53 101.8,39.53 101.58,39.31 101.58,38.16 101.48,38.06 100.88,38.06 100.78,38.15 100.78,42.39 101.16,42.77 101.16,44.61 101.35,44.8 101.66,44.8
+2.5VOUT on IN2 (solid shape): outline of 537 points within 129.83,151.03 138.35,161.25
+2.5VSP_VIN on BOTTOM (solid shape): 100.95,54.06 101.5,54.06 101.5,54.61 101.74,54.61 101.74,54.06 102.29,54.06 102.29,54.61 102.91,54.61 103.2,54.32 103.2,53.37 102.37,52.55 102.37,50.32 101.99,49.94 101.99,48.17 101.8,47.97 101.35,47.97 101.16,48.17 101.16,52.42 100.4,53.18 100.4,54.54 100.47,54.62 100.95,54.62
+3.3V_1.8V_DVDD on TOP (solid shape): 38.61,31.79 38.84,31.62 39.13,31.68 39.14,31.69 39.24,31.69 39.24,31.69 39.28,31.69 39.29,31.68 39.47,31.61 39.66,31.65 39.7,31.67 39.76,31.6 39.76,31.59 40.17,31.19 41.07,31.19 41.2,31.06 41.2,30.78 41.22,30.77 41.22,29.56 40.34,29.56 40.34,29.24 40.28,29.18 39.78,29.18 39.69,29.27 39.68,29.31 39.68,29.68 39.71,29.69 39.91,30.08 39.58,30.37 39.56,30.37 38.94,30.37 38.81,30.5 38.81,30.94 38.71,31.04 38.14,31.04 38.07,31.11 38.07,31.74 38.13,31.79
