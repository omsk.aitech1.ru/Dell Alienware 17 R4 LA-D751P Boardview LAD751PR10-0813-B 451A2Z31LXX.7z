# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 241.7
  TOP w0.127: v2(17.47,24.97) v4(17.47,25.89)
  TOP w0.203: v2(22.54,19.65) 22.54,20.09 22.31,20.31 21.46,20.31 20.41,21.37 20.41,22.19 19.9,22.7 UA3.A2 ; v2(27.96,33.61) v4(26.97,33.61) ; UA2.A2 23.5,28.23 v2(23.57,28.16)
  TOP w0.356: v2(21.48,26.27) 21.99,26.27 CA51.1 ; RA44.2 21.6,24.99 v2(21.54,24.92) ; v2(17.47,24.97) 17.79,24.66 CA44.1
  TOP w0.381: v2(19.57,24.19) 20.46,24.19 CA50.2 ; RA45.2 23.5,21.37 22.81,21.37 v2(22.67,21.51) 21.6,21.51 21.18,21.92 CA48.2
  TOP w0.508: CA92.2 18.03,20.71 v2(17.55,20.71) ; v2(14.3,1.8) RA7.1 ; v2(30.62,23.36) 29.83,24.15 CA16.2 28.96,24.15 28.47,23.65 CA17.2 ; v2(18.32,15.18) 18.37,15.23 CA91.2 ; RA6.1 28.14,33.43 v2(27.96,33.61) ; v4(26.09,35.4) 26.9,35.4 v2(26.91,35.4) 26.91,35.4 CA32.2 ; v2(27.72,27.57) CA25.2 28.58,27.67 CA24.2 ; CA30.2 31.76,23.46 CA31.2 v2(32.28,22.05) ; RA1.1 15.88,27.78 v2(15.78,27.88) ; v2(26.87,16.8) 26.74,16.92 RA4.1
  GND1 w0.203: 7.19,16.33 JACK2.3 ; JACK2.3 9.35,17 ; JACK2.3 8.27,16.33 ; JACK2.3 7.19,17 ; JACK2.3 9.35,16.33 ; 4.59,16.33 JACK2.4 ; JACK2.4 4.59,17 ; JACK2.4 6.75,16.33 ; JACK2.4 5.67,16.33 ; JACK2.4 6.75,17 ; 9.64,25.83 JACK2.6 ; JACK2.6 9.64,27.17 ; JACK2.6 9.64,26.5 ; JACK2.6 11.8,27.17 ; JACK2.6 10.72,27.17 ; JACK2.6 10.72,25.83 ; JACK2.6 11.8,26.5 ; JACK2.6 11.8,25.83 ; JACK1.5 14.55,13.13 ; JACK1.5 12.39,13.8 ; JACK1.5 12.39,13.13 ; JACK1.5 13.47,13.13 ; JACK1.5 13.47,14.47 ; JACK1.5 14.55,13.8 ; JACK1.5 14.55,14.47 ; JACK1.5 12.39,14.47
  GND2 w0.203: JACK2.6 11.8,26.5 ; JACK2.6 11.8,27.17 ; JACK2.6 9.64,26.5 ; JACK2.6 9.64,25.83 ; JACK2.6 10.72,27.17 ; JACK2.6 11.8,25.83 ; JACK2.6 10.72,25.83 ; JACK2.6 9.64,27.17 ; 12.39,13.13 JACK1.5 ; JACK1.5 14.55,13.8 ; JACK1.5 13.47,14.47 ; JACK1.5 13.47,13.13 ; JACK1.5 12.39,13.8 ; JACK1.5 14.55,14.47 ; JACK1.5 14.55,13.13 ; JACK1.5 12.39,14.47 ; JACK2.3 9.35,17 ; JACK2.3 7.19,17 ; JACK2.3 8.27,16.33 ; JACK2.3 7.19,16.33 ; JACK2.3 9.35,16.33 ; JACK2.4 6.75,17 ; JACK2.4 4.59,17 ; JACK2.4 4.59,16.33 ; JACK2.4 6.75,16.33 ; JACK2.4 5.67,16.33
  GND3 w0.203: JACK2.4 6.75,16.33 ; JACK2.4 6.75,17 ; JACK2.4 5.67,16.33 ; JACK2.4 4.59,17 ; JACK2.4 4.59,16.33 ; JACK2.6 11.8,26.5 ; JACK2.6 11.8,25.83 ; JACK2.6 11.8,27.17 ; JACK2.6 9.64,27.17 ; JACK2.6 9.64,25.83 ; JACK2.6 9.64,26.5 ; JACK2.6 10.72,27.17 ; JACK2.6 10.72,25.83 ; 12.39,14.47 JACK1.5 ; JACK1.5 13.47,13.13 ; JACK1.5 14.55,14.47 ; JACK1.5 14.55,13.13 ; JACK1.5 13.47,14.47 ; JACK1.5 12.39,13.8 ; JACK1.5 14.55,13.8 ; JACK1.5 12.39,13.13 ; 8.27,16.33 JACK2.3 ; JACK2.3 7.19,16.33 ; JACK2.3 9.35,17 ; JACK2.3 9.35,16.33 ; JACK2.3 7.19,17
  IN3 w0.508: v2(32.82,26.13) 31.38,27.57 v2(27.72,27.57)
  GND4 w0.203: 12.39,13.8 JACK1.5 ; JACK1.5 13.47,13.13 ; JACK1.5 14.55,13.13 ; JACK1.5 14.55,14.47 ; JACK1.5 12.39,14.47 ; JACK1.5 12.39,13.13 ; JACK1.5 13.47,14.47 ; JACK1.5 14.55,13.8 ; 9.64,26.5 JACK2.6 ; JACK2.6 9.64,25.83 ; JACK2.6 11.8,26.5 ; JACK2.6 10.72,27.17 ; JACK2.6 11.8,25.83 ; JACK2.6 10.72,25.83 ; JACK2.6 9.64,27.17 ; JACK2.6 11.8,27.17 ; 7.19,17 JACK2.3 ; JACK2.3 7.19,16.33 ; JACK2.3 9.35,16.33 ; JACK2.3 9.35,17 ; JACK2.3 8.27,16.33 ; JACK2.4 6.75,17 ; JACK2.4 6.75,16.33 ; JACK2.4 4.59,16.33 ; JACK2.4 4.59,17 ; JACK2.4 5.67,16.33
  IN5 w0.203: 12.39,13.8 JACK1.5 ; JACK1.5 13.47,13.13 ; JACK1.5 14.55,13.13 ; JACK1.5 14.55,13.8 ; JACK1.5 12.39,14.47 ; JACK1.5 14.55,14.47 ; JACK1.5 13.47,14.47 ; JACK1.5 12.39,13.13 ; 9.64,25.83 JACK2.6 ; JACK2.6 9.64,26.5 ; JACK2.6 11.8,25.83 ; JACK2.6 11.8,27.17 ; JACK2.6 9.64,27.17 ; JACK2.6 10.72,27.17 ; JACK2.6 11.8,26.5 ; JACK2.6 10.72,25.83 ; 4.59,17 JACK2.4 ; JACK2.4 4.59,16.33 ; JACK2.4 6.75,17 ; JACK2.4 6.75,16.33 ; JACK2.4 5.67,16.33 ; JACK2.3 9.35,16.33 ; JACK2.3 7.19,17 ; JACK2.3 8.27,16.33 ; JACK2.3 7.19,16.33 ; JACK2.3 9.35,17
  GND5 w0.203: 12.39,13.8 JACK1.5 ; JACK1.5 12.39,14.47 ; JACK1.5 14.55,14.47 ; JACK1.5 13.47,13.13 ; JACK1.5 14.55,13.13 ; JACK1.5 13.47,14.47 ; JACK1.5 12.39,13.13 ; JACK1.5 14.55,13.8 ; JACK2.6 11.8,25.83 ; JACK2.6 9.64,26.5 ; JACK2.6 9.64,27.17 ; JACK2.6 10.72,27.17 ; JACK2.6 11.8,27.17 ; JACK2.6 11.8,26.5 ; JACK2.6 9.64,25.83 ; JACK2.6 10.72,25.83 ; 8.27,16.33 JACK2.3 ; JACK2.3 7.19,16.33 ; JACK2.3 9.35,16.33 ; JACK2.3 9.35,17 ; JACK2.3 7.19,17 ; 4.59,17 JACK2.4 ; JACK2.4 6.75,17 ; JACK2.4 6.75,16.33 ; JACK2.4 4.59,16.33 ; JACK2.4 5.67,16.33
  GND6 w0.203: 7.19,16.33 JACK2.3 ; JACK2.3 9.35,16.33 ; JACK2.3 7.19,17 ; JACK2.3 8.27,16.33 ; JACK2.3 9.35,17 ; 9.64,27.17 JACK2.6 ; JACK2.6 11.8,26.5 ; JACK2.6 10.72,27.17 ; JACK2.6 9.64,26.5 ; JACK2.6 9.64,25.83 ; JACK2.6 10.72,25.83 ; JACK2.6 11.8,27.17 ; JACK2.6 11.8,25.83 ; JACK2.4 6.75,16.33 ; JACK2.4 4.59,17 ; JACK2.4 6.75,17 ; JACK2.4 4.59,16.33 ; JACK2.4 5.67,16.33 ; JACK1.5 14.55,13.8 ; JACK1.5 12.39,14.47 ; JACK1.5 14.55,13.13 ; JACK1.5 14.55,14.47 ; JACK1.5 13.47,14.47 ; JACK1.5 13.47,13.13 ; JACK1.5 12.39,13.8 ; JACK1.5 12.39,13.13
  BOTTOM w0.203: UA1.42 28.28,33.11 27.96,33.43 v2(27.96,33.61) ; UA1.30 28.24,28.31 27.95,28.02 27.95,27.8 v2(27.72,27.57) ; UA1.20 v2(32.82,26.13)
  BOTTOM w0.356: v2(18.32,15.18) 18.44,15.29 CA43.2
  BOTTOM w0.381: CA46.2 27.91,18.65 CA45.2 27.82,18.52 27.36,18.07 27.06,18.07 v2(26.81,17.81) ; CA42.2 v2(22.54,19.65)
  BOTTOM w0.508: v2(26.91,35.4) 26.91,35.4 26.97,35.46 CA15.2 ; CA28.2 31.63,24.04 31.31,23.73 CA29.2 30.96,23.36 v2(30.62,23.36) ; CA14.2 27.05,36.54 v2(27.01,36.5) ; CA26.2 CA27.2 v2(25.81,33.62) ; v2(24.92,32.57) CA33.2
VCCGT_SENSE: length 45.4
  IN4 w0.381: v2(150.76,123.73) 147.77,126.71 133.3,126.71 128.66,131.35 128.66,136.3 127.39,137.57 121.42,137.57 v2(121.33,137.66)
  BOTTOM w0.254: CPU1.AH38 152.8,120.47 152.64,120.47 152.14,120.97
  BOTTOM w0.381: PR531.2 v2(121.33,137.66) 121.34,137.65 PC508.1 ; RH203.2 151.39,123.42 151.08,123.73 v2(150.76,123.73) 150.56,123.53 150.56,121.61 151.19,120.97 152.14,120.97
VCCIO_PGOOD: length 2.8
  BOTTOM w0.114: PU509.9 122.06,118.16 122.77,118.86 PR5016.2 123.43,119.25 v1(123.72,119.54)
VCCIO_SENSE: length 66.9
  IN6 w0.254: v2(168,102.18) 168,103.61 166.77,104.85 166.77,109.1 165.06,110.81 165.06,114.24 165.46,114.64 165.46,122.04
  IN6 w0.381: 165.46,122.04 165.46,122.64 162.53,125.57 132.47,125.57 130.05,123.15 v2(130.05,122.91)
  BOTTOM w0.254: CPU1.H14 168,102.25 v2(168,102.18)
  BOTTOM w0.381: PR5017.2 125.42,121.13 127.2,122.91 v2(130.05,122.91)
VCCSA_SENSE: length 77.1
  IN6 w0.381: v2(172.47,126.4) 172.47,126.4 168.22,126.4 167.52,127.1 161.43,127.1 159.71,128.81 155.96,128.81 154.25,127.1 133.74,127.1 131.85,128.99 131.85,133.08 133.3,134.53 133.3,140.36 v2(134.03,141.09)
  BOTTOM w0.254: CPU1.M38 165.66,120.58 165.54,120.69 165.54,122.96 166.07,123.49 168.68,123.49 169.45,122.71 171.08,122.71 171.4,122.39 174.26,122.39 174.89,123.02 174.89,123.08
  BOTTOM w0.381: 174.89,123.08 174.89,123.48 174.06,124.31 RH201.1 173.37,125.95 172.93,126.4 v2(172.47,126.4) ; PR533.2 133.14,142.97 PC514.2 v2(134.03,141.09)
VCCSENSE: length 54.3
  IN4 w0.381: v2(126.17,148.51) 126.17,147.96 128.26,145.87 135.79,145.87 140.28,141.38 140.28,129.83 140.79,129.32 150.12,129.32 154.5,124.94 v2(154.5,123.6)
  BOTTOM w0.254: 154.52,120.81 154.26,120.55 154.26,119.83 154,119.56 CPU1.AG37
  BOTTOM w0.381: PR550.1 126.15,147.8 PC533.1 v2(126.17,148.51) ; v2(154.5,123.6) 154.82,123.92 155.27,123.92 155.59,123.6 RH197.2 155.53,123.42 154.94,122.83 154.94,121.62 154.52,121.21 154.52,120.81
VDD_1.2V: length 5.2
  BOTTOM w0.203: 93.75,41.88 93.49,42.13 PU201.11
  BOTTOM w0.254: PR201.1 PR203.2 PC212.1 94.94,41.66 94.73,41.88 93.75,41.88
VIN: length 123
  TOP w0.254: v2(54.3,26.32) 54.3,26.38 54.96,27.04 PR716.1 ; v2(106.85,50.1) 109.17,52.41 109.17,57.75 115.9,64.48 v4(115.9,65.5) 115.9,74.64 117.66,76.41 118.13,76.41 118.63,76.91 PR732.1 119.76,75.79 121.03,75.79 PR729.2
  IN1 w0.508: 59.13,19.46 59.13,18.83 59.13,17.37 57.57,15.81 54.1,15.81 v2(53.87,16.03)
  IN3 w0.457: 58.85,19.97 v2(59.13,19.97)
  IN3 w0.508: v2(54.3,26.32) 54.3,24.86 54.81,24.35 57.22,24.35 57.6,23.97 58.75,23.97 59.19,23.53 59.19,22.19 58.77,21.77 58.25,21.77 57.9,21.42 57.9,20.91 58.25,20.55 58.27,20.55 58.85,19.97
  IN4 w0.254: 74.37,33.94 74.88,33.94 87.02,46.08 91.06,46.08 92.76,47.78 95.7,47.78 97.31,49.4 100.26,49.4 102.55,51.68 105.27,51.68 v2(106.85,50.1)
  IN4 w0.508: 71.32,32.23 71.32,30.51 68.17,27.36 55.34,27.36 v2(54.3,26.32)
  BOTTOM w0.457: PD700.3 58.82,19.67 v2(59.13,19.97)
  BOTTOM w0.508: v2(53.87,16.03) 54.07,15.84 56.64,15.84 57,16.2 PD101.2
  vias: v2(71.32,33.75) v2(71.32,33.12) v2(71.95,33.75) v2(71.95,33.12) v2(71.95,32.53) v2(72.59,33.75) v2(72.59,33.12) v2(72.59,32.53) v2(73.22,33.75) v2(73.22,33.12) v2(73.22,32.53) v2(73.86,33.75) v2(73.86,33.12) v2(73.86,32.53) v4(73.48,40.7) v4(76.83,34.14)
VIN1N: length 3.9
  BOTTOM w0.102: RG59.2 190.56,112.11 190.56,112.71 190.66,112.81 CG62.2 190.56,113.39 190.56,113.56 190.65,113.65 190.65,113.9 190.86,114.11 UG11.11
VIN1P: length 3.9
  BOTTOM w0.102: RG62.2 190.33,112.11 190.33,112.71 190.23,112.81 CG62.1 190.33,113.39 190.33,113.65 190.42,113.74 190.42,113.91 190.21,114.12 UG11.12
VIN2N: length 3.8
  BOTTOM w0.102: UG11.14 188.54,116.28 188.33,116.49 188.16,116.49 CG63.2 187.52,116.34 187.42,116.44 187.18,116.44 187.12,116.5 186.76,116.5 RG64.2
VIN2P: length 3.8
  BOTTOM w0.102: UG11.15 188.54,116.93 188.33,116.72 188.06,116.72 CG63.1 187.52,116.77 187.42,116.67 187.28,116.67 187.22,116.73 186.76,116.73 RG66.2
VIN3N: length 3.9
  BOTTOM w0.102: RG138.2 190.42,121.1 190.42,120.43 190.36,120.36 CG183.2 190.47,119.77 190.47,119.64 190.42,119.59 190.42,119.34 190.21,119.13 UG11.1
VIN3P: length 3.9
  BOTTOM w0.102: UG11.2 190.86,119.12 190.65,119.33 190.65,119.5 190.7,119.54 190.7,119.79 CG183.1 190.79,120.36 190.65,120.5 190.65,121.15 RG137.2
VINMON: length 8.8
  TOP w0.254: v2(267.92,141.5) v1(269.2,141.5) 270.52,141.5 271.99,140.03 271.99,139.63 271.55,139.19 v2(271.5,139.19)
  BOTTOM w0.203: PU6000.27 272.01,138.87 271.69,139.19 v2(271.5,139.19)
  BOTTOM w0.254: v2(267.92,141.5) PR6000.1 PR6006.2
VSSGT_SENSE: length 49.1
  TOP w0.381: PC513.1 122.81,141.45 122.18,140.81 v2(121.95,140.81)
  IN4 w0.381: v2(152.09,123.6) 152.09,124.37 148.85,127.6 133.48,127.6 129.42,131.67 129.42,136.62 127.64,138.4 124.37,138.4 v2(121.95,140.81)
  BOTTOM w0.203: v2(121.95,140.81) 122.02,140.88 PU500.6
  BOTTOM w0.254: 152.96,120.96 153.48,120.44 153.48,119.87 153.17,119.56 CPU1.AH37
  BOTTOM w0.381: 152.96,120.96 152.08,121.84 152.08,123.59 v2(152.09,123.6) 152.1,123.59 152.59,123.59 RH472.1
VSSIO_SENSE: length 64.9
  IN6 w0.254: v2(167.19,102.6) 167.19,103.94 166.42,104.71 166.42,108.96 164.72,110.67 164.72,114.38 165.12,114.78 165.12,121.63 163.71,123.04 163.71,123.06
  IN6 w0.381: 163.71,123.06 161.97,124.8 132.84,124.8 v2(130.94,122.91)
  BOTTOM w0.254: v2(167.19,102.6) 167.71,102.6 CPU1.J14
  BOTTOM w0.381: v2(130.94,122.91) 129.99,123.86 127.07,123.86 125.23,122.02 PR5018.2
VSSSA_SENSE: length 76.8
  TOP w0.381: PC515.1 129.74,138.58 130.5,139.34 130.5,140.5 130.89,140.89 131.4,140.89 v2(131.51,141.01)
  IN6 w0.381: v2(131.51,141.01) 132.09,140.43 132.09,134.97 130.88,133.76 130.88,128.58 133.13,126.33 154.57,126.33 156.28,128.05 159.4,128.05 161.11,126.33 167.2,126.33 167.9,125.64 v2(172.47,125.64)
  BOTTOM w0.203: PU500.31 v1(130.86,140.88) 131.39,140.88 v2(131.51,141.01)
  BOTTOM w0.254: CPU1.M37 165.59,119.56 165.24,119.92 165.24,120.49 165.2,120.53 165.2,123.29 165.96,124.04 168.6,124.04 169.59,123.06 171.23,123.06 RH469.1
  BOTTOM w0.381: v2(172.47,125.64) 172.48,125.63 RH469.1
VSSSENSE: length 51.5
  TOP w0.254: PC534.1 126.61,144.64 126.05,145.2 v2(126.05,145.39)
  IN4 w0.381: v2(126.05,145.39) 126.14,145.3 126.14,145.16 126.68,144.62 129.13,144.62 130.02,143.73 132.41,143.73 133.51,144.84 135.75,144.84 139.52,141.07 139.52,129.38 140.41,128.49 149.13,128.49 153.29,124.34 153.29,123.93 v2(153.3,123.92)
  BOTTOM w0.203: PU500.18 126.27,145.16 v2(126.05,145.39)
  BOTTOM w0.254: CPU1.AG38 153.84,121.16
  BOTTOM w0.381: 153.84,121.16 153.84,121.36 154.38,121.9 154.38,122.77 153.82,123.34 RH466.1 153.73,123.49 v2(153.3,123.92)
+CODEC_AVDD2: length 14.2
  TOP w0.508: CA16.1 29.41,25.05 CA17.1 27.71,25.05 27.02,24.35 v1(27.02,23.53) 27.6,22.94 v2(29.1,22.94)
  IN6 w0.508: v2(29.1,22.94) 28.95,23.1 28.95,23.81 v2(30.88,25.75)
  BOTTOM w0.203: v2(30.88,25.75) 31.22,26.08 UA1.24
  BOTTOM w0.356: LA4.1 30.83,22.26 RA12.1
  BOTTOM w0.508: v2(29.1,22.94) 30.29,21.76 LA4.1
+EC_VCCA: length 25.2
  TOP w0.203: v2(286.84,25.37) 286.84,25.43 v4(286.29,25.98)
  TOP w0.508: v2(286.84,11.08) CE33.1 ; LE1.2 287.43,25.37 v2(286.84,25.37)
  IN1 w0.508: v2(286.84,11.08) 288.49,9.43 v2(293.75,9.43)
  BOTTOM w0.508: v2(286.84,25.37) 287.02,25.37 287.73,24.65 287.73,11.97 v2(286.84,11.08)
+FBA_VREFC: length 10.7
  BOTTOM w0.305: UG1.J14 276.55,98.43 277.03,98.91 277.03,99.97 CG78.1 276.86,101.05 276.88,101.07 ; 276.88,101.07 277.07,101.07 277.34,100.81 RG110.2 RG111.2 277.75,101.85 v1(276.89,102.7) 276.54,103.05 CG79.1 276.54,104.39 276.55,104.4 UG2.J14 ; 276.88,101.07 RG112.1
+FBB_VREFC: length 27.8
  BOTTOM w0.305: UG3.J14 261.13,58.57 CG114.1 RG123.1 RG121.2 264.51,57.7 266.81,60 266.81,66.29 268.52,68 v1(274.16,68) 276.35,68 ; 276.35,68 RG122.2 ; 276.35,68 CG113.1 276.35,70.5 276.55,70.71 UG4.J14
+FBC_VREFC: length 11
  BOTTOM w0.305: RG132.2 RG133.2 ; RG133.2 v1(230.49,57.7) 230.89,57.7 231.57,58.38 CG149.1 233.1,58.38 233.37,58.64 234.12,58.64 UG6.J14 ; RG133.2 RG134.1 CG148.1 227.37,58.57 227.02,58.91 UG5.J14
+FBD_VREFC: length 16.5
  BOTTOM w0.305: UG7.J14 199.03,88.78 198.27,88.02 198.27,87.47 ; RG156.2 RG155.2 195.54,86.79 196.22,87.47 v1(196.6,87.47) 198.27,87.47 ; RG156.2 CG256.1 ; RG156.2 CG265.1 RG154.1 ; UG8.J14 199.03,82.31 198.27,83.06 198.27,87.47
+FBX_PLLAVDD: length 79.4
  TOP w0.305: v2(244.62,88.1) 244.5,88.22 CG56.1 ; CG58.1 226.56,93.14 v2(226.32,92.9) ; v2(247.32,103.4) 247.23,103.49 CG57.1 ; v2(230.01,88.16) 229.69,88.48 CG54.1 ; v2(238.32,88.1) 237.94,88.48 237.87,88.48 CG60.1
  IN2 w0.4: v2(226.32,92.9) 226.87,93.45 226.87,102.4 226.47,102.8 220.27,102.8 218.32,104.74 212.35,104.74 211.07,106.02 205.12,106.02 v2(205.11,106.01)
  IN6 w0.381: v2(226.32,92.9) 226.33,92.9 226.94,92.29 226.94,89.77 228.42,88.29 229.69,88.29 229.83,88.16 v2(230.01,88.16) 230.44,88.16 230.99,88.71 237.71,88.71 v2(238.32,88.1) 238.93,88.71 244.01,88.71 v2(244.62,88.1) 244.79,88.1 246.2,89.51 246.2,96.88 v2(247.32,98) 246.74,98.58 246.74,102.82 v2(247.32,103.4)
  BOTTOM w0.25: v2(230.01,88.16) 230.17,88 UG9.L17
  BOTTOM w0.3: UG9.AF42 247.42,98 v2(247.32,98) ; 238.36,87.96 238.32,88 v2(238.32,88.1) ; v2(244.62,88.1) 244.62,88 UG9.L38 ; UG9.V11 226.22,92.9 v2(226.32,92.9) ; UG9.AN42 247.57,103.15 v2(247.32,103.4)
  BOTTOM w0.305: UG9.L29 238.36,87.96
  vias: v1(201.68,105.07)
+HDMI_5V_OUT: length 0.6
  TOP w0.203: v2(222.46,171.22) v4(221.85,171.22)
+IFPX_PLLVDD: length 0.8
  BOTTOM w0.25: UG9.BD18 v2(231.17,110.55) ; UG9.BD15 v2(229.07,110.55)
  vias: v1(230.45,115.2)
+INV_PWR_SRC:
  vias: v2(158.24,172.12) v2(158.24,171.51) v2(158.82,172.12) v2(158.82,171.48) v2(169.78,179.39) v2(170.11,178.9) v2(170.43,179.41) v2(170.81,178.9) v4(169.68,182.51)
+LAN_IO: length 19.7
  TOP w0.508: CL17.1 274.3,157.22 v2(274.54,156.98) ; CL16.1 272.54,157.36 v2(272.2,157.02) ; RL14.1 266.58,155.59 v2(265.71,155.59) 265.71,156.21 LL1.1 ; RL8.2 v2(242.71,172.56)
  IN4 w0.508: v2(272.2,157.02) 272.2,156.7 270.53,155.04 266.26,155.04 v2(265.71,155.59)
  BOTTOM w0.203: CL11.1 275.5,164 275.5,163.7 275.24,163.44 UL1.1 ; UL1.16 v2(272.2,157.02)
  BOTTOM w0.508: v2(278.24,163.54) 278.04,163.34 RL2.1 RL1.1 ; CL11.1 v2(275.9,165.13)
  vias: v2(270.71,168.38) v2(270.71,167.8) v2(270.71,167.21) v4(270.79,166.49)
+LCDVDD: length 1.2
  TOP w0.102: 164.37,181.2 v4(164.37,182.39)
  vias: v2(163.25,170.63) v2(163.69,171.06) v2(163.85,170.47) v2(163.85,169.86) v2(164.17,171.47) v2(164.27,170.89)
+NVVDD1: length 12.2
  TOP w0.254: v2(246.13,100.04) 246.01,100.17 PC6304.1 ; v2(243.19,89.43) 242.97,89.64 PC6302.1
  TOP w0.3: v2(241.72,90.84) 241.71,90.86 240.33,90.86 v2(240.32,90.84) 240.31,90.86 238.98,90.86 v2(238.97,90.85) ; 240.17,88.8 240.32,88.94 v2(240.32,89.49)
  TOP w0.305: v2(229.12,104.96) 229.11,104.95 v2(228.42,104.95) 228.08,104.95 PC6303.1 ; PC6331.1 228.14,97.85 v2(228.42,97.85) ; v2(233.32,89.45) 233.27,89.4 PC6350.1 ; PC6358.1 240.11,88.73 240.17,88.8 ; 240.32,88.94 240.53,88.73 PC6365.1 ; v2(228.42,92.25) 228.12,92.55 PC6353.1
  TOP w0.508: PC6328.1 v2(246.72,96.48)
  BOTTOM w0.254: RG544.1 v2(287.96,79.99)
  BOTTOM w0.3: UG9.BC49 v2(252.27,110.45)
  vias: v2(217.62,136.49) v2(217.69,135.48) v2(218.26,136.49) v2(218.32,135.48) v2(218.89,136.49) v2(218.96,135.48) v2(219.53,136.49) v2(219.59,135.48) v2(220.16,136.49) v2(220.23,135.48) v2(220.8,136.49) v2(220.86,135.48) v2(221.43,136.49) v2(221.5,135.48) v2(221.62,133.19) v2(221.62,132.3) v2(221.69,131.35) v2(221.69,130.33) v2(221.69,129.38) v2(222.07,136.49) v2(222.13,135.48) v2(222.26,133.19) v2(222.26,132.3) v2(222.32,131.35) v2(222.32,130.33) v2(222.32,129.38) v2(222.7,136.49) v2(222.77,135.48) v2(222.89,133.19) v2(222.89,132.3) v2(222.96,131.35) v2(222.96,130.33) v2(222.96,129.38) v2(223.53,133.19) v2(223.53,132.3) v2(223.59,131.35) v2(223.59,130.33) v2(223.59,129.38) v2(224.16,133.19) v2(224.16,132.3) v2(224.23,131.35) v2(224.23,130.33) v2(224.23,129.38) v2(224.86,131.35) v2(224.86,130.33) v2(224.86,129.38) v2(225.5,131.35) v2(225.5,130.33) v2(225.5,129.38) v2(226.13,131.35) v2(226.13,130.33) v2(226.13,129.38) v2(226.77,131.35) v2(226.77,130.33) v2(226.77,129.38) v2(228.42,102.15) v2(228.42,99.9) v2(228.42,95.05) v2(229.12,102.15) v2(229.12,99.92) v2(229.12,97.85) v2(229.12,95.05) v2(229.12,92.25) v2(230.52,104.96) v2(230.52,102.15) v2(230.52,97.85) v2(230.52,95.05) v2(230.52,92.25) v2(231.92,106.35) v2(231.92,104.96) v2(231.92,103.56) v2(231.92,102.15) v2(231.92,100.75) v2(231.92,96.4) v2(231.92,95.05) v2(231.92,93.65) v2(232.36,133.83) v2(232.42,134.65) v2(232.48,136.37) v2(232.48,135.54) v2(232.62,96.4) v2(232.62,95.05) v2(232.67,131.99) v2(232.67,130.72) v2(232.67,129.45) v2(233.05,134.65) v2(232.99,133.83) v2(233.12,136.37) v2(233.12,135.54) v2(233.31,131.99) v2(233.31,130.72) v2(233.31,129.45) v2(233.32,106.35) v2(233.32,104.96) v2(233.32,103.56) v2(233.32,102.15) v2(233.32,100.75) v2(233.32,96.4) v2(233.32,95.05) v2(233.32,93.65) v2(233.75,136.37) v2(233.75,135.54) v2(233.94,131.99) v2(233.94,130.72) v2(233.94,129.45) v2(234.39,136.37) v2(234.39,135.54) v2(234.58,131.99) v2(234.58,130.72) v2(234.58,129.45) v2(234.67,106.35) v2(234.67,103.55) v2(234.67,96.45) v2(234.67,93.65) v2(234.67,90.85) v2(234.72,104.95) v2(234.72,102.15) v2(234.72,99.35) v2(234.72,97.85) v2(234.72,95) v2(234.72,92.25) v2(235.02,136.37) v2(235.02,135.54) v2(235.21,131.99) v2(235.21,130.72) v2(235.21,129.45) v2(235.42,104.95) v2(235.42,102.15) v2(235.42,99.35) v2(235.42,97.8) v2(235.42,95.05) v2(235.42,92.25) v2(235.91,131.99) v2(235.91,130.72) v2(235.91,129.45) v2(236.55,131.99) v2(236.55,130.72) v2(236.55,129.45) v2(236.82,104.95) v2(236.82,102.15) v2(236.82,99.35) v2(236.82,97.8) v2(236.82,95) v2(236.82,92.25) v2(237.18,131.99) v2(237.18,130.72) v2(237.18,129.45) v2(237.82,131.99) v2(237.82,130.72) v2(237.82,129.45) v2(238.22,104.95) v2(238.22,102.15) v2(238.22,99.35) v2(238.22,97.8) v2(238.22,95) v2(238.22,92.25) v2(238.45,131.99) v2(238.45,130.72) v2(238.45,129.45) v2(238.96,136.43) v2(238.96,135.41) v2(238.96,134.4) v2(238.97,106.35) v2(238.92,104.95) v2(238.97,103.55) v2(238.92,102.15) v2(238.92,99.35) v2(238.92,97.85) v2(238.97,96.45) v2(238.92,95.05) v2(238.97,93.65) v2(238.92,92.24) v2(239.02,133.32) v2(239.09,131.99) v2(239.09,130.72) v2(239.09,129.45) v2(239.59,136.43) v2(239.59,135.41) v2(239.59,134.4) v2(239.66,133.32) v2(239.72,131.99) v2(239.72,130.72) v2(239.72,129.45) v2(240.23,136.43) v2(240.23,135.41) v2(240.23,134.4) v2(240.29,133.32) v2(240.36,131.99) v2(240.36,130.72) v2(240.36,129.45) v2(240.32,103.55) v2(240.32,102.15) v2(240.32,100.8) v2(240.32,96.45) v2(240.32,95.05) v2(240.32,93.64) v2(240.32,92.24) v2(240.86,136.43) v2(240.86,135.41) v2(240.86,134.4) v2(241.02,102.15) v2(241.02,100.8) v2(241.5,136.43) v2(241.5,135.41) v2(241.5,134.4) v2(241.72,103.55) v2(241.72,102.15) v2(241.72,100.8) v2(241.72,96.45) v2(241.72,95.05) v2(241.72,93.64) v2(241.72,92.24) v2(242.13,136.43) v2(242.13,135.41) v2(242.13,134.4) v2(243.12,104.95) v2(243.12,102.15) v2(243.12,99.35) v2(243.12,95.05) v2(243.12,92.24) v2(244.52,104.95) v2(244.52,102.15) v2(244.52,99.35) v2(244.52,97.82) v2(244.52,95.05) v2(244.52,92.24) v2(244.62,109.1) v2(245.22,104.95) v2(245.22,102.15) v2(245.22,99.35) v2(245.22,97.82) v2(245.22,95.05) v2(245.22,92.25) v2(245.87,109.15) v2(246.45,135.41) v2(246.45,134.4) v2(246.45,133.38) v2(246.45,132.43) v2(246.45,131.48) v2(246.45,130.59) v2(246.45,129.76) v2(246.67,111.25) v2(246.62,108.45) v2(246.62,107.05) v2(246.62,105.65) v2(247.09,135.41) v2(247.09,134.4) v2(247.09,133.38) v2(247.09,132.43) v2(247.09,131.48) v2(247.09,130.59) v2(247.09,129.76) v2(247.73,135.4) v2(247.72,134.4) v2(247.72,133.38) v2(247.72,132.43) v2(247.72,131.48) v2(247.72,130.59) v2(247.72,129.76) v2(248.02,111.25) v2(248.02,109.85) v2(248.02,108.45) v2(248.02,107.05) v2(248.36,135.4) v2(248.36,134.4) v2(248.36,133.38) v2(248.36,132.43) v2(248.36,131.48) v2(248.36,130.59) v2(248.36,129.76) v2(248.72,107.75) v2(249.06,135.41) v2(249.06,134.4) v2(248.99,133.38) v2(248.99,132.43) v2(248.99,131.48) v2(248.99,130.59) v2(248.99,129.76) v2(249.47,107.65) v2(249.69,135.41) v2(249.69,134.4) v2(249.69,133.38) v2(249.69,132.43) v2(249.69,131.48) v2(249.69,130.59) v2(249.69,129.76) v2(250.12,113.35) v2(250.12,111.95) v2(250.33,135.41) v2(250.33,134.4) v2(250.33,133.38) v2(250.33,132.43) v2(250.33,131.48) v2(250.33,130.59) v2(250.33,129.76) v2(250.82,112.65) v2(250.82,111.25) v2(250.96,135.41) v2(250.96,134.4) v2(250.96,133.38) v2(250.96,132.43) v2(250.96,131.48) v2(250.96,130.59) v2(250.96,129.76) v2(250.87,108.45) v2(251.6,135.41) v2(251.6,134.4) v2(251.6,133.38) v2(251.6,132.43) v2(251.6,131.48) v2(251.6,130.59) v2(251.6,129.76) v2(252.23,135.41) v2(252.23,134.4) v2(252.23,133.38) v2(252.23,132.43) v2(252.23,131.48) v2(252.23,130.59) v2(252.23,129.76) v2(252.22,115.45) v2(252.22,114.05) v2(252.87,135.41) v2(252.87,134.4) v2(252.87,133.38) v2(252.87,132.43) v2(252.87,131.48) v2(252.87,130.59) v2(252.87,129.76) v2(252.92,114.75) v2(253.5,135.41) v2(253.5,134.4) v2(253.5,133.38) v2(253.5,132.43) v2(253.5,131.48) v2(253.5,130.59) v2(253.5,129.76) v2(254.14,135.41) v2(254.14,134.4) v2(254.14,133.38) v2(254.14,132.43) v2(254.14,131.48) v2(254.14,130.59) v2(254.14,129.76) v2(258.2,136.11) v2(258.2,135.03) v2(258.2,134.08) v2(258.83,136.11) v2(258.83,135.03) v2(258.83,134.08) v2(259.47,136.11) v2(259.47,135.03) v2(259.47,134.08) v2(260.1,136.11) v2(260.1,135.03) v2(260.1,134.08) v2(260.17,132.87) v2(260.17,131.92) v2(260.74,136.11) v2(260.74,135.03) v2(260.74,134.08) v2(260.8,132.87) v2(260.8,131.92) v4(253.16,136.72)
+NVVDD2: length 41.2
  TOP w0.254: PC6377.1 237.09,103.28 v2(236.82,103.55)
  TOP w0.3: v2(228.42,96.45) v2(229.12,96.45) ; v2(245.22,100.75) v2(244.52,100.75) ; v2(244.52,96.45) v2(245.22,96.45) ; v2(228.38,100.76) 228.39,100.75 229.07,100.75 v2(229.12,100.8) ; v2(245.22,93.65) 245.19,93.62 v2(244.52,93.62) ; v2(229.12,93.65) 228.45,93.65 v2(228.43,93.67) ; v2(245.22,103.55) v2(244.52,103.55) ; v2(235.42,100.75) v2(234.77,100.75)
  TOP w0.305: v2(243.12,90.82) 243.19,90.89 PC6314.1 244.45,90.89 v2(244.52,90.82) 245.19,90.82 v2(245.22,90.85) ; PC6321.1 243.55,103.98 v2(243.12,103.55) ; v2(244.52,93.62) 244.32,93.82 PC6337.1 243.29,93.82 v2(243.12,93.65) ; v2(230.52,100.75) 230.34,100.93 PC6336.1 229.25,100.93 v2(229.12,100.8) ; v2(238.22,90.85) 238.04,91.03 PC6361.1 237.05,91.03 v2(236.82,90.8) ; v2(230.52,90.85) 230.49,90.82 PC6342.1 229.15,90.82 v2(229.12,90.85) v2(228.42,90.85) ; PC6317.1 244.63,106.24 v2(244.52,106.35) ; v2(228.42,103.55) 228.45,103.58 v2(229.12,103.58) 229.39,103.85 PC6340.1 230.22,103.85 v2(230.52,103.55) ; v2(230.52,106.38) 230.28,106.14 PC6318.1 229.36,106.14 v2(229.12,106.38) 228.48,106.38 v2(228.42,106.32) ; 237.52,95.75 237.52,95.75 v2(236.82,96.45) 236.73,96.36 235.51,96.36 v2(235.42,96.45) ; 237.52,95.75 PC6362.1 ; 237.52,95.75 v2(238.22,96.45) ; v2(228.42,98.55) v2(229.12,98.55) 229.66,99.09 PC6319.1 ; v2(229.12,93.65) 229.2,93.57 PC6341.1 230.44,93.57 v2(230.52,93.65) ; v2(244.52,100.75) 244.46,100.81 PC6316.1 243.18,100.81 v2(243.12,100.75) ; v2(244.52,103.55) 244.14,103.17 PC6339.1 ; v2(230.52,98.55) 230.19,98.22 PC6320.1 ; v2(236.82,100.75) 237.13,100.75 PC6376.1 237.9,100.75 v2(238.22,100.75) v2(238.87,100.75) ; v2(245.23,98.68) 245.21,98.7 v2(244.53,98.7) 244.17,98.34 PC6338.1 243.43,98.34 v2(243.12,98.65) ; v2(229.12,96.45) 229.13,96.46 PC6343.1 230.51,96.46 v2(230.52,96.45) ; v2(244.52,96.45) 244.48,96.49 PC6315.1 243.16,96.49 v2(243.12,96.45)
  BOTTOM w0.254: v2(251.15,119.97) 250.95,119.97 250.64,119.67 PR6425.1
  BOTTOM w0.508: RG542.1 289.96,87.94 v2(289.7,88.21)
  vias: v2(235.42,106.35) v2(235.42,103.55) v2(235.42,98.55) v2(235.42,93.65) v2(235.42,90.8) v2(236.82,106.35) v2(236.82,93.65) v2(238.22,106.35) v2(238.22,103.55) v2(238.22,98.65) v2(238.22,93.65) v2(245.92,106.97) v2(276.59,60.84) v2(276.59,60.01) v2(276.59,59.13) v2(276.59,58.36) v2(277.22,60.84) v2(277.22,60.01) v2(277.22,59.13) v2(277.22,58.36) v2(278.46,58.96) v2(278.46,58.13) v2(278.46,57.25) v2(278.46,56.17) v2(278.72,64.47) v2(279.09,58.96) v2(279.09,58.13) v2(279.09,57.25) v2(279.15,56.17) v2(279.36,64.47) v2(279.73,58.96) v2(279.79,58.13) v2(279.79,57.25) v2(279.79,56.17) v2(279.99,64.47) v2(280.42,58.96) v2(280.42,58.13) v2(280.42,57.25) v2(280.42,56.17) v2(280.69,64.47) v2(281.06,58.96) v2(281.06,58.13) v2(281.06,57.25) v2(281.06,56.17) v2(281.33,64.47) v2(281.69,58.96) v2(281.69,58.13) v2(281.69,57.25) v2(281.69,56.17) v2(282.01,60.61) v2(282.01,59.98) v2(282.33,58.96) v2(282.33,58.13) v2(282.33,57.25) v2(282.33,56.17) v2(282.65,60.61) v2(282.65,59.98) v2(282.96,58.96) v2(282.96,58.13) v2(282.96,57.25) v2(282.96,56.17) v2(283.28,60.61) v2(283.28,59.98) v2(283.6,58.96) v2(283.6,58.13) v2(283.6,57.25) v2(283.6,56.17) v2(283.92,60.61) v2(283.92,59.98) v2(284.23,58.96) v2(284.23,58.13) v2(284.23,57.25) v2(284.23,56.17) v2(284.55,60.61) v2(284.55,59.98) v2(284.87,58.96) v2(284.87,58.13) v2(284.87,57.25) v2(284.87,56.17) v2(285.19,60.61) v2(285.19,59.98) v2(285.57,58.96) v2(285.5,58.13) v2(285.5,57.25) v2(285.5,56.17) v2(285.82,60.61) v2(285.82,59.98) v2(286.14,58.13) v2(286.14,57.25) v2(286.14,56.17) v2(286.2,58.96) v2(286.46,60.61) v2(286.46,59.98) v2(286.84,58.96) v2(286.77,58.13) v2(286.77,57.25) v2(286.77,56.17) v2(287.09,60.61) v2(287.09,59.98) v2(287.47,59.02) v2(287.47,58.2) v2(287.47,57.31) v2(287.47,56.23) v2(288.11,64.93) v2(288.11,64.23) v2(288.11,59.02) v2(288.11,58.2) v2(288.11,57.31) v2(288.11,56.23) v2(288.74,64.93) v2(288.74,64.23) v2(288.74,59.02) v2(288.74,58.2) v2(288.74,57.31) v2(288.74,56.23) v2(289.38,67.53) v2(289.38,66.9) v2(289.38,66.26) v2(289.38,65.63) v2(289.38,64.93) v2(289.38,64.23) v2(290.01,67.53) v2(290.01,66.9) v2(290.01,66.26) v2(290.01,65.63) v2(290.01,64.93) v2(290.01,64.23) v2(290.65,66.26) v2(290.65,65.63) v2(290.65,64.93) v2(290.65,64.23) v2(290.71,66.9) v2(291.28,66.26) v2(291.28,65.63) v2(291.28,64.93) v2(291.28,64.23) v4(276.34,57.72)
+PEX_PLL_HVDD: length 25
  TOP w0.089: CG34.1 218.98,111.45 v1(218.83,111.6)
  TOP w0.356: v2(219.25,109.88) 218.98,110.15 CG34.1
  TOP w0.508: LG1.1 219.67,109.46 v2(219.25,109.88)
  IN6 w0.381: v2(219.25,109.88) 219.94,109.19 224.1,109.19 224.61,109.7 225.56,109.7 226.87,108.39 238.81,108.39 v2(239.52,109.1)
  BOTTOM w0.3: v2(239.52,109.1) 239.52,109.2 UG9.BB30
+PEX_VDD: length 4.5
  TOP w0.254: CG311.1 245.14,111.92 v2(243.77,110.55)
  TOP w0.305: v2(243.77,110.55) v2(243.77,109.85)
  BOTTOM w0.25: UG9.BC18 v2(231.17,109.85) ; UG9.BC17 v2(229.87,109.85) ; UG9.BC15 v2(229.07,109.85)
  BOTTOM w0.254: v2(229.02,109) 228.77,109.25 UG9.BB15
  vias: v2(231.25,52.1) v2(231.25,51.52) v2(231.25,50.93) v2(231.83,52.1) v2(231.83,51.52) v2(231.83,50.93) v2(231.97,109.85) v2(232.43,51.47) v2(232.77,50.95) v2(232.99,109) v2(233.27,109.85) v2(234.07,109.85) v2(234.12,109.1) v2(241.67,110.55) v2(241.67,109.85) v2(241.62,109.1) v2(242.47,109.85) v2(242.52,109.1) v2(243.72,109.1) v4(230.97,109.3)
+RBIAS: length 4.2
  TOP w0.102: v2(275.9,157.97) 276.37,157.97 v1(276.7,157.64)
  TOP w0.508: RL3.1 275.37,157.97 v2(275.9,157.97)
  BOTTOM w0.203: v2(275.9,157.97) 275.47,158.4 275.47,159.64 275.27,159.84 UL1.10
+RTC_CELL: length 349.8
  TOP w0.356: v2(39.49,28.29) 39.06,28.29 38.55,28.79 RA25.1
  TOP w0.381: RH531.2 216.22,34.61 RH83.1
  TOP w0.508: v2(214.08,29.79) 213.72,29.79 212.99,29.06 CH80.1 CH173.1 ; RH531.2 215.69,34.9 215.01,35.58 215.01,35.84 v2(215.03,35.86) 215.05,35.88 216.13,35.88 RH84.1 ; PD5.1 295.92,42.39 v4(296.04,42.27) 297.15,41.15 v2(297.15,36.42)
  IN2 w0.432: 209.67,25.69 208.99,25.69 208.73,25.43 207.22,25.43 207.11,25.54 206.39,25.54 206.16,25.31 205.36,25.31
  IN2 w0.508: v2(215.03,35.86) 215.87,35.02 215.87,34.25 216.58,33.54 218.89,33.54 219.71,32.72 221.64,32.72 222.56,31.81 224.57,31.81 225.55,32.79 225.55,34.3 226.18,34.93 229.56,34.93 230.49,35.86 231.61,35.86 232.14,36.38 238.64,36.38 241.35,33.67 241.35,30.35 242.64,29.05 248.1,29.05 248.93,28.23 267.85,28.23 268.83,27.25 271.24,27.25 273.82,24.67 274.46,24.67 275.34,23.78 279.16,23.78 283.35,19.6 283.35,17.53 284.43,16.45 291.7,16.45 292.73,17.48 v2(293.39,17.48) ; 209.67,25.69 210.33,25.69 210.85,26.21 210.85,27.57 212.09,28.8 212.9,28.8 213.89,29.79 v2(214.08,29.79) ; 205.36,25.31 202.32,25.31 201.83,25.79 195.77,25.79 195.09,26.47 195.09,27.74 194.33,28.51 190.56,28.51 189.05,30.02 187.63,30.02 186.79,29.18 129.99,29.18 122.04,21.23 121.33,21.23 119.69,19.6 100.59,19.6 96.1,15.11 84.25,15.11 82.61,13.47 56.61,13.47 55.44,14.64 44.82,14.64 43.93,15.53 43.93,17 43.09,17.84 37.11,17.84 33.87,21.09 33.87,23.67 34.4,24.2 34.98,24.2 37.47,26.69 37.47,27.38 38.38,28.29 v2(39.49,28.29)
  IN3 w0.381: v2(214.08,29.79) 215.91,31.61 215.91,34.98 v2(215.03,35.86)
  BOTTOM w0.203: UH1.BA22 214.51,29.4 214.26,29.75 v2(214.08,29.79)
  BOTTOM w0.508: v2(297.15,36.42) 297.52,36.05 297.52,32.77 296.28,31.53 293.01,31.53 292.5,31.02 292.5,18.36 v2(293.39,17.48)
+TBTA_VBUS: length 2.9
  BOTTOM w0.254: JUSBC1.B9 191.35,179.35 191.27,179.27 191.27,178.92 v2(191.16,178.82) ; v2(194.11,178.88) 194.11,178.98 193.85,179.24 JUSBC1.B4 ; v2(202.8,159.44) 202.66,159.59 UT4.A10 UT4.B10
  vias: v1(204.52,158.86) v2(191.65,177.03) v2(191.65,176.45) v2(193.68,176.9) v2(193.68,176.31) v2(203.12,158.95) v2(203.77,164.66) v2(203.77,164.03) v2(204.35,164.66) v2(204.35,164.03)
+V_DDR_REFA: length 5.9
  TOP w0.508: RH206.2 CD18.1 ; CD18.1 154.45,50.22 v2(154.63,50.04) ; CD18.1 RH209.1 RH484.2
  BOTTOM w0.305: JDIMM1.164 154.44,50.8 154.37,50.73 154.37,50.3 v2(154.63,50.04)
+V_DDR_REFA_R: length 64.6
  TOP w0.508: RH484.1 156.23,52.53 156.47,52.77 156.47,53.04 v2(156.36,53.16) 155.95,53.57 CH101.1
  IN4 w0.508: v2(156.36,53.16) 156.25,53.05 155.65,53.05 155.07,53.63 155.07,60.87 153.49,62.45 152.94,62.45 141.04,74.35 141.04,96.49 140.4,97.13 135.26,97.13 134.69,97.7 134.69,100.34 134.05,100.97 134.05,101.7 134.4,102.05 v2(134.63,102.05)
+V_DDR_REFB: length 5.6
  TOP w0.508: v2(154.29,40.6) 154.44,40.45 CD29.1 RH210.1 RH485.2 RH207.2
  BOTTOM w0.305: v2(154.29,40.6) 154.44,40.44 JDIMM2.164
+V_DDR_REFB_R: length 77.4
  TOP w0.508: v2(152.66,36.94) CH100.1 RH485.1
  IN4 w0.508: v2(133.33,101.25) 133.33,100.41 132.81,99.89 132.81,99.42 133.81,98.42 133.81,94.9 135.13,93.57 137.63,93.57 138.02,93.19 138.02,91.78 136.4,90.17 136.4,88.34 140.02,84.72 140.02,73.93 151.77,62.18 151.77,52.74 151.39,52.36 151.39,48.61 151.77,48.23 151.77,43.97 152.09,43.66 152.09,38.7 152.66,38.13 v2(152.66,36.94)
AC_PRESENT: length 10.1
  BOTTOM w0.089: UH1.BB15 215.14,32.64 215.35,32.43 215.72,32.43 215.81,32.33 216.51,32.33 216.69,32.15 218.48,32.15 218.97,31.66
  BOTTOM w0.107: DH1.2 223.42,29.41 222.33,30.5 RH533.1 v1(220.38,30.5) 220.13,30.5 218.97,31.66
ACDET_CHG: length 4.5
  TOP w0.203: PU700.6 56.64,24.74 55.95,25.43 v2(55.83,25.43)
  TOP w0.254: v2(55.83,25.43) 55.63,25.43 55.16,25.91 PR716.2
  BOTTOM w0.254: v2(55.83,25.43) 56.34,24.92 PC719.1 56.32,24.87 PR719.1
ACDRV_CHG: length 2.1
  TOP w0.203: 57.22,25.88 57.22,25.37 57.44,25.15 PU700.4
  TOP w0.508: PR705.2 57.07,26.03 57.22,25.88
ACIN#: length 35.3
  TOP w0.102: QE3.3 325.18,46.01 RE17.2 324.4,46.18 323.78,45.56 v2(323.6,45.56)
  TOP w0.107: v2(314.06,19.06) 313.8,18.79 UE1.24
  IN3 w0.102: v2(323.6,45.56) 322.78,45.56 321.7,44.48 321.7,41.42 321.84,41.28 321.84,38.13 321.77,38.06 321.45,37.75 321.45,35.8 315.08,29.43 315.08,20.08 v2(314.06,19.06)
AD0_0: length 1.8
  TOP w0.102: UE3.31 225.8,157.36 RE43.2
AD0_1: length 1.6
  TOP w0.107: RE27.1 186.6,24.04 UE4.31
AD0_2: length 3.6
  TOP w0.102: UE8.31 303.97,34.98 303.02,34.03 v1(303.02,33.64) 302.37,32.99 RE164.1
AD1_0: length 1.9
  TOP w0.102: RE40.2 226.19,156.86 UE3.32
AD1_1: length 3.1
  TOP w0.102: RE26.2 185.23,24.06 v1(184.53,24.75)
  TOP w0.107: RE26.2 186.1,23.59 UE4.32
AD1_2: length 6.5
  TOP w0.102: UE8.32 304.1,34.48 303.9,34.28 303.9,33.99 RE163.1 301.38,31.46 299.84,31.46 v1(299.47,31.83)
AD2_0: length 4.5
  TOP w0.102: v1(223.85,154.54) RE42.1 225.8,155.23 227.07,155.23 227.51,155.66 UE3.1
AD2_1: length 3.1
  TOP w0.102: RE29.1 183.87,22.98 v1(183.38,23.46)
  TOP w0.107: UE4.1 184.34,21.69 RE29.1
AD2_2: length 4.2
  TOP w0.102: UE8.1 305.22,33.3 304.55,32.63 304.19,32.63 v1(304.08,32.53) 303.91,32.35 RE165.2
AD3_0: length 2.8
  TOP w0.102: RE44.1 226.21,154.74 v1(227.03,154.74) 228.01,155.72 UE3.2
AD3_1: length 1.4
  TOP w0.107: RE30.1 183.89,21.19 UE4.2
AD3_2: length 3.8
  TOP w0.102: UE8.2 305.72,32.49 304.92,31.7 v1(304.92,31.19) RE162.1
AD_BID: length 8
  TOP w0.102: v1(286.93,8.3) RE64.1 RE66.2 CE28.1 291.74,8.3
  TOP w0.107: 291.74,8.3 292.74,9.3 293.25,9.3 293.54,9.02 UE5.66
ADP_I: length 287.6
  TOP w0.107: PR717.2 v2(52.97,26.32) ; UE5.65 293.14,7.2 PR23.2 285.3,6.32 284.49,7.13 284.49,14 281.98,16.51 281.98,16.96 279.99,18.95 279.99,25.91 v1(279.47,26.43) v2(279.02,26.88)
  IN2 w0.102: v2(52.97,26.32) 52.97,22.89 55.92,19.94 57.66,19.94 58.63,18.97 62.25,18.97 63.24,17.98 65.85,17.98 66.63,18.76 73.95,18.76 75.46,17.25 96.32,17.25 99.86,20.8 112.99,20.8 122.49,30.3 186.09,30.3 186.99,31.2 187.94,31.2 189.25,32.51 194.33,32.51 195.63,33.8 197.66,33.8 198.48,34.63 198.48,34.81 198.95,35.28 201.05,35.28 201.88,36.11 203.69,36.11 203.89,35.91 204.62,35.91 204.97,36.26 204.97,37.81 205.29,38.13 205.87,38.13 206.3,37.7 207.29,37.7 207.66,38.08 208.32,38.08 208.46,37.94 209.74,37.94 210.78,38.97 215.61,38.97 216.43,38.15 216.43,36.82 217.53,35.72 218.77,35.72 220.65,33.84 223.04,33.84 226.46,37.26 229.9,37.26 230.18,36.98 231.15,36.98 231.67,37.5 239.1,37.5 240.34,36.27 246.49,36.27 247.88,34.88 247.88,30.86 249.39,29.34 268.76,29.34 269.74,28.37 274.84,28.37 275.73,27.48 277.43,27.48 278.03,26.88 v2(279.02,26.88)
ADPIN: length 3.8
  TOP w0.102: v4(79.45,40.8) 79.45,39.58 v2(79.43,39.57) ; v2(79.43,39.57) v4(77.97,39.57) ; v2(79.43,39.57) v4(79.43,38.46)
ALERT#: length 23.5
  TOP w0.089: v2(220.07,114.05) 219.38,113.36 RG504.1
  IN1 w0.102: v2(220.07,114.05) 219.42,113.4 218.5,113.4 216.87,115.03 211.97,115.03 211.18,114.24 209.78,114.24 209.16,114.86 204.97,114.86 204.67,115.16 204.67,115.42 v2(205.48,116.24)
  BOTTOM w0.1: UG9.BJ3 v2(220.07,114.05)
  BOTTOM w0.102: QG501.4 204.11,116.86 204.73,116.24 v2(205.48,116.24) 205.71,116.24 v1(206.29,115.65)
ALIEN_LED_B_DRV#: length 20.4
  TOP w0.102: v1(231.47,154.38) 231.39,154.46 230.51,154.46 v2(229.82,155.16)
  TOP w0.254: v2(229.82,155.16) 229.51,155.47 UE3.5
  TOP w0.508: v2(226.45,168.47) 226.43,168.47 225.92,167.96 JLOGO.5
  IN1 w0.508: v2(226.45,168.47) 226.19,168.21 226.19,167.25 226.85,166.59 226.85,162.59 228.42,161.02 228.42,158.24 229,157.66 229,156.48 229.82,155.66 v2(229.82,155.16)
ALIEN_LED_G_DRV#: length 14.3
  TOP w0.127: v2(224.92,165.01) v1(224.92,164.2)
  TOP w0.254: v2(229.03,155.23) 229.01,155.25 UE3.4
  TOP w0.508: v2(224.92,165.01) JLOGO.4
  IN1 w0.508: v2(229.03,155.23) 229.03,155.55 228.37,156.21 228.37,157.4 227.04,158.73 227.04,160.5 226.01,161.53 226.01,162.92 224.92,164.01 v2(224.92,165.01)
ALIEN_LED_R_DRV#: length 18.9
  TOP w0.127: v1(223.12,164.55) 223.92,165.35 JLOGO.3
  TOP w0.254: UE3.3 228.51,155.35 v2(228.38,155.23)
  TOP w0.508: v2(223.72,167.74) 223.72,167.6 223.92,167.4 JLOGO.3
  IN1 w0.508: v2(223.72,167.74) 224.28,167.17 224.28,163.74 225.37,162.66 225.37,161.26 226.4,160.23 226.4,158.46 226.78,158.09 226.78,156.9 228.38,155.3 v2(228.38,155.23)
AMD#_NV: length 43.9
  TOP w0.102: UE1.17 319.4,17 318.79,16.4 v2(318.79,15.06) ; UE6.20 328.53,43.45 v2(328.4,43.59) v1(327.79,43.59)
  IN1 w0.102: v2(328.4,43.59) 329.7,42.29 329.7,41.71 330.22,41.19 333.25,41.19 334.15,40.29 334.15,36.2 330.49,32.55 330.49,31.9 v2(328.17,29.57)
  IN3 w0.102: v2(328.17,29.57) 327.47,28.87 327.47,23.94 323.69,20.17 323.69,19.52 319.23,15.06 v2(318.79,15.06)
AMP_ASEL: length 2.1
  TOP w0.107: UA4.18 35.45,14.07 v2(35.26,14.26)
  BOTTOM w0.102: v2(35.26,14.26) 35.71,14.26 v1(36.22,13.75)
AMP_I2S_BCLK: length 340
  TOP w0.107: UA4.10 38.02,10.81 38.36,11.15 v2(38.57,11.15) ; RA29.2 35.82,36.56 36.37,37.1 CA38.1 v1(37.79,37.1) 38.12,37.1 v2(38.87,36.36) ; JIO.15 326.59,16.85 v2(327.09,16.36)
  IN2 w0.102: v2(327.09,16.36) 326.64,15.91 326.63,15.91 325.98,15.26 324.25,15.26 323.8,15.71 317.33,15.71 312.54,10.93 304.42,10.93 303.45,11.89 291.52,11.89 291.46,11.95 291.45,11.95 291.26,12.14 288.71,12.14 288.02,12.82 279.05,12.82 277.14,14.74 273.94,14.74 273.33,15.35 263.25,15.35 262.31,16.28 260.89,16.28 258.39,13.77 247.57,13.77 247.36,13.56 244.25,13.56 243.87,13.93 243.87,14.12 243.45,14.55 235.11,14.55 234.79,14.23 231.39,14.23 230.59,13.43 218.99,13.43 218.74,13.68 216.36,13.68 214.15,11.47 208.09,11.47 206.74,10.13 201.19,10.13 200.53,9.47 193.96,9.47 191.98,11.44 188.02,11.44 186.9,12.57 185.87,12.57 179.82,18.61 170.02,18.61 169.48,18.08 128.06,18.08 126.45,16.47 99.69,16.47 96.75,13.53 84.9,13.53 83.26,11.89 55.39,11.89 54.4,12.88 46.31,12.88 45.14,11.72 43.85,11.72 42.81,10.67 39.04,10.67 v2(38.57,11.15)
  IN6 w0.102: v2(38.87,36.36) 37.98,35.47 37.98,28.12 39.33,26.78 39.33,14.78 37.75,13.21 37.75,11.97 v2(38.57,11.15)
AMP_I2S_BCLK_R: length 4.4
  TOP w0.102: v1(33.55,32.77) 34.59,33.81 v2(35.38,33.81)
  TOP w0.107: RA29.1 35.78,34.59 35.78,34.22 v2(35.38,33.81)
  BOTTOM w0.107: v2(35.38,33.81) 35.12,33.55 34.94,33.55 34.82,33.68 UA1.56
AMP_I2S_MCLK: length 334.4
  TOP w0.107: v2(39.32,11.59) 39.32,11.29 v1(39.06,11.03) 38.75,10.72 38.32,10.72 38.02,10.41 UA4.9 ; v2(326.45,16.36) JIO.14 ; v2(38.87,35.76) 38.59,35.48 CA39.1 RA27.2
  IN2 w0.102: v2(39.32,11.59) 39.94,10.96 42.56,10.96 44.8,13.2 54.59,13.2 55.67,12.12 83.17,12.12 84.8,13.76 96.66,13.76 99.59,16.69 126.36,16.69 127.97,18.3 169.39,18.3 169.92,18.84 179.92,18.84 185.96,12.8 186.99,12.8 188.11,11.67 192.11,11.67 193.43,10.36 206.65,10.36 207.99,11.7 214.06,11.7 216.27,13.91 218.83,13.91 219.09,13.66 230.5,13.66 231.3,14.46 234.69,14.46 235.02,14.78 243.54,14.78 244.1,14.22 244.1,14.02 244.34,13.79 247.26,13.79 247.48,14 258.29,14 260.8,16.51 262.41,16.51 263.34,15.58 273.42,15.58 274.03,14.97 277.23,14.97 279.15,13.05 290.69,13.05 291.61,12.12 303.55,12.12 304.51,11.16 312.45,11.16 317.23,15.94 323.89,15.94 324.27,15.56 325.66,15.56 v2(326.45,16.36)
  IN6 w0.102: v2(39.32,11.59) 40.34,12.62 40.34,27.73 40.73,28.11 40.73,31.24 41.23,31.74 41.23,32.61 39.28,34.57 39.28,35.35 v2(38.87,35.76)
AMP_I2S_MCLK_R: length 6.7
  TOP w0.102: v1(35.01,33.23) 35.43,33.23 36.58,34.39 v2(36.58,34.45)
  TOP w0.107: v2(36.58,34.45) 36.7,34.56 RA27.1
  BOTTOM w0.107: UA1.55 34.42,33.33 34.54,33.2 35.11,33.2 35.3,33.39 36.07,33.39 36.2,33.52 36.2,34.17 36.48,34.45 v2(36.58,34.45)
AMP_LDO_A1.5V: length 1.5
  BOTTOM w0.102: CA78.1 33.32,13.51 v1(32.98,13.16)
  vias: v2(33.98,14.26)
AUD_HP_OUT_L_CN: length 27.3
  TOP w0.102: v1(18.35,17.81) 18.07,18.09 v2(17.83,18.09)
  IN6 w0.254: JACK1.1 15.58,4.3 16.52,5.24 16.52,17.75 16.86,18.09 v2(17.83,18.09)
  BOTTOM w0.254: LA9.1 24.52,19.15 24.01,19.65 CA42.1 23.67,19.81 23.18,20.3 20.7,20.3 20.37,19.97 20.37,19.16 DA4.3 18.89,19.16 v2(17.83,18.09)
AUD_HP_OUT_R_CN: length 28.8
  TOP w0.254: v2(16.71,20.83) 16.46,20.58 v1(16.46,18.1) 16.46,15.96 17.76,14.65 18.54,14.65 v2(19.02,15.13)
  IN1 w0.254: v2(15.99,15.76) 14.72,15.76 13.97,15.01 9.53,15.01 8.32,13.8 JACK1.2
  BOTTOM w0.254: v2(15.99,15.76) 15.99,16.31 17.24,17.56 20.04,17.56 DA4.2 20.37,15.97 20.11,15.71 CA43.1 v2(19.02,15.13) ; LA10.1 16.62,22.43 16.62,20.92 v2(16.71,20.83)
AUDIO_IRQ: length 3.6
  TOP w0.102: v1(35.35,30.7) 35.56,30.91 v2(36.84,30.91)
  TOP w0.107: RA24.2 37.38,31.46 v2(36.84,30.91)
  BOTTOM w0.107: UA1.6 36.18,31.11 36.38,30.91 v2(36.84,30.91)
B+: length 522.2
  TOP w0.508: v2(74.49,9.56) 74.3,9.37 PC10.1 73.73,9.94 73.81,10.01 PR12.1 73.81,12.72 72.06,14.47 70.8,14.47 70.44,14.11 PQ3.4 ; v2(234.34,35.76) 236.34,35.76 236.58,35.52 238.49,35.52 239.56,34.44 239.56,33.1 238.8,32.33 238.8,31.69 239.85,30.64 239.85,30.61 240.28,30.18 240.85,30.18 242.46,28.57 242.46,23.27
  TOP w1.016: 108.78,72.36 109.29,72.36 112.15,69.5 112.15,62.52 107.64,58.01 107.64,57.07 106.71,56.14 104.53,56.14 104.19,55.8 101.43,55.8 100.61,54.97
  TOP w1.524: 248.33,37.43 248.27,37.37 248.27,27.97 248.17,27.87 248.17,25.37 246.07,23.27 242.46,23.27 240.22,21.03 240.22,20.73 239.53,20.04 239.53,15.78 238.96,15.21 238.96,13.57 240.18,12.35 242.77,12.35 243.14,11.98 251.99,11.98 252.61,12.61
  TOP w2.54: 98.68,54.73 98.71,54.77 98.71,57.65 101.16,60.1 101.16,64.74 108.78,72.36
  TOP w3.556: 137.99,136.11 137.99,133.57 135.26,130.84 130.76,130.84 127.45,127.54 117.67,127.54 115.47,125.34 115.47,121.27 115.45,121.25 ; 108.78,72.36 108.78,79.51 115.47,86.2 115.47,111.75 115.45,111.77
  IN1 w1.524: 207.34,6.77 207.59,6.77 208.48,7.65 208.51,7.65 208.7,7.84 223.85,7.84 224.99,6.7 ; 207.02,5.11 223.94,5.11
  IN1 w3.048: 205.24,5.81 205.22,5.79 186.45,5.79 180.74,11.5 162.98,11.5 157.74,16.73 121.2,16.73 118.79,19.15 106.31,19.15
  IN3 w3.048: 98.18,55.21 98.18,56.74 101.41,59.97 101.41,65.31 113.99,77.88 113.99,90.96 115.39,92.36 115.39,118.52
  BOTTOM w0.508: v2(74.49,9.56) 74.49,8.54 76.51,6.52 94.58,6.52 95.2,7.15 95.2,19.71 95.78,20.29 100.62,20.29 v2(102.52,22.19)
  BOTTOM w3.556: 138.06,133.45 137.23,132.62 132.58,132.62 130.88,130.91 ; 101.16,59.47 102.5,60.8 102.5,66.26 106.56,70.33 106.56,75.03 115.52,83.98 115.52,117.25
  vias: v2(55.64,33.62) v2(55.64,33.04) v2(55.64,32.44) v2(55.76,31.59) v2(55.86,34.64) v2(55.93,30.96) v2(56.24,35.08) v2(56.18,33.94) v2(56.18,33.31) v2(56.18,32.67) v2(56.18,32.04) v2(56.51,30.96) v2(56.74,35.4) v2(56.74,34.77) v2(56.74,34.13) v2(56.77,33.5) v2(56.77,32.86) v2(56.77,32.23) v2(56.77,31.59) v2(57.1,30.96) v2(57.35,32.86) v2(57.35,32.23) v2(57.35,31.59) v2(57.73,30.96) v2(57.98,32.86) v2(57.98,32.23) v2(57.98,31.59) v2(58.37,30.96) v2(58.62,32.86) v2(58.62,32.23) v2(58.62,31.59) v2(59.25,32.86) v2(59.25,32.23) v2(59.25,31.59) v2(87.96,31.59) v2(87.96,30.96) v2(87.96,30.32) v2(87.96,29.69) v2(87.96,29.05) v2(87.96,28.42) v2(88.59,30.96) v2(88.59,30.32) v2(88.59,29.69) v2(88.59,29.05) v2(88.59,28.42) v2(89.23,30.96) v2(89.23,30.32) v2(89.23,29.69) v2(89.23,29.05) v2(89.23,28.42) v2(94.62,51.05) v2(94.62,50.45) v2(95.26,51.66) v2(95.26,51.05) v2(95.26,50.45) v2(95.87,52.25) v2(95.87,51.66) v2(95.87,51.05) v2(95.87,50.45) v2(96.19,52.83) v2(96.47,52.25) v2(96.47,51.66) v2(96.47,51.05) v2(96.47,50.45) v2(96.78,52.83) v2(97.05,52.2) v2(97.48,52.76) v2(97.93,53.18) v2(102.88,21.69) v2(103.17,22.21) v2(103.5,21.72) v2(103.82,22.23) v2(104.13,21.72) v2(104.44,22.21) v2(104.66,22.83) v2(104.72,23.46) v2(104.76,21.72) v2(105.09,22.23) v2(105.23,23.15) v2(118.82,123.35) v2(118.82,122.71) v2(118.82,122.08) v2(119.4,123.35) v2(119.4,122.71) v2(119.4,122.08) v2(137.58,140.68) v2(137.58,140.1) v2(137.58,139.52) v2(137.58,138.93) v2(137.58,138.35) v2(138.16,140.68) v2(138.16,140.1) v2(138.16,139.52) v2(138.16,138.93) v2(138.16,138.35) v2(138.74,140.68) v2(138.74,140.1) v2(138.74,139.52) v2(138.74,138.93) v2(154.28,158.56) v2(154.28,157.98) v2(154.28,157.4) v2(154.54,168.95) v2(154.54,168.37) v2(154.54,167.79) v2(154.86,158.56) v2(154.86,157.98) v2(154.86,157.4) v2(155.13,168.95) v2(155.13,168.37) v2(155.13,167.79) v2(247.97,39.22) v2(248.52,39.03) v2(248.65,39.69) v2(252.59,10.95) v2(252.59,10.37) v2(253.17,10.95) v2(253.17,10.37) v2(253.75,10.95) v2(253.75,10.37) v4(83.19,42.07)
B+_BIAS: length 327.1
  TOP w0.508: v2(191.4,19.08) 191.4,19.54 191.91,20.05 R179.2
  IN2 w0.508: 69.26,9.46 70.38,8.34 82.71,8.34 84.9,10.53 97.25,10.53 98.18,11.46 111.9,11.46 115.32,14.89 127.11,14.89 128.12,15.91 170.04,15.91 v2(171.14,17.01) 179.18,17.01 188.41,7.78 206.73,7.78 208.21,9.25 214.58,9.25 216.83,11.5 232.02,11.5 232.63,12.11 242.64,12.11 243.28,11.47 251.25,11.47 251.98,12.2 259.04,12.2 259.66,12.82 266.73,12.82 267.31,13.4 268.27,13.4 269.15,12.52 277.13,12.52 280.45,9.2 287.82,9.2 288.02,9.01 292.79,9.01 292.99,8.82 295.56,8.82 296.7,7.68 301.36,7.68 303.02,9.34 318.27,9.34 319.63,10.7 323.81,10.7 v2(324.65,9.86)
  IN2 w1.524: 41.14,7.64 43.06,9.56 53.83,9.56 55.36,8.03 61.71,8.03 62.47,8.8 66,8.8 ; 36.08,6.57 31.56,6.57 31.46,6.67 30.4,6.67 29.6,5.87 29.6,5.43
  IN4 w0.254: v2(191.4,19.08) 191.27,18.96 186.83,18.96 186.04,19.74 184.1,19.74 182.99,18.64 180.68,18.64 179.05,17.01 v2(171.14,17.01)
  vias: v2(27.38,2.51) v2(27.38,1.87) v2(27.89,2.19) v2(67.06,10.24) v2(67.69,10.24) v4(66.96,11.97)
B+_VCCIO:
  vias: v2(119.06,119.93)
BATDRV_CHG: length 30.7
  TOP w0.102: v2(78.3,27.46) 78.25,27.46 v1(77.67,26.88)
  TOP w0.203: v2(57.41,19.34) 57.44,19.36 PU700.18
  TOP w0.254: v2(78.3,27.46) 78.37,27.4 PR733.2
  IN3 w0.254: v2(78.3,27.46) 78.3,21.94 75.45,19.08 70.77,19.08 70.48,18.79 65.3,18.79 65.01,19.08 62.18,19.08 61.76,18.66 58.28,18.66 57.6,19.34 v2(57.41,19.34)
BATLOW#: length 9.1
  TOP w0.102: RT14.1 RT31.2 171.36,162.9 171.36,162.95 171.52,163.1 v1(172.6,163.1) 172.82,163.1 173.11,163.39 173.11,165.37 173.33,165.59 174.09,165.59 175.07,166.57 175.07,166.78 175.6,167.31 176.14,167.31 176.37,167.54 UT1.F2
BATSRC_CHG: length 31.8
  TOP w0.203: v2(56.71,19.15) 56.71,19.27 56.96,19.51 56.96,19.53 57.04,19.61 PU700.17
  TOP w0.254: PR734.2 78.24,28.48 v2(78.2,28.52)
  IN3 w0.254: v2(56.71,19.15) 56.71,19.34 57.22,19.84 57.67,19.84 58.47,19.04 61.44,19.04 61.86,19.46 65.21,19.46 65.5,19.17 70.32,19.17 70.62,19.46 75.13,19.46 77.8,22.13 77.8,28.11 v2(78.2,28.52)
BATT+: length 0.6
  TOP w0.102: v2(81.16,21.19) v4(81.16,21.75)
BATT++: length 38.1
  TOP w0.203: v4(84.21,20.61) v4(84.21,22.56)
  IN4 w0.508: v2(84.72,20.35) 77.42,13.05 61.73,13.05 59.89,14.89 59.89,15.05 59.89,15.06 59.89,15.56 59.89,15.57 59.89,16.34 59.9,16.34 59.9,16.85 59.89,16.85 v2(59.89,19.91)
  BOTTOM w0.508: PD700.2 58.86,18.37 59.32,18.83 59.32,19.21 59.89,19.78 v2(59.89,19.91)
  vias: v2(85.35,20.35) v4(84.81,18.96)
BATT_CHG_LED: length 31.9
  TOP w0.127: v2(323.48,37.88) 323.48,37.31 v1(322.8,36.63)
  TOP w0.432: QE1.6 325.27,38.26 324.84,37.83 RE23.2
  TOP w0.457: v2(313.5,16.33) UE1.25
  TOP w0.508: v2(323.48,37.88) 324.13,37.88 324.18,37.83 RE23.2
  IN3 w0.508: v2(313.5,16.33) 313.5,16.57 314.68,17.75 315.13,17.75 316.33,18.94 316.33,22.13 316,22.46 316,29.05 323.48,36.53 v2(323.48,37.88)
BATT_CHG_LED#: length 48.8
  TOP w0.203: UE5.90 303.13,8.18 v2(303.13,6.67)
  TOP w0.432: QE1.2 324.62,40.23 v2(324.64,40.21)
  IN3 w0.508: v2(324.64,40.21) 325.32,39.52 325.32,33.88 318.59,27.14 318.59,24.29 317.85,23.56 317.85,18.15 311.11,11.4 306.41,11.4 303.13,8.13 v2(303.13,6.67)
  BOTTOM w0.127: v2(324.64,40.21) v1(323.97,40.21)
BATT_LOW_LED: length 43.8
  TOP w0.432: QE3.6 326.48,43.61 326.85,43.98 v2(327.03,43.98)
  TOP w0.457: v2(314.84,16.35) 315.4,16.9 UE1.22
  TOP w0.508: RE21.2 327.4,46.18 v1(327.91,45.68) 327.91,44.6 327.29,43.98 v2(327.03,43.98)
  IN3 w0.508: v2(327.03,43.98) 326.58,43.98 325.76,44.8 323.65,44.8 323.29,44.44 323.29,42.98 324,42.26 324,39.95 324.37,39.58 324.37,36.16 317.74,29.53 317.74,24.34 317.22,23.82 317.22,18.41 315.16,16.35 v2(314.84,16.35)
BATT_LOW_LED#: length 57
  TOP w0.203: v2(304.4,6.76) 304.34,6.83 UE5.93
  TOP w0.432: v2(324.59,44.06) 325.45,44.06 325.83,44.44 QE3.2
  IN3 w0.508: v2(324.59,44.06) 324.83,44.06 325.34,43.55 325.34,42.91 326.59,41.65 326.59,33.35 320.91,27.67 320.91,25.43 320.48,25 320.48,22.63 320.05,22.19 320.05,18.55 315.54,14.03 315.54,11.1 314.57,10.13 306.94,10.13 304.4,7.6 v2(304.4,6.76)
  BOTTOM w0.102: v2(324.59,44.06) 323.78,43.25 v1(323.78,42.75)
BATT_PRS: length 7.8
  TOP w0.254: v2(82.82,9.69) 82.43,9.69 v1(81.82,10.3) 81.28,10.83 PR22.1
  BOTTOM w0.508: PBATT1.7 v2(82.82,9.69)
BBS_BIT0: length 3.2
  TOP w0.089: v1(210.89,26.85) 211.6,26.14 RH130.2
  TOP w0.107: v2(211.82,24.89) 211.6,25.11 RH130.2
  BOTTOM w0.089: UH1.AT29 212.12,25.19 v2(211.82,24.89)
BEEP#: length 320
  TOP w0.102: v2(36.21,51.16) 36.65,50.72 36.65,39.76 v1(39.7,36.71) 39.86,36.55 39.86,33.76 40.41,33.21 41.13,33.21 41.62,32.72 41.62,31.09 41.73,30.98 41.73,25.11 41.08,24.46 DA1.2
  TOP w0.107: UE5.23 296.74,24.68 295.97,25.44 v2(295.97,26.89)
  IN2 w0.102: v2(36.21,51.16) 37.56,49.82 44.81,49.82 46.2,48.43 57.9,48.43 58.37,48.9 66.18,48.9 67.94,47.14 82.6,47.14 84.61,49.14 85.7,49.14 86.15,48.7 93.41,48.7 93.73,49.02 96.7,49.02 96.97,48.75 107.99,48.75 109.19,49.95 123.77,49.95 124.44,49.28 127.48,49.28 128.77,48 172.94,48 173.05,47.89 174.48,47.89 174.94,47.43 178.98,47.43 180.22,48.67 182.76,48.67 185.72,51.64 201.14,51.64 202.33,52.83 207.12,52.83 210.68,49.27 210.68,48.31 210.91,48.08 215.71,48.08 216.09,48.46 222.7,48.46 223.31,47.84 223.31,45.83 224.09,45.05 224.09,44.09 225.7,42.48 230.73,42.48 236.71,48.46 241.58,48.46 241.69,48.57 251.28,48.57 255.83,44.02 268.17,44.02 273.31,38.88 273.31,37.08 275.63,34.76 275.74,34.76 276.98,33.52 283.39,33.52 285.78,31.13 287.24,31.13 287.68,30.69 290.57,30.69 293.29,27.97 294.4,27.97 295.48,26.89 v2(295.97,26.89)
