# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSI18: length 103.8
  TOP w0.102: v2(236.43,29.75) 236.43,29.74 236.84,29.33 v1(237.59,29.33)
  TOP w0.107: v2(299.51,10.31) 299.54,10.28 UE5.81 ; v2(236.43,29.75) 236.01,29.75 RE500.2 235.89,29.16 235.85,29.12 QE47.3
  IN3 w0.102: v2(236.43,29.75) 236.84,30.16 239.3,30.16 239.37,30.22 242.38,30.22 243.16,31.01 246.94,31.01 246.97,30.99 247.62,30.99 250.24,33.61 250.24,39.7 251.71,41.17 264.69,41.17 272.99,32.87 274.63,32.87 276.89,30.6 287.93,30.6 292.9,25.62 300,25.62 302.99,22.63 302.99,19.93 303.71,19.22 303.71,15.2 303.37,14.86 303.37,12.77 303.08,12.48 300.49,12.48 299.09,11.08 299.09,10.73 v2(299.51,10.31)
KSI19: length 106.2
  TOP w0.102: RE499.2 233.33,29.62 v1(233.26,29.55)
  TOP w0.107: v2(299.51,10.89) 299.94,10.46 UE5.82 ; RE499.2 234.12,29.25 234.45,28.92 234.83,28.92 v2(234.95,28.81) 234.51,28.38 234.51,27.58 234.32,27.39 QE47.6
  IN3 w0.102: v2(234.95,28.81) 234.95,28.84 236.49,30.39 239.21,30.39 239.27,30.45 242.28,30.45 243.07,31.24 245.33,31.24 246.74,32.65 246.74,34.36 249.97,37.59 249.97,39.76 251.61,41.4 264.79,41.4 273.09,33.1 274.72,33.1 276.99,30.83 288.02,30.83 293,25.85 300.1,25.85 303.22,22.73 303.22,20.02 303.93,19.31 303.93,15.1 303.6,14.76 303.6,12.67 303.17,12.25 300.59,12.25 299.51,11.17 v2(299.51,10.89)
KSI20: length 111.3
  TOP w0.102: v2(300.45,10.29) 301.11,10.29 301.3,10.1 301.3,9.2 301.14,9.04 ; UE5.85 v1(301.14,6.62)
  TOP w0.107: QE48.3 235.85,25.9 235.89,25.94 RE505.2 235.95,26.45 v2(236.43,26.45) ; 301.14,9.04 UE5.85
  IN3 w0.102: v2(300.45,10.29) 300.04,10.7 300.04,11.38 300.68,12.02 303.27,12.02 303.82,12.58 303.82,14.67 304.16,15.01 304.16,19.4 303.45,20.12 303.45,22.82 300.19,26.08 293.09,26.08 288.12,31.06 277.08,31.06 274.82,33.32 273.18,33.32 264.88,41.62 251.52,41.62 249.74,39.85 249.74,37.68 246.52,34.46 246.52,32.74 245.24,31.46 242.97,31.46 242.19,30.68 239.18,30.68 239.11,30.61 236.39,30.61 235.21,29.43 235.02,29.43 234.64,29.43 234.3,29.09 234.3,26.7 234.55,26.45 v2(236.43,26.45)
KSI21: length 112.8
  TOP w0.102: QE48.6 233.95,23.02 v1(234.11,22.85)
  TOP w0.107: RE506.2 234.03,26.11 234.45,25.69 234.83,25.69 v2(234.95,25.57) 234.51,25.14 234.51,24.34 234.32,24.15 QE48.6 ; UE5.86 301.54,10.34 300.99,10.89 v2(300.45,10.89)
  IN3 w0.102: v2(234.95,25.57) 234.07,26.45 234.07,29.18 234.55,29.66 235.12,29.66 236.3,30.84 239.02,30.84 239.08,30.91 242.09,30.91 242.88,31.69 245.15,31.69 246.29,32.84 246.29,34.55 249.51,37.78 249.51,39.95 251.42,41.85 264.98,41.85 273.28,33.55 274.91,33.55 277.18,31.29 288.21,31.29 293.19,26.31 300.1,26.31 300.29,26.31 303.68,22.92 303.68,21.04 304.59,20.13 304.59,17.27 304.39,17.06 304.39,14.91 304.05,14.57 304.05,12.48 303.36,11.79 300.95,11.79 300.45,11.3 v2(300.45,10.89)
KSO0: length 91.9
  TOP w0.102: v2(232.6,33.46) 232.42,33.28 232.42,30.87 231.94,30.39 231.94,26.16 231.5,25.72 RE513.1 ; UE5.39 287.62,19.81 285.29,22.14 285.29,24.56 284.49,25.36 v1(284.49,28.52) 284.49,33.57 284.26,33.8 284.26,37.81 v2(284.23,37.84)
  IN1 w0.102: v2(284.23,37.84) 283.8,37.41 282.69,37.41 280.86,39.24 273.88,39.24 268.21,44.91 250.2,44.91 247.2,41.92 245.06,41.92 243.33,40.19 239.97,40.19 234.49,34.7 233.72,34.7 233.05,34.04 233.05,33.92 v2(232.6,33.46)
KSO1: length 78.2
  TOP w0.102: v2(284.5,24.77) v1(284.9,24.38) 285.06,24.22 285.06,22.05 287.69,19.41 UE5.40
  TOP w0.107: RE516.1 223.12,22.61 v2(222.77,22.26)
  IN3 w0.091: 222.77,22.23 v2(222.77,22.26)
  IN3 w0.102: v2(284.5,24.77) 278.93,24.77 277.43,26.27 267.5,26.27 266.71,27.06 247.72,27.06 244.04,23.38 239.81,23.38 236.14,19.72 231.12,19.72 230.96,19.56 230.23,19.56 229.28,20.51 226.48,20.51 226.13,20.86 224.14,20.86 222.77,22.23
KSO2: length 91
  TOP w0.102: v2(283.47,37.84) v1(283.89,37.42) 284.03,37.28 284.03,33.7 284.1,33.63 284.1,23.94 284.83,23.21 284.83,21.94 287.76,19.01 UE5.41 ; 231,28.96 231.47,29.43 231.47,30.56 231.91,31.01 231.91,33.55 231.72,33.74 v2(231.72,34.12)
  TOP w0.107: RE520.1 231,28.96
  IN1 w0.102: v2(283.47,37.84) 283.47,37.87 281.57,39.78 273.99,39.78 268.4,45.37 253.5,45.37 252.91,45.97 250.48,45.97 246.88,42.37 244.87,42.37 243.14,40.65 239.78,40.65 235.81,36.67 232.85,36.67 231.72,35.54 v2(231.72,34.12)
KSO3: length 121
  TOP w0.102: RE524.1 v1(231.96,23.62) 232.18,23.84 232.18,30.31 232.65,30.77 232.65,32.93 233.02,33.29 v2(233.3,33.29)
  TOP w0.107: UE5.42 292.46,18.61 292.57,18.51 292.57,11.58 v2(292.8,11.35)
  IN1 w0.097: v2(287.47,37.24) 286.97,37.75 284.74,37.75
  IN1 w0.102: v2(233.3,33.29) 233.3,33.95 233.82,34.47 234.58,34.47 240.07,39.96 243.43,39.96 245.15,41.69 247.3,41.69 250.29,44.69 268.11,44.69 273.79,39.01 280.75,39.01 282.58,37.18 284.17,37.18 284.74,37.75
  BOTTOM w0.107: v2(287.47,37.24) 287.66,37.06 287.66,32.02 291.79,27.89 291.79,13.42 292.8,12.41 v2(292.8,11.35) 292.44,11.35 290.57,9.48 286.22,9.48 285.17,8.44 JEC.1
KSO4: length 88
  TOP w0.102: UE5.43 290.31,18.21 290.01,18.51 v1(288.43,18.51) 287.93,18.51 284.59,21.85 284.59,23.12 283.87,23.85 283.87,33.53 283.8,33.6 283.8,36.87 v2(282.83,37.84)
  TOP w0.107: RE528.1 230.32,32.71 230.32,33.24 v2(230.84,33.76)
  IN1 w0.102: v2(282.83,37.84) 281.18,39.5 273.95,39.5 268.3,45.14 250.1,45.14 247.11,42.15 244.97,42.15 243.24,40.42 239.88,40.42 235.9,36.44 232.95,36.44 232.13,35.62 232.13,33.95 231.8,33.62 230.98,33.62 v2(230.84,33.76)
KSO5: length 168.1
  TOP w0.102: v2(140.47,7.5) 140.17,7.5 v1(138.67,6)
  TOP w0.107: UE5.44 289.93,17.81 v2(289.63,17.51)
  IN4 w0.102: v2(140.47,7.5) 141.89,8.91 147.79,8.91 153.67,14.79 172.58,14.79 175.12,12.25 181.24,12.25 184.08,15.09 191.99,15.09 193.99,13.09 194.18,13.09 196.4,13.09 196.63,13.32 205.6,13.32 207.5,11.42 219,11.42 221.32,13.75 225.29,13.75 225.93,13.11 246.47,13.11 246.91,12.67 254.9,12.67 255.34,13.11 259.13,13.11 259.99,13.98 264.14,13.98 265.59,15.42 268.6,15.42 268.9,15.12 280.11,15.12 281.47,16.48 288.6,16.48 v2(289.63,17.51)
  BOTTOM w0.107: JKB2.4 140.38,7.41 v2(140.47,7.5) 140.38,7.59 JKB2.3
LAN_ACTIVITY#: length 59.8
  TOP w0.102: JLAN.10 v1(245.09,169.17) 244.83,169.17 243.96,170.03 CL27.1
  IN1 w0.102: v2(242.71,158.72) 259.09,158.72 260.8,157 266.52,157 268.97,159.46 268.97,161.23 269.74,162.01 269.74,163.02 270.79,164.07 272.75,164.07 v2(273.99,165.3)
  IN2 w0.102: v2(242.71,158.72) 242.71,163.54 243.94,164.78 243.94,168.4 244.71,169.17 JLAN.10
  BOTTOM w0.102: v2(273.99,165.3) 273.4,164.71 UL1.38
LAN_LED2#: length 18.7
  TOP w0.508: RL15.1 264.63,156.64 265.13,157.14 265.13,157.91 264.63,158.41 CL29.1 264.36,159.1 264.96,159.7 264.96,159.71 266.12,160.87 v1(266.12,165.51) 266.12,166.6 263.56,169.17 JLAN.13
LAN_LED2#_R: length 10.1
  TOP w0.508: RL15.2 264.51,155.57 v2(264.99,155.57)
  BOTTOM w0.203: UL1.23 269.17,160.64 268.96,160.85 268.36,160.85
  BOTTOM w0.508: v2(264.99,155.57) 264.99,157.8 v1(265.15,157.96) 265.15,158.58 265.11,158.62 265.11,159.48 266.48,160.85 268.36,160.85
LAN_LINK#: length 21.9
  TOP w0.102: JLAN.11 258.8,169.17 259.79,168.18 v1(262.8,168.18) 263.85,168.18 265.69,166.34 265.69,161.05 264.31,159.67 264.31,159.66 263.47,158.82 CL28.1 262.39,158.41 262.17,158.19 262.17,156.97 262.51,156.64 RL13.1
LAN_LINK#_R: length 20.5
  TOP w0.102: v2(274.57,165.28) 274.33,165.04 RL4.2 275.18,164.6 277.06,162.72 277.06,161.93 278.58,160.41 v1(278.58,159.48) 278.58,158.85 276.08,156.34 270.94,156.34 QL3.2
  BOTTOM w0.102: UL1.39 273.8,164.61 274.04,164.85 274.14,164.85 v2(274.57,165.28)
LAN_MDIN0: length 38.6
  IN6 w0.076: v2(274.79,155.25) 274.82,155.25 275.02,155.06 275.02,154.77 274.66,154.41 272.16,154.41 271.42,155.15 264.75,155.15 264.44,155.46 248,155.46 246.48,156.97 246.48,157.36 246.73,157.61 v2(246.76,157.61)
  BOTTOM w0.089: TL1.11 247.11,156.53 247.02,156.62 246.51,156.62 246.42,156.71 246.42,157.28 246.74,157.61 v2(246.76,157.61) ; UL1.12 273.8,158.49 273.88,158.41 273.88,156.44 274.6,155.72 274.87,155.72 274.96,155.63 274.96,155.42 v2(274.79,155.25)
LAN_MDIN1: length 31.1
  IN1 w0.076: v2(272.82,155.14) 273.18,154.78 273.18,154.62 273.12,154.56 271.78,154.56 271.06,155.28 266.97,155.28 265.95,156.31 252.42,156.31 251.53,157.19 251.53,157.27 251.71,157.44 251.71,157.49 251.82,157.61 v2(251.9,157.61)
  BOTTOM w0.089: TL1.7 252.19,156.47 252.1,156.56 251.64,156.56 251.55,156.65 251.55,157.28 251.88,157.61 v2(251.9,157.61) ; UL1.15 272.6,158.49 272.68,158.41 272.68,156.6 272.9,156.38 272.9,155.22 v2(272.82,155.14)
LAN_MDIN2: length 24.3
  IN6 w0.076: v2(254.38,157.61) 254.36,157.61 254.02,157.27 254.02,156.93 254.68,156.27 267.07,156.27 267.24,156.1 269.21,156.1 v2(269.38,156.27)
  BOTTOM w0.089: v2(269.38,156.27) 269.57,156.08 270.61,156.08 v3(271.05,156.52) 271.5,156.97 271.5,158.38 271.4,158.49 UL1.18 ; TL1.5 254.73,156.41 254.58,156.56 254.14,156.56 254.04,156.66 254.04,157.28 254.36,157.61 v2(254.38,157.61)
LAN_MDIN3: length 16.4
  IN6 w0.076: v2(259.46,157.61) 259.29,157.44 259.29,157.16 259.37,157.08 v2(268.71,157.08)
  BOTTOM w0.089: v2(259.46,157.61) 259.12,157.26 259.12,156.78 259.34,156.56 259.74,156.56 259.81,156.5 TL1.1 ; UL1.21 269.3,159.84 268.82,159.35 268.82,157.18 v2(268.71,157.08)
LAN_MDIP0: length 38.6
  IN6 w0.076: v2(275.38,155.25) 275.24,155.12 275.24,154.68 274.75,154.19 272.07,154.19 271.33,154.93 264.66,154.93 264.35,155.24 247.9,155.24 246.26,156.88 246.26,157.45 246.26,157.45 246.26,157.52 v2(246.18,157.61)
  BOTTOM w0.089: TL1.12 245.84,156.39 246.18,156.73 v2(246.18,157.61) ; UL1.11 274.2,158.49 274.12,158.41 274.12,156.54 274.7,155.96 274.98,155.96 275.21,155.73 275.21,155.42 v2(275.38,155.25)
LAN_MDIP1: length 31
  IN1 w0.076: v2(251.31,157.61) 251.31,157.44 251.31,157.1 252.33,156.08 265.85,156.08 266.88,155.06 270.96,155.06 271.69,154.34 273.21,154.34 273.4,154.52 v2(273.4,155.14)
  BOTTOM w0.089: v2(273.4,155.14) 273.14,155.4 273.14,156.48 272.92,156.7 272.92,158.41 273,158.49 UL1.14 ; TL1.8 250.92,156.45 251.31,156.85 v2(251.31,157.61)
LAN_MDIP2: length 24.3
  IN6 w0.076: v2(253.8,157.61) 253.8,156.83 254.59,156.04 266.98,156.04 267.15,155.87 269.19,155.87 v2(269.38,155.68)
  BOTTOM w0.089: UL1.17 271.8,158.49 271.74,158.43 271.74,156.87 270.71,155.84 269.53,155.84 v2(269.38,155.68) ; TL1.6 253.46,156.45 253.8,156.79 v2(253.8,157.61)
LAN_MDIP3: length 16.4
  IN6 w0.076: v2(258.88,157.61) 259.07,157.42 259.07,157.06 259.28,156.85 268.35,156.85 v2(268.71,156.49)
  BOTTOM w0.089: TL1.2 258.54,156.51 258.88,156.86 v2(258.88,157.61) ; UL1.20 270.6,158.73 269.8,157.93 269.8,157.39 269.12,156.71 268.9,156.71 268.81,156.62 268.81,156.58 v2(268.71,156.49)
LCD_TEST: length 307.6
  TOP w0.107: v2(166.94,178.96) 166.62,179.28 JEDP.31 ; UE5.72 295.94,9.04 295.84,9.14 295.84,13.44 296.35,13.95 296.35,15.04 295.96,15.42 295.96,16.97 v2(296.42,17.43)
  IN4 w0.102: v2(296.62,30.45) 296.2,30.03 292.65,30.03 291.92,29.3 281.42,29.3 280.65,30.07 276.26,30.07 274.89,28.7 268.95,28.7 264.95,24.7 260.63,24.7 260.03,25.29 257.71,25.29 256.33,26.68 252.38,26.68 251.43,25.72 244.19,25.72 243.56,26.35 243.56,28.63 242.13,30.05 242.13,31.32 242.83,32.01 242.83,33.8 242.6,34.03 242.04,34.03 241.78,34.3 241.78,34.3 241.55,34.53 241.55,36.05 239.66,37.94 233.47,37.94 232.21,39.2 231.04,39.2 230.02,38.18 224.6,38.18 222.13,40.65 218.85,40.65 218.73,40.53 211.59,40.53 210.65,41.47 210.65,42.17 209.68,43.14 205.98,43.14 204.81,41.97 203.21,41.97 186.45,58.73 186.45,62.58 186.94,63.07 186.94,65.29 186.35,65.88 186.35,67.34 186.6,67.59 186.6,72.04 186.02,72.62 186.02,81.02 187.08,82.08 187.08,92.54 185.28,94.35 185.28,98.93 185.47,99.12 185.47,110.35 186.78,111.65 186.78,114.37 187.96,115.55 187.96,118.82 193.07,123.93 193.07,127.63 193.76,128.31 193.76,129.44 194.38,130.06 194.38,135.42 194.51,135.55 195.31,136.35 195.31,137.17 194.8,137.68 194.8,145.42 191.31,148.91 191.31,150.83 189.86,152.28 189.86,154.41 188.42,155.85 185.17,155.85 184.65,156.37 182.32,156.37 180.56,158.12 178.98,158.12 178.67,158.44 177.1,158.44 175.52,160.03 170.72,160.03 170.05,160.7 170.05,168.08 169.43,168.7 169.43,172.31 168.16,173.58 168.16,177.74 v2(166.94,178.96)
  BOTTOM w0.102: v2(296.62,30.45) v1(296.62,29.85) 296.62,29.43 294.81,27.62 294.81,19.06 296.42,17.46 v2(296.42,17.43)
LDO2-CAP: length 5.1
  BOTTOM w0.203: UA1.22 32.02,25.41 32.55,24.88 CA28.1
  BOTTOM w0.254: RA12.2 32.28,22.7 32.71,23.13 CA29.1 32.71,24.69 CA28.1
LG_3V: length 16.4
  IN1 w1.016: 47.74,31.21 49.73,31.21 51,32.48 51,35.72 56.4,41.12 56.4,41.88
  BOTTOM w0.102: v2(55.57,43.41) 55.57,43.3 v1(56.21,42.67)
  vias: v2(46.17,31.46) v2(46.17,30.87) v2(55.13,43.85)
LG_5V: length 7.4
  TOP w0.102: v2(48.4,35.59) 48.46,35.52 v1(48.9,35.52)
  IN1 w1.016: 48.11,36.96 48.11,38.16 52.15,42.2
  vias: v2(47.95,36.04) v2(52.59,43.79) v2(52.59,43.15)
LG_+1VALWP: length 8.9
  IN1 w1.016: 255.8,18.61 253.87,16.68 247.72,16.68
  vias: v1(246.47,15.4) v2(246.69,16.39) v2(247.06,15.91) v2(256.55,19.2) v2(256.68,18.6)
LID_SW#: length 41.3
  TOP w0.102: v1(312.78,23.72) 312.9,23.72 v2(313.71,22.9)
  TOP w0.203: CE43.1 RE70.2 309.01,16.75 308.59,16.75 308.33,17.01 UE5.115
  TOP w0.254: v2(325.7,25.94) 326.05,25.94 326.78,25.21 326.78,21.43 327.28,20.94 327.28,19.64 326.99,19.36 JIO.20 ; v2(313.71,22.9) 313.2,22.39 DE1.1 ; CE43.1 v2(308.43,17.73)
  IN1 w0.254: v2(325.7,25.94) 324.18,25.94 323.86,26.26 323.86,27.78 323.22,28.42 321.89,28.42 321.13,27.65 318.44,27.65 313.71,22.92 v2(313.71,22.9) 313.15,22.35 313.15,18.22 312.28,17.34 309.98,17.34 309.59,17.73 v2(308.43,17.73)
LINE1_JD: length 39.2
  TOP w0.107: RA36.2 38.89,30.07 39.5,30.07 v2(39.56,30.01)
  IN2 w0.254: v2(39.56,30.01) 39.37,30.19 38.81,30.19 38.05,30.96 38.05,33.69 36.63,35.1 34,35.1 32.8,36.31 27.71,36.31 27.42,36.02 26.47,36.02 22.87,32.42 22.87,30.89 21.03,29.05 19.5,29.05 17.6,27.15 15.76,27.15 15.11,26.5 JACK2.5
  BOTTOM w0.102: v2(39.56,30.01) 39.56,30.52 v1(41,31.96)
LINE1_L:
  vias: v1(24.18,30.14)
LINE1_R:
  vias: v1(27.54,29.93)
LINE1_VREFO_L: length 11.5
  TOP w0.102: v1(27.56,31.79) 27.78,32.02 v2(27.78,32.38)
  TOP w0.254: RA41.1 25.66,26.57 25.92,26.32 v2(25.92,26)
  IN6 w0.203: v2(27.78,32.38) 25.75,32.38 25.18,31.8 25.18,27.19 25.92,26.45 v2(25.92,26)
  BOTTOM w0.203: UA1.40 27.85,32.31 v2(27.78,32.38)
LINE1_VREFO_R: length 12.2
  TOP w0.127: RA40.1 26.3,25.11 v1(26.39,25.03)
  TOP w0.254: RA40.1 25.29,25.19 v2(25.29,26.02)
  IN6 w0.254: v2(25.29,26.02) 25.29,26.44 24.67,27.06 24.67,31.72 v2(24.58,31.81)
  BOTTOM w0.203: UA1.39 28.22,31.91 28.21,31.9 24.67,31.9 v2(24.58,31.81)
LINE-IN-L: length 7
  TOP w0.254: v2(25.35,17.75) 25.35,18.21 v1(25.11,18.45) 22.84,20.72 RA38.1
  BOTTOM w0.254: v2(25.35,17.75) 25.35,17.55 RA35.2 25.99,16.8 25.41,16.8 25.14,17.06 LA9.2
LINE-IN-R: length 3.5
  TOP w0.102: v2(18.58,21.57) 18.16,21.57 v1(18.06,21.47)
  TOP w0.254: v2(18.58,21.57) 18.72,21.43 RA39.1 19.34,20.9 RA37.2
  BOTTOM w0.254: v2(18.58,21.57) 18.41,21.73 LA10.2
LOGO_LED_B_DRV#: length 17.9
  TOP w0.127: v2(232.48,156.39) v1(233.27,156.39)
  TOP w0.254: v2(232.48,156.39) 232.48,156.5 232.12,156.86 UE3.9
  TOP w0.508: v2(231,168.21) 230.72,167.93 229.62,167.93 228.92,167.22 JLOGO.8
  IN1 w0.508: v2(231,168.21) 231,167.71 230.77,167.48 230.77,161.85 232,160.62 232,156.87 v2(232.48,156.39)
LOGO_LED_G_DRV#: length 20.8
  TOP w0.127: v1(227.49,164.6) 227.92,165.03 JLOGO.7
  TOP w0.254: UE3.8 231.01,155.52 v2(231.36,155.16)
  TOP w0.508: v2(228.48,168.94) 227.92,168.38 JLOGO.7
  IN1 w0.508: v2(231.36,155.16) 231.36,160.36 230.01,161.71 230.01,163.3 228.97,164.34 228.97,167.06 228.48,167.55 v2(228.48,168.94)
LOGO_LED_R_DRV#: length 20.1
  TOP w0.127: v1(233.33,154.26) 232.85,154.74 230.95,154.74 v2(230.65,155.04)
  TOP w0.254: v2(230.65,155.04) 230.01,155.68 UE3.6
  TOP w0.508: v2(226.82,167.69) 226.82,167.51 226.92,167.41 JLOGO.6
  IN1 w0.508: v2(226.82,167.69) 226.82,167.51 228.32,166.01 228.32,164.09 229.37,163.04 229.37,160.3 229.87,159.8 229.87,156.89 230.65,156.1 v2(230.65,155.04)
LPC_AD0: length 110.3
  TOP w0.114: v2(300.3,18.19) 300.3,19.91 301.94,21.55 UE5.10
  IN6 w0.081: v2(300.3,18.19) 299.56,17.45 296.96,17.45 296.26,18.15 273.01,18.15 271.57,19.6 269.63,19.6 268.73,20.5 260.54,20.5 255.82,25.22 248.22,25.22 244.93,21.93 244.93,18.87 243.61,17.56 235.67,17.56 235.03,18.2 232.1,18.2 232.02,18.29 227.34,18.29 224.7,20.93 224.7,22.8 221.67,25.82 221.67,26.09 219.28,28.49 219.18,28.49 ; 218.17,28.49 216.74,28.49 216,29.23 215.18,29.23 214.26,30.15 212.49,30.15 v2(212.03,29.7)
  IN6 w0.089: 219.18,28.49 218.17,28.49
  BOTTOM w0.089: UH1.AT22 212.22,29.5 v2(212.03,29.7)
LPC_AD1: length 111.5
  TOP w0.114: UE5.8 302.74,21.73 300.54,19.53 300.54,18.57 300.71,18.4 300.71,18 v2(300.81,17.9)
  IN6 w0.081: 219.18,26.56 219.25,26.49 219.91,26.49 221.14,25.26 221.94,25.26 223.83,23.38 223.83,21.5 227.25,18.08 231.93,18.08 232.02,18 234.94,18 235.59,17.35 244.69,17.35 245.78,18.44 245.78,22.49 248.3,25.01 255.74,25.01 261.85,18.9 267.54,18.9 268.09,18.35 270.97,18.35 271.97,17.35 275.59,17.35 276.24,16.7 286.24,16.7 286.41,16.87 296.63,16.87 297,17.24 300.15,17.24 v2(300.81,17.9) ; v2(212.81,29.75) 213.32,29.24 214.79,29.24 215.08,28.95 215.92,28.95 216.59,28.28 217.99,28.28 218.64,27.63
  IN6 w0.089: 218.64,27.63 218.64,27.1 219.18,26.56
  BOTTOM w0.089: UH1.AV22 212.81,29.44 v2(212.81,29.75)
LPC_AD2: length 112
  TOP w0.114: UE5.7 303.14,21.79 301.11,19.75 v2(301.11,18.53)
  IN6 w0.081: v2(301.11,18.53) 301.01,18.63 299.34,18.63 299.28,18.57 273.19,18.57 271.74,20.01 269.81,20.01 268.9,20.92 261.79,20.92 260.9,21.8 260.9,24.97 260.24,25.64 257.83,25.64 256.89,26.57 252.57,26.57 251.63,25.63 248.04,25.63 243.15,20.74 243.15,20.29 240.84,17.97 235.85,17.97 234.51,19.31 232.57,19.31 231.5,20.38 229.86,20.38 229.61,20.13 226.11,20.13 225.38,20.86 225.36,20.86 225.11,21.1 225.11,22.97 222.09,25.99 222.09,26.33 217.91,30.51 212.11,30.51 v2(211.79,30.83)
  BOTTOM w0.089: UH1.AT19 212.21,30.37 211.79,30.79 v2(211.79,30.83)
LPC_AD3: length 108.9
  TOP w0.114: v2(301.92,18.76) 301.92,19.9 303.94,21.92 UE5.5
  IN6 w0.081: v2(218.34,31.18) 218.34,30.38 222.3,26.42 222.3,26.08 225.32,23.06 225.32,21.21 226.2,20.33 229.52,20.33 229.77,20.59 231.59,20.59 232.66,19.52 234.6,19.52 235.93,18.18 240.75,18.18 242.94,20.37 242.94,20.83 247.96,25.84 251.41,25.84 252.35,26.78 256.98,26.78 257.91,25.84 260.33,25.84 261.11,25.06 261.11,21.89 261.88,21.13 268.99,21.13 269.89,20.22 271.86,20.22 273.31,18.78 299.19,18.78 299.36,18.95 301.73,18.95 v2(301.92,18.76)
  BOTTOM w0.089: v2(218.34,31.18) 218.34,31.32 217.87,31.79 216.27,31.79 215.97,32.1 UH1.BD16
LPC_FRAME#: length 107.9
  TOP w0.114: v2(302.5,18.77) 302.5,20.15 304.34,21.98 UE5.4
  IN6 w0.081: v2(302.5,18.77) 302.11,19.15 299.27,19.15 299.11,18.99 273.39,18.99 271.89,20.49 271.71,20.49 270.85,21.36 266.16,21.36 264.91,22.61 264.91,25.01 262.93,26.99 248.81,26.99 243.28,21.46 242.56,21.46 239.97,18.88 238.11,18.88 237.78,19.21 235.53,19.21 235.01,19.73 232.74,19.73 231.67,20.8 229.69,20.8 229.43,20.54 226.28,20.54 225.53,21.3 225.53,23.14 222.51,26.17 222.51,26.5 218.91,30.1 v2(218.91,31.18)
  BOTTOM w0.089: UH1.BE16 216.51,31.97 218.2,31.97 218.91,31.26 v2(218.91,31.18)
LX_1.0VS_VGAP: length 6
  IN3 w0.254: v2(242.52,43.47) 243.02,42.96 243.02,38.7 v2(243.07,38.65)
  BOTTOM w0.254: PU800.6 242.72,39.16 243.07,38.81 v2(243.07,38.65)
  vias: v1(245.97,42.89)
LX_3V: length 24.7
  IN4 w1.016: 57.28,44.8 59.44,42.64 59.44,40.1 54.17,34.83 54.17,30.96 54.68,30.45 54.68,28.97 53.67,27.95 51.93,27.95 50.24,26.26
  vias: v1(50.49,26.26) v2(44.71,25.94) v2(44.78,24.8) v2(44.97,25.37) v2(45.41,25.94) v2(45.47,24.8) v2(45.67,25.37) v2(46.05,25.94) v2(46.11,24.8) v2(46.3,25.37) v2(46.74,25.94) v2(46.74,24.8) v2(47,25.37) v2(47.38,25.94) v2(47.38,24.8) v2(47.63,25.37) v2(48.01,25.94) v2(48.01,24.8) v2(48.27,25.37) v2(48.65,25.94) v2(48.71,24.8) v2(48.9,25.37) v2(49.28,25.94) v2(49.35,24.8) v2(49.54,25.37) v2(56.26,45.76) v2(56.9,45.75)
LX_5V: length 9.4
  IN4 w1.016: 50.55,45 43.92,38.36
  vias: v1(40.66,34.7) v2(40.2,37.05) v2(40.27,35.91) v2(40.46,36.48) v2(40.52,37.56) v2(40.84,37.05) v2(40.86,35.91) v2(41.09,36.48) v2(41.22,37.56) v2(41.54,37.05) v2(41.5,35.91) v2(41.73,36.48) v2(41.86,37.56) v2(42.13,35.91) v2(42.17,37.05) v2(42.36,36.48) v2(42.49,37.56) v2(42.81,37.05) v2(42.83,35.91) v2(43.06,36.48) v2(43.13,37.56) v2(43.44,37.05) v2(43.7,36.48) v2(50.78,45.78) v2(51.37,45.77)
LX_+1.8VGS: length 6.7
  TOP w0.508: v2(231.02,43.89) v1(231.02,42.56) 231.02,39.37 230.67,39.01 v2(230.67,38.14)
  BOTTOM w0.254: PU802.6 230.52,38.29 v2(230.67,38.14)
LX_CHG: length 4.6
  IN1 w1.016: 61.67,23.46 64.46,23.46 65.73,22.19
  vias: v1(60.59,23.07) v2(60.97,23.46) v2(61.41,23.84) v2(65.92,20.8) v2(65.9,20.16) v2(66.56,20.8) v2(66.49,20.16) v2(67.19,20.8) v2(67.83,20.8) v2(68.27,20.29) v2(68.53,20.86) v2(68.72,23.65) v2(68.72,23.02) v2(68.72,22.38) v2(68.72,21.75) v2(68.91,20.29) v2(69.03,21.18) v2(69.41,20.61)
LX_VCCIO: length 7.7
  TOP w0.508: v2(120.34,118.52) v1(120.34,115.07) 120.34,112.43 v2(120.91,111.86)
  BOTTOM w0.254: v2(120.34,118.52) 120.71,118.15 PU509.6
M_CLK_DDR0: length 50.9
  IN6 w0.081: 150.51,86.64 150.5,86.63 150.5,86.62 150.47,86.59 150.47,86.58 150.46,86.57 150.46,83.62 150.72,83.36 151.04,83.36 151.15,83.25 151.15,82.87 151.03,82.75 150.62,82.75 150.41,82.54 150.41,82.13 150.62,81.92 150.98,81.92 151.09,81.82 151.09,81.48 150.96,81.35 150.64,81.35 150.43,81.14 150.43,80.71 150.64,80.5 151.07,80.5 151.26,80.32 151.26,71.68 146.4,66.82 146.4,60.31 146.2,60.11 146.2,59.72 146.1,59.62 145.71,59.62 145.52,59.42 145.52,58.93 145.72,58.73 146.15,58.73 146.26,58.62 146.26,57.34 146.13,57.21 145.9,57.21 v2(145.62,57.49) ; 151.08,86.9 151,86.82 150.88,86.82
  IN6 w0.089: 150.51,86.64 150.7,86.82 150.88,86.82 ; 151.08,86.9 151.19,87.02 v2(151.19,87.13)
  BOTTOM w0.076: v2(151.19,87.13) 151.66,86.66 152.64,86.66 154.02,88.04 v3(154.02,89.62) 154.02,90.97 154.21,91.17 154.21,93.32 154.28,93.38 154.28,93.87 154.18,93.96 153.88,93.96 153.81,93.89 153.81,93.71 CPU1.AG1
  BOTTOM w0.107: JDIMM1.137 145.69,59.07
  BOTTOM w0.114: 145.69,59.07 145.8,58.96 145.8,58.55 146.26,58.1 146.26,57.4 146.14,57.28 145.73,57.28 145.62,57.4 v2(145.62,57.49)
M_CLK_DDR1: length 53.7
  IN6 w0.081: v2(145.62,53.68) 145.74,53.8 145.88,53.8 145.99,53.7 146.27,53.7 146.75,53.22 147.69,53.22 147.93,53.45 147.93,53.87 147.69,54.1 147.23,54.1 147.11,54.22 147.11,54.62 147.22,54.74 147.73,54.74 147.84,54.85 147.84,54.85 147.93,54.93 147.93,55.44 147.74,55.63 147.69,55.67 146.46,55.67 146.36,55.78 146.36,56.2 146.47,56.31 146.89,56.31 147.1,56.52 147.1,59.33 147.25,59.49 147.25,66.38 152.08,71.21 152.08,84.33 151.73,84.67 151.73,87.99 151.42,88.3 151.42,89.35 151.77,89.69 151.77,91.32 151.55,91.54 151.3,91.54 v2(151.04,91.8)
  BOTTOM w0.076: v2(151.04,91.8) 151.27,91.57 151.48,91.57 151.66,91.75 151.66,92.59 150.96,93.28 150.96,93.83 151.12,93.99 151.17,93.99 151.42,94.23 CPU1.AK2
  BOTTOM w0.107: JDIMM1.138 145.94,52.68
  BOTTOM w0.114: v2(145.62,53.68) 145.84,53.9 146,53.9 146.19,53.71 146.19,53.47 146.06,53.34 146.06,52.79 145.94,52.68
M_CLK_DDR2: length 65.2
  IN1 w0.081: v2(145.62,43.8) 145.33,44.09 145.25,44.09 145.04,44.3 145.04,51.51 146.2,52.67 146.2,72.32 151.78,77.91 151.78,88.15 151.62,88.32 151.62,92.72 151.03,93.31 151.03,94.6 151.72,95.28 151.93,95.28 152.2,95.55 152.2,96.1 151.66,96.64 151.47,96.64 151.16,96.94 150.79,96.94 150.14,97.59 150.14,98.09 v2(149.75,98.48)
  BOTTOM w0.076: v2(149.75,98.48) 150.07,98.8 CPU1.AM9
  BOTTOM w0.107: 145.44,43.98 v2(145.62,43.8) ; JDIMM2.137 145.69,46.29
  BOTTOM w0.114: 145.44,43.98 145.42,43.98 145.41,43.98 145.15,43.98 144.79,44.34 144.79,45.21 145.32,45.74 145.7,45.74 145.81,45.85 145.81,46.17 145.69,46.29
M_CLK_DDR3: length 67
  IN1 w0.081: v2(145.62,41.26) 145.76,41.12 146.99,41.12 147.13,41.26 147.13,41.76 147.02,41.87 146.4,41.87 146.06,42.2 146.06,51.57 146.9,52.4 146.9,72.03 152.47,77.61 152.47,86.61 152.85,86.99 152.85,93.09 152.57,93.37 152.57,96.49 151.79,97.27 151.41,97.27 151.1,97.59 151.1,97.86 150.95,98 150.84,98 v2(150.66,97.82)
  BOTTOM w0.076: CPU1.AM7 v2(150.66,97.82)
  BOTTOM w0.107: JDIMM2.138 145.94,39.86
  BOTTOM w0.114: 145.94,39.86 145.99,39.9 145.99,40.08 145.9,40.16 145.48,40.16 145.19,40.46 145.19,40.82 v2(145.62,41.26)
M_CLK_DDR#0: length 51
  IN6 w0.081: v2(145.62,56.85) 145.82,57.05 146.2,57.05 146.42,57.27 146.42,58.69 146.2,58.91 145.77,58.91 145.67,59 145.67,59.36 145.78,59.46 146.16,59.46 146.38,59.68 146.38,60.06 146.55,60.24 146.55,66.76 151.41,71.62 151.41,80.38 151.14,80.66 150.7,80.66 150.59,80.77 150.59,81.08 150.7,81.19 151.03,81.19 151.25,81.41 151.25,81.88 151.05,82.08 150.68,82.08 150.57,82.19 150.57,82.48 150.69,82.59 151.1,82.59 151.31,82.81 151.31,83.31 151.11,83.52 150.78,83.52 150.62,83.68 150.62,86.51 150.63,86.52
  IN6 w0.089: 150.63,86.52 150.77,86.66 151.03,86.66 v2(151.19,86.5)
  BOTTOM w0.076: CPU1.AG2 154,94.17 154.2,94.17 154.44,93.93 154.44,93.31 154.38,93.25 154.38,91.1 154.18,90.9 154.18,89.92 154.21,89.89 154.21,89.34 154.18,89.32 154.18,87.98 152.71,86.5 v2(151.19,86.5)
  BOTTOM w0.107: JDIMM1.139 146.19,59.1
  BOTTOM w0.114: v2(145.62,56.85) 145.8,57.04 146.24,57.04 146.5,57.3 146.5,58.2 146.05,58.65 146.05,58.95 146.19,59.1
M_CLK_DDR#1: length 53.7
  IN6 w0.081: v2(151.04,91.16) 151.26,91.38 151.49,91.38 151.61,91.26 151.61,89.76 151.27,89.41 151.27,88.24 151.57,87.93 151.57,84.61 151.92,84.26 151.92,71.27 147.1,66.45 147.1,59.55 146.94,59.4 146.94,56.59 146.82,56.47 146.38,56.47 146.18,56.27 146.18,55.73 146.4,55.52 147.63,55.52 147.77,55.37 147.77,55 147.69,54.92 147.69,54.91 147.67,54.9 147.16,54.9 146.95,54.69 146.95,54.15 147.16,53.94 147.63,53.94 147.77,53.8 147.77,53.52 147.63,53.37 146.82,53.37 146.32,53.87 146.06,53.87 v2(145.62,54.31)
  BOTTOM w0.076: v2(151.04,91.16) 151.29,91.41 151.55,91.41 151.83,91.69 151.83,92.65 151.13,93.35 151.13,93.76 151.19,93.82 151.29,93.82 151.42,93.69 CPU1.AK1
  BOTTOM w0.107: JDIMM1.140 146.44,52.68
  BOTTOM w0.114: v2(145.62,54.31) 145.78,54.15 146.11,54.15 146.44,53.81 146.44,53.37 146.31,53.24 146.31,52.82 146.44,52.68
M_CLK_DDR#2: length 65.2
  IN1 w0.081: v2(145.62,44.43) 145.44,44.25 145.32,44.25 145.2,44.37 145.2,51.44 146.35,52.6 146.35,72.26 151.94,77.85 151.94,88.22 151.78,88.38 151.78,92.79 151.19,93.37 151.19,94.54 151.78,95.13 152,95.13 152.36,95.48 152.36,96.16 151.73,96.79 151.53,96.79 151.22,97.1 150.85,97.1 150.3,97.65 150.3,98.15 150.11,98.34 150.11,98.63 149.75,98.99 v2(149.75,99.11)
  BOTTOM w0.076: v2(149.75,99.11) 149.43,98.8 149.4,98.8 149.39,98.8 CPU1.AN9
  BOTTOM w0.107: JDIMM2.139 146.2,46.26
  BOTTOM w0.114: v2(145.62,44.43) 145.41,44.23 145.25,44.23 145.04,44.44 145.04,45.11 145.42,45.5 145.81,45.5 146.06,45.75 146.06,46.12 146.2,46.26
M_CLK_DDR#3: length 66.8
  IN1 w0.081: v2(150.66,98.47) 150.66,98.29 150.79,98.16 151.02,98.16 151.26,97.92 151.26,97.65 151.48,97.43 151.85,97.43 152.72,96.56 152.72,93.44 153.01,93.15 153.01,86.93 152.63,86.55 152.63,77.54 147.06,71.97 147.06,52.34 146.22,51.5 146.22,42.27 146.46,42.03 147.09,42.03 147.29,41.83 147.29,41.19 147.05,40.96 145.88,40.96 145.62,40.7 v2(145.62,40.62)
  BOTTOM w0.076: CPU1.AM8 v2(150.66,98.47)
  BOTTOM w0.114: v2(145.62,40.62) 145.82,40.42 146,40.42 146.44,39.97 JDIMM2.140
M_ODT0: length 52.7
  IN6 w0.089: 158.08,83.85 158.08,84.15 155.71,86.52 155.12,86.52 154.44,87.2 154.44,88.42 154.61,88.59 v2(154.82,88.59)
  IN6 w0.13: 158.08,83.85 158.08,68.37 153.85,64.14 153.85,59.98 153.32,59.45 153.32,55.92 v2(152.85,55.45)
  BOTTOM w0.076: v2(154.82,88.59) 156.37,90.14 156.37,93.17 156.17,93.37 156.17,94.61 CPU1.AD3
  BOTTOM w0.175: JDIMM1.155 152.19,57.67 151.94,57.41 151.59,57.41 151.41,57.24 151.41,56.85 151.59,56.67 152.22,56.67 152.34,56.55 152.34,56.16 152.22,56.04 151.59,56.04 151.41,55.86 151.41,55.52 151.59,55.34 152.74,55.34 v2(152.85,55.45)
M_ODT1: length 51.6
  IN6 w0.089: 156.61,83.85 156.61,84.16 154.03,86.74 154.03,91.61 v2(154.82,92.4)
  IN6 w0.13: 156.61,83.85 156.61,70.94 156.76,70.79 157.01,70.79 157.16,70.63 157.16,70.33 157.01,70.18 156.76,70.18 156.61,70.02 156.61,69.72 156.76,69.57 157.01,69.57 157.16,69.41 157.16,69.11 157.01,68.96 156.76,68.96 156.61,68.8 156.61,68.19 152.86,64.45 152.86,62.19 152.4,61.72 152.4,57.62 151.8,57.02 151.8,56.67 152.05,56.42 152.32,56.42 v2(152.88,56.97)
  BOTTOM w0.076: v2(154.82,92.4) 154.82,92.54 155.27,92.98 155.27,95.19 155.61,95.54 CPU1.AE4
  BOTTOM w0.175: v2(152.88,56.97) 153.25,56.97 153.42,56.8 153.42,56.15 153.6,55.98 153.89,55.98 154.06,56.15 154.06,58.52 153.69,58.88 JDIMM1.161
M_ODT2: length 66.1
  IN1 w0.089: v2(155.24,97.85) 155.46,97.63 155.46,94.84 156.35,93.95 156.35,88.23 158.3,86.28 158.3,83.85
  IN1 w0.13: v2(152.85,45.57) 152.87,45.59 152.87,48.27 153.69,49.08 153.69,50.82 154.96,52.09 154.96,59.87 153.92,60.91 153.92,62.85 153.7,63.07 153.01,63.07 152.85,63.22 152.85,63.53 153.01,63.69 153.76,63.69 153.92,63.84 153.92,64.15 153.76,64.31 153.01,64.31 152.85,64.46 152.85,64.77 153.01,64.93 153.75,64.93 153.92,65.1 153.92,65.39 153.76,65.55 153.01,65.55 152.85,65.7 152.85,66.01 153.01,66.17 153.76,66.17 153.92,66.32 153.92,66.63 153.76,66.79 153.01,66.79 152.85,66.94 152.85,67.25 153.01,67.41 153.74,67.41 153.92,67.58 153.92,68.63 158.3,73.01 158.3,83.85
  BOTTOM w0.076: v2(155.24,97.85) CPU1.AF7
  BOTTOM w0.175: v2(152.85,45.57) 152.2,46.23 JDIMM2.155
M_ODT3: length 67.2
  IN1 w0.089: 159.22,83.85 159.22,86.63 156.94,88.91 156.94,94.62 156.47,95.09 156.47,97.37 v2(156.12,97.72)
  IN1 w0.13: 159.22,83.85 159.22,72.63 155.75,69.16 155.75,64.38 155.59,64.22 154.99,64.22 154.84,64.07 154.84,63.73 154.99,63.57 155.56,63.57 155.71,63.42 155.71,63.12 155.56,62.96 154.99,62.96 154.84,62.81 154.84,61.29 155.88,60.25 155.88,51.71 155.12,50.96 155.12,48.65 153.79,47.32 153.79,43.59 v2(152.85,42.65)
  BOTTOM w0.076: v2(156.12,97.72) CPU1.AE8
  BOTTOM w0.175: v2(152.85,42.65) 153.87,43.67 153.87,46.07 153.69,46.24 JDIMM2.161
MDP_AUX#_SDA: length 99.8
  IN4 w0.089: v2(223.59,118.15) 223.59,118.42 223.76,118.59 224.45,118.59 224.82,118.96 224.82,119.86 224.16,120.53 224.16,120.54 224.14,120.56
  IN4 w0.109: 224.14,120.56 211.51,133.18 211.51,147.04 210.04,148.51 210.04,151.21 212.18,153.35 213.49,153.35 217.58,157.44 225.07,157.44 226.1,156.41 226.1,155.93 v2(225.83,155.66)
  IN6 w0.089: v2(235.08,158.16) 234.52,158.16 233.49,157.13 231.88,157.13 231.3,156.54 226.14,156.54 225.83,156.24 v2(225.83,155.66)
  BOTTOM w0.089: UV3.13 238.08,161.12 238.24,161.28 238.24,162.09 238.32,162.18 238.45,162.18 238.74,161.88 238.74,159.18 237.32,157.75 235.49,157.75 v2(235.08,158.16) 234.88,157.96 234.5,157.96 234.1,158.36 234.1,161.03 232.9,162.22 232.32,162.22 231.69,161.6 231.1,161.6 230.28,162.42 UV3.6 ; UG9.BL8 223.95,115.83 223.95,116.03 223.85,116.13 223.61,116.13 223.46,116.28 223.46,116.93 223.1,117.29 223.1,118.34 223.3,118.53 223.82,118.53 223.91,118.44 223.91,118.24 223.82,118.15 v2(223.59,118.15) ; v2(225.83,155.66) 226.02,155.85 226.02,156.18 225.43,156.77 225.43,157.39 RV618.2 RV665.1
MDP_AUX_SCL: length 99.5
  IN4 w0.089: 224,120.41 224.01,120.4 224.03,120.4 224.64,119.79 224.64,119.04 224.37,118.77 223.75,118.77 v2(223.61,118.92)
  IN4 w0.109: 224,120.41 211.31,133.1 211.31,146.96 209.84,148.43 209.84,151.3 212.1,153.55 213.41,153.55 217.5,157.64 225.15,157.64 226.29,156.49 226.29,155.77 v2(226.41,155.66)
  IN6 w0.089: v2(226.41,155.66) 226.39,155.66 226.03,156.03 226.03,156.15 226.22,156.35 231.38,156.35 231.96,156.93 233.57,156.93 234.59,157.94 234.73,157.94 235.08,157.59 v2(235.08,157.58)
  BOTTOM w0.089: v2(226.41,155.66) 226.2,155.87 226.2,156.25 225.61,156.84 225.61,157.39 RV619.2 RV664.1 ; UG9.BK8 223.87,115.29 223.52,115.64 223.52,115.95 223.25,116.22 223.25,116.85 222.91,117.19 222.91,118.42 223.22,118.73 223.42,118.73 v2(223.61,118.92) ; UV3.10 236.3,163.07 236.43,163.2 237.68,163.2 238.92,161.96 238.92,159.1 237.39,157.58 v2(235.08,157.58) 234.88,157.78 234.43,157.78 233.92,158.29 233.92,160.95 233.37,161.5 233,161.5 232.16,160.65 230.54,160.65 230.36,160.47 UV3.3
MDP_HPD: length 4.3
  BOTTOM w0.107: RX2.2 CX1.1 232.21,168.23 232.04,168.4 v1(232.04,168.62) 232.04,169.09 232.37,169.43 JDP.2
MDP_LANE_N0_C: length 8.4
  BOTTOM w0.089: JDP.5 232.93,173.14 232.56,173.14 231.57,172.16 231.57,170.12 230.21,168.77 230.15,168.77 229.74,168.35 229.74,168.29 229.57,168.13 229.57,167.51 CV27.2
MDP_LANE_N1_C: length 10.5
  TOP w0.089: CV30.2 242.22,168.09 241.94,168.37 241.94,168.56 241.19,169.31 240.83,169.31 240.79,169.35 240.2,169.35 240.16,169.31 239.92,169.31 238.65,170.58 v3(237.54,170.58) 237.07,170.58 235.19,172.46 235.19,173.31 JDP.11
MDP_LANE_N2_C: length 9.5
  BOTTOM w0.089: JDP.17 237.18,172.85 237.26,172.93 237.89,172.93 238.4,172.42 238.4,170.58 239.84,169.15 240.79,169.15 241.47,168.46 v3(241.47,168.14) 241.47,167.7 241.25,167.47 241.25,167.24 241.16,167.15 240.87,167.15 CV33.2
MDP_LANE_N3_C: length 2.8
  BOTTOM w0.089: CV31.2 235.15,168.45 235.15,169.39 235.37,169.61 JDP.12
MDP_LANE_P0_C: length 8.3
  BOTTOM w0.089: CV26.2 230.15,167.14 229.84,167.14 229.75,167.23 229.75,168.05 v3(230.1,168.4) 231.75,170.05 231.75,172.08 232.63,172.96 232.86,172.96 232.97,172.85 JDP.3
MDP_LANE_P1_C: length 10.4
  TOP w0.089: JDP.9 235.01,173.25 235.01,172.38 236.99,170.4 237.2,170.4 237.24,170.36 237.83,170.36 237.87,170.4 238.58,170.4 239.85,169.13 v3(240.5,169.13) 241.12,169.13 241.77,168.49 241.77,168.37 241.49,168.09 CV28.2
MDP_LANE_P2_C: length 9.5
  BOTTOM w0.089: CV32.2 241.65,167.81 241.69,167.85 241.69,168.43 241.65,168.48 241.65,168.54 240.86,169.32 239.91,169.32 238.58,170.66 238.58,172.5 237.96,173.11 237.54,173.11 236.96,173.69 JDP.15
MDP_LANE_P3_C: length 2.7
  BOTTOM w0.089: CV29.2 234.97,168.42 234.97,169.33 234.77,169.53 JDP.10
ME_EN: length 126.6
  TOP w0.089: v1(214.41,35.6) 214.46,35.65 v2(214.46,36.11)
  TOP w0.097: RH16.1 214.46,36.77 v2(214.46,36.11)
  TOP w0.114: UE5.99 306.17,10.61 306,10.78 304.29,10.78 299.82,15.24 v2(299.82,16.6)
  IN6 w0.081: v2(214.46,36.11) 214,35.66 212.63,35.66 211.4,34.43 211.4,29.8 212.78,28.43 215.92,28.43 216.96,27.38 217.12,27.38 218.22,26.28 219.82,26.28 221.05,25.05 221.86,25.05 223.62,23.29 223.62,18.32 224.07,17.87 231.85,17.87 231.93,17.79 234.85,17.79 235.5,17.14 244.78,17.14 245.99,18.35 245.99,22.4 248.39,24.8 255.65,24.8 261.76,18.69 267.46,18.69 268,18.14 270.88,18.14 271.88,17.14 275.51,17.14 276.16,16.49 295.71,16.49 296.12,16.08 298.13,16.08 299.08,17.03 299.39,17.03 v2(299.82,16.6)
ME_SUS_PWR_ACK: length 108.4
  TOP w0.107: UE5.71 295.54,9.11 295.61,9.18 295.61,14.36 v2(295.94,14.69)
  TOP w0.127: RH506.1 v1(219.06,29.36) 218.4,29.36 v2(218.02,29.74)
  IN2 w0.102: v2(295.94,14.69) 295.9,14.65 279.81,14.65 275.68,18.78 267.85,18.78 267.75,18.89 266.08,18.89 264.51,20.45 259.66,20.45 256.94,23.17 256.94,23.67 256.14,24.48 248.05,24.48 246.17,22.6 246.17,20.33 246.67,19.84 246.67,18.04 245.23,16.61 235.45,16.61 234.47,17.59 229.35,17.59 228.23,18.7 227.72,18.7 227.02,19.4 227.02,21.37 226.01,22.38 225.38,22.38 225.01,22.75 225.01,24.5 224.74,24.77 224.74,25.94 221.64,29.03 219.86,29.03 219.4,29.5 218.26,29.5 v2(218.02,29.74)
  BOTTOM w0.089: UH1.BD19 217.27,30.49 v2(218.02,29.74)
MEM_VDD_CTL: length 120.7
  IN3 w0.102: v2(235.14,39.08) 235.14,39.91 234.68,40.37 230.62,40.37 229.95,39.69 224.59,39.69 222.8,41.48 219.1,41.48 218.28,42.3 218.28,42.72 214.15,46.85 210.74,46.85 209.59,48 209.59,51.65 211.34,53.4 211.34,57.64 v2(212.02,58.33)
  IN4 w0.102: v2(221.37,113.35) 222.1,113.35 222.96,112.49 222.96,111.35 224.1,110.2 224.1,109.57 223.72,109.19 220.93,109.19 219.31,107.58 216.06,107.58 215.63,107.14 214.11,107.14 211.9,104.93 211.9,60.89 212.64,60.14 212.64,58.95 v2(212.02,58.33)
  BOTTOM w0.1: UG9.BH4 v2(221.37,113.35)
  BOTTOM w0.102: PR8214.1 237.73,29.13 237.73,29.98 237.11,30.6 237.11,32.88 235.59,34.39 v1(235.59,36.98) 235.54,37.03 235.54,38.68 v2(235.14,39.08)
MEM_VREF: length 253.5
  TOP w0.102: v2(191.72,99.96) 191.55,99.96 191.11,100.4 RG24.1
  IN3 w0.102: v2(284.69,66.25) 286.68,68.23 294.14,68.23 295.03,67.34 295.03,65.73 295.68,65.08 295.68,52.11 293.2,49.64 288.95,49.64 288.43,50.16 275.52,50.16 274.23,51.45 261.02,51.45 259.51,49.94 254.01,49.94 253.56,50.39 245.42,50.39 245.14,50.11 234.07,50.11 233.69,50.49 231.01,50.49 230.42,51.07 228.52,51.07 v2(228.02,50.57)
  BOTTOM w0.1: 213.69,103.73 214.77,104.81 214.77,109.03 215.88,110.14 218.54,110.14 218.75,110.36 219.18,110.36 219.35,110.53 219.9,110.53 220.22,110.85 UG9.BD3
  BOTTOM w0.102: QG4.2 228.45,51 v2(228.02,50.57) 227.32,49.87 222.67,49.87 220.89,51.64 214.28,51.64 213.75,52.17 213.75,57.49 212.4,58.83 211.7,58.83 204.19,66.35 192.96,66.35 190.08,69.23 190.08,81.51 191.07,82.5 191.07,86.5 QG8.2 191.07,86.53 191.07,99.31 v2(191.72,99.96) 191.72,101.35 193.24,102.88 198.03,102.88 198.38,103.23 210.51,103.23 210.64,103.09 v1(212.44,103.09) 213.05,103.09 213.69,103.73
  BOTTOM w0.254: QG2.2 284.71,99.45 286.65,97.5 286.65,70.52 285.12,69 285.12,67.11 284.69,66.68 v2(284.69,66.25) 284.75,66.2 QG3.2
MIC1-VREFO_L: length 23
  TOP w0.254: RA28.1 27.25,22 v1(26.45,21.2) 25.66,20.42 v2(25.66,20.16)
  IN6 w0.254: v2(23.96,31.78) 23.96,29.43 23,28.47 23,25.57 23.96,24.61 23.96,20.34 24.71,19.59 25.15,19.59 25.66,20.1 v2(25.66,20.16)
  BOTTOM w0.203: v2(23.96,31.78) 24.44,31.3 24.73,31.3 24.99,31.57 28.04,31.57 28.1,31.51 UA1.38
  BOTTOM w0.254: RA26.1 25.66,19.65 v2(25.66,20.16)
MIC_CLK: length 305.2
  TOP w0.114: JEDP.23 162.62,179.58 162.53,179.48 162.53,176.38 163.19,175.72 163.19,173.12 162.43,172.36 162.43,171.94 162.75,171.62 v2(162.76,171.62) ; RV13.1 164.21,163.87 v2(164.66,164.32)
  IN1 w0.081: v2(162.76,171.62) 162.57,171.81 162.57,172.24 162.23,172.58 159.35,172.58 158.65,173.28 155.03,173.28 154.08,172.32 152.83,172.32 151.31,170.8 148.85,170.8 145.25,167.2 145.25,165.99 144.53,165.27 144.53,164.5 145.25,163.78 145.25,162.4 142.61,159.75 138.73,159.75 137.43,158.44 132.07,158.44 129.51,161 115.03,161 113.79,159.77 113.79,73.81 108.47,68.49 108.47,43.7 108.02,43.25 108.02,40.59 107.51,40.08 107.51,35.32 105.91,33.71 105.91,28.78 105.83,28.7 105.64,28.7 v2(105.42,28.92)
  IN3 w0.127: v2(162.76,171.62) 162.57,171.43 162.57,165.96 164.2,164.32 v2(164.66,164.32)
  IN6 w0.081: v2(105.42,28.92) 105.19,28.7 104.69,28.7 101.79,31.6 101.79,35.89 99.92,37.76 99.92,38.75 97.94,40.74 90.73,40.74 87.66,43.8 57.63,43.8 56.36,45.07 55.29,45.07 54.84,44.61 50.65,44.61 48.87,46.39 38.16,46.39 36.71,44.95 36.71,36.48 v2(36.58,36.35)
  BOTTOM w0.114: v2(36.58,36.35) 36.76,36.53 CA34.1 LA6.1
MIC_DATA: length 295.7
  TOP w0.114: JEDP.22 162.12,179.75 162.29,179.58 162.29,176.28 162.95,175.62 162.95,173.22 162.19,172.46 162.19,171.52 v2(162.06,171.4)
  IN1 w0.081: v2(162.06,171.4) 162.36,171.7 162.36,172.16 162.15,172.37 159.27,172.37 158.57,173.07 155.12,173.07 154.16,172.11 152.91,172.11 151.39,170.59 148.93,170.59 145.46,167.12 145.46,165.9 144.74,165.18 144.74,164.59 145.46,163.87 145.46,162.31 142.69,159.54 138.82,159.54 137.51,158.24 131.98,158.24 129.42,160.8 115.12,160.8 114,159.68 114,73.73 108.68,68.4 108.68,43.61 108.23,43.17 108.23,40.5 107.72,39.99 107.72,35.23 106.12,33.63 106.12,28.7 105.92,28.49 105.62,28.49 v2(105.42,28.29)
  IN6 w0.081: v2(37.22,36.35) 36.92,36.65 36.92,44.86 38.25,46.19 48.79,46.19 50.57,44.41 54.92,44.41 55.38,44.86 56.27,44.86 57.54,43.59 87.58,43.59 90.64,40.53 97.85,40.53 99.71,38.67 99.71,37.68 101.58,35.81 101.58,31.51 104.6,28.49 105.22,28.49 v2(105.42,28.29)
  BOTTOM w0.114: v2(37.22,36.35) 36.76,35.9 CA35.1 RA19.1
MUX_EDP_A0N: length 80.7
  TOP w0.107: CV2.2 147.52,166.49 147.52,166.21 147.65,166.08 v2(147.71,166.08)
  IN1 w0.089: v2(193.02,142.65) 192.69,142.98 192.1,142.98 191.58,143.51 191.58,146.61 185.61,152.59 168.98,152.59 167.64,153.92 166.25,153.92 165.43,154.74 165.43,157.62 163.42,159.63 163.42,162.69 162.63,163.48 162.63,166.34 160,168.97 156.06,168.97 155.45,169.58 154.24,169.58 152.84,168.18 148.93,168.18 147.3,166.55 147.3,166.42 147.64,166.08 v2(147.71,166.08)
  BOTTOM w0.107: UV21.45 200.32,134.88 200.41,134.98 200.41,139.19 200.01,139.6 199.97,139.6 199.57,140 199.57,140.04 198.41,141.19 195.62,141.19 193.8,143.01 193.54,143.01 193.43,142.9 193.43,142.68 193.32,142.58 193.09,142.58 v2(193.02,142.65)
MUX_EDP_A0P: length 80.7
  TOP w0.107: v2(147.07,166.08) 147.14,166.08 147.28,166.22 147.28,166.48 CV1.2
  IN1 w0.089: v2(193.02,143.24) 192.93,143.15 192.17,143.15 191.75,143.58 191.75,146.68 185.68,152.75 169.04,152.75 167.71,154.08 166.32,154.08 165.59,154.81 165.59,157.69 163.58,159.7 163.58,162.76 162.8,163.55 162.8,166.41 160.07,169.13 156.13,169.13 155.52,169.75 154.17,169.75 152.77,168.35 148.87,168.35 147.14,166.62 147.14,166.15 v2(147.07,166.08)
  BOTTOM w0.107: v2(193.02,143.24) 193.04,143.21 193.89,143.21 195.7,141.4 198.5,141.4 v3(199.93,139.96) 200.62,139.27 200.62,134.99 200.63,134.98 200.65,134.98 200.72,134.91 UV21.46
MUX_EDP_A1N: length 74.8
  TOP w0.107: CV4.2 148.81,166.77 148.81,166.25 v2(148.98,166.08)
  IN1 w0.089: v2(148.98,166.08) 148.96,166.08 148.64,166.41 148.64,166.57 149.58,167.51 152.78,167.51 153.99,166.3 157.8,166.3 159.41,164.69 160.37,164.69 162.72,162.33 162.72,159.43 164.79,157.36 164.79,154.47 166.17,153.09 167.2,153.09 168.34,151.95 185.28,151.95 190.89,146.34 190.89,142.67 191.96,141.6 192.62,141.6 v2(193.02,141.21)
  BOTTOM w0.107: v2(193.02,141.21) 193.09,141.14 193.25,141.14 193.35,141.24 193.35,141.45 193.49,141.59 194.05,141.59 195.28,140.35 197.37,140.35 199.21,138.51 199.21,135.24 199.12,135.14 UV21.42
MUX_EDP_A1P: length 74.8
  TOP w0.107: v2(148.4,166.08) 148.61,166.3 148.61,166.8 CV3.2
  IN1 w0.089: v2(193.02,141.79) 192.99,141.76 192.03,141.76 191.05,142.74 191.05,146.41 185.34,152.12 168.41,152.12 167.27,153.26 166.24,153.26 164.96,154.54 164.96,157.43 162.89,159.5 162.89,162.4 160.44,164.85 159.48,164.85 157.87,166.47 154.06,166.47 152.85,167.67 149.51,167.67 148.47,166.64 148.47,166.16 v2(148.4,166.08)
  BOTTOM w0.107: UV21.43 199.52,135.14 199.42,135.24 199.42,138.6 197.46,140.56 195.37,140.56 194.14,141.79 v2(193.02,141.79)
MUX_EDP_A2N: length 77.1
  TOP w0.107: CV6.2 150.11,166.8 150.11,166.36 149.68,165.92 149.68,165.07 149.4,164.79 149.4,164.14 v2(149.61,163.93)
  IN1 w0.089: v2(149.61,163.93) 149.6,163.93 149.2,164.33 149.2,164.8 151.27,166.87 152.45,166.87 153.68,165.64 155.52,165.64 157.21,163.95 159.94,163.95 160.12,163.77 160.12,161.14 164.16,157.1 164.16,154.21 167.07,151.29 171.81,151.29 172.51,150.59 185.56,150.59 190.09,146.06 190.09,142.39 190.79,141.7 190.79,140.43 191.1,140.11 191.7,140.11 v2(191.91,139.91)
  BOTTOM w0.107: UV21.39 197.92,134.96 198.11,135.16 198.11,135.18 198.38,135.45 198.38,138.36 197.14,139.61 194.45,139.61 193.76,140.29 192.37,140.29 192.26,140.18 192.26,140.02 192.15,139.91 v2(191.91,139.91)
MUX_EDP_A2P: length 77.2
  TOP w0.107: v2(149.03,163.93) 149.19,164.09 149.19,164.87 149.48,165.15 149.48,166.01 149.91,166.44 149.91,166.77 CV8.2
  IN1 w0.089: v2(149.03,163.93) 149.03,164.87 151.2,167.04 152.52,167.04 153.75,165.81 155.59,165.81 157.28,164.12 160.01,164.12 160.28,163.84 160.28,161.2 164.32,157.17 164.32,154.28 167.14,151.46 171.88,151.46 172.58,150.76 185.63,150.76 190.25,146.13 190.25,142.46 190.95,141.76 190.95,140.49 191.17,140.28 191.69,140.28 v2(191.91,140.49)
  BOTTOM w0.107: v2(191.91,140.49) 193.84,140.49 194.53,139.81 197.23,139.81 198.59,138.45 198.59,135.36 198.32,135.09 UV21.40
MUX_EDP_A3N: length 68.6
  TOP w0.107: CV11.2 150.96,165.36 150.96,164.72 v2(151.12,164.56)
  IN1 w0.089: v2(191.91,138.46) 191.91,138.48 191.56,138.83 190.61,138.83 189.21,140.22 189.21,146.01 185.27,149.96 166.7,149.96 163.48,153.17 163.48,156.87 161.43,158.92 159.09,158.92 158.2,159.81 158.2,160.92 156.21,162.91 153.62,162.91 151.27,165.26 150.88,165.26 150.78,165.16 150.78,164.88 151.1,164.56 v2(151.12,164.56)
  BOTTOM w0.107: UV21.36 196.72,135.02 196.8,135.1 196.8,135.57 196.21,136.16 196.21,136.82 196.1,136.93 196.07,136.93 195.67,137.33 195.67,137.37 194.19,138.84 192.38,138.84 192.27,138.74 192.27,138.52 192.15,138.4 191.97,138.4 v2(191.91,138.46)
MUX_EDP_A3P: length 68.6
  TOP w0.107: CV7.2 150.76,165.41 150.76,164.78 v2(150.54,164.56)
  IN1 w0.089: v2(150.54,164.56) 150.62,164.64 150.62,165.23 150.82,165.42 151.33,165.42 153.68,163.07 156.27,163.07 158.37,160.98 158.37,159.88 159.16,159.09 161.5,159.09 163.65,156.94 163.65,153.24 166.77,150.12 185.33,150.12 189.38,146.08 189.38,140.29 190.67,139 191.86,139 v2(191.91,139.05)
  BOTTOM w0.107: v2(191.91,139.05) 194.28,139.05 v3(196.03,137.29) 196.41,136.91 196.41,136.24 197,135.66 197,135.15 197.12,135.03 UV21.37
MUX_EDP_AUXN: length 74.6
  TOP w0.107: CV13.2 151.9,166.74 151.9,162.92 151.44,162.46 v2(150.12,162.46)
  IN1 w0.089: v2(150.12,162.46) 150.12,162.71 150.22,162.81 151.39,162.81 152.3,161.89 156.32,161.89 157.51,160.71 157.51,158.93 156.73,158.15 156.73,153.91 158.68,151.95 163.77,151.95 166.42,149.3 184.93,149.3 188.52,145.71 188.52,138.19 191.2,135.5 192.8,135.5 v2(192.95,135.36)
  BOTTOM w0.089: v2(192.95,135.36) 192.79,135.52 192.21,135.52 RV19.2
  BOTTOM w0.107: UV21.31 194.72,134.96 194.79,135.04 194.79,135.19 194.41,135.58 194.21,135.58 194.05,135.74 193.32,135.74 193.25,135.67 193.25,135.42 193.15,135.31 192.99,135.31 v2(192.95,135.36)
MUX_EDP_AUXP: length 74.7
  TOP w0.107: v2(149.88,163.03) 150.12,163.03 150.5,162.66 151.35,162.66 151.7,163 151.7,166.82 CV12.2
  IN1 w0.089: v2(149.88,163.03) 150.12,163.03 150.19,162.97 151.46,162.97 152.37,162.06 156.39,162.06 157.67,160.78 157.67,158.86 156.89,158.08 156.89,153.98 158.75,152.11 163.84,152.11 166.49,149.46 185,149.46 188.69,145.78 188.69,138.25 191.27,135.67 192.67,135.67 v2(192.95,135.94)
  BOTTOM w0.089: v2(192.95,135.94) 192.76,135.76 192.19,135.76 RV20.1
  BOTTOM w0.107: v2(192.95,135.94) 194.13,135.94 194.29,135.78 194.49,135.78 195.04,135.24 195.04,135.04 195.12,134.96 UV21.32
N17_ID0: length 26.4
  BOTTOM w0.089: UH1.AL43 209.63,18.52 209.3,18.19 209.3,17.05 209.71,16.65 210.98,16.65 212.13,15.5
  BOTTOM w0.107: RH27.1 RH28.1 196.82,14.13 197.2,13.75 197.46,13.75 197.78,13.43 197.78,12.59 198.95,11.41 v1(200.68,11.41) 201.61,11.41 201.9,11.12 209.16,11.12 209.97,11.93 211.11,11.93 212.21,13.03 212.21,15.42 212.13,15.5
N17_ID1: length 23.6
  BOTTOM w0.089: 211.72,15.2 210.71,16.21 208.99,16.21 208.2,17 208.2,18.46 UH1.AJ43
  BOTTOM w0.102: RH26.1 RH25.1 199.11,13.88 199.42,13.56 199.42,12.26 199.64,12.05
  BOTTOM w0.107: 211.72,15.2 211.72,13.71 210.63,12.62 v1(209.95,12.62) 206.9,12.62 205.94,11.66 203.7,11.66 203.13,12.22 201.95,12.22 201.77,12.05 199.64,12.05
NC_B4: length 5.6
  TOP w0.089: 177.52,170.19 177.52,170.19 177.52,169.64 177.3,169.42 UT1.B4
  TOP w0.107: v2(177.49,171.23) 177.43,171.16 177.43,170.28 177.52,170.19
  BOTTOM w0.102: v1(176.11,169.7) 176.46,170.06 RT86.2
  BOTTOM w0.107: RT86.2 177.36,170.47 177.49,170.59 v2(177.49,171.23) 177.87,171.61 RT45.1
NC_B5: length 3.1
  TOP w0.089: 178,170.14 177.99,169.67 177.76,169.43 UT1.B5
  TOP w0.127: RT46.1 178.95,171.55 178.6,171.19 v1(178.6,171.06) 178.6,170.75 178,170.14
NC_G2: length 4.4
  TOP w0.089: 175.72,166.84 176.14,166.84 UT1.G2
  TOP w0.102: 175.72,166.84 175.57,166.69 175.57,166.44 174.91,165.78 v1(174.91,164.85) 174.91,164.82 174.46,164.37 174.46,164.21 174.14,163.89 RT47.1
Net_399:
  vias: v2(190.36,117.43) v2(190.36,115.78) v2(192.01,117.43) v2(192.01,115.78)
NRB_BIT: length 4.7
  TOP w0.102: v2(217.53,25.76) 217.56,25.76 v1(218.18,25.15) 218.53,24.8 219.68,24.8 RH524.2
  BOTTOM w0.089: v2(217.53,25.76) 217.46,25.83 216.69,25.83 216.58,25.94 UH1.BD28
NTC_LA: length 29
  IN1 w0.203: v2(268.13,136.71) 268.15,136.71 268.57,137.13 268.57,137.91 267.87,138.61 267.06,139.42 267.06,143.11 264.03,146.15 257.34,146.15 256.4,145.21 251.43,145.21 251.23,145.01 v2(251.23,144.37)
  BOTTOM w0.102: v1(251.23,146.26) PH6000.1
  BOTTOM w0.203: PH6000.1 v2(251.23,144.37)
  BOTTOM w0.254: v2(268.13,136.71) PR6009.1 269.78,136.71 PR6008.2
NTC_LB: length 46.8
  IN1 w0.203: v2(267.53,134.91) 268.9,136.28 268.9,138.05 267.39,139.55 267.39,143.24 264.06,146.58 257.2,146.58 256.16,145.54 250.61,145.54 250.31,145.24 v2(250.31,144.37)
  BOTTOM w0.203: PH6000.2 v2(250.31,144.37)
  BOTTOM w0.254: PR6014.2 266.04,131.15 PC6003.2 267.85,131.15 268.11,131.4 268.11,133.05 ; PR6011.2 266.04,134.96 PR6012.2 266.95,134.91 v2(267.53,134.91) 267.72,134.91 ; 267.72,134.91 268.11,134.53 v1(268.11,133.78) 268.11,133.05 ; 267.72,134.91 269.69,134.91 PC6008.1 269.78,134.99 PR6020.1 268.91,135.82 PR6009.2 268.29,135.8 267.29,136.8 PC6006.2 266.04,136.8 PR6010.2 ; 268.11,133.05 PC6004.2 266.04,133.05 PR6013.2
NUM: length 93.7
  TOP w0.102: RE636.1 273.75,33.52 v1(276.31,30.97) 277.44,29.84 277.44,27.41 279.46,25.39 279.46,18.71 280.6,17.57 v2(280.6,17.1)
  IN4 w0.102: v2(280.6,17.1) 279.08,15.58 269.09,15.58 268.79,15.88 261.25,15.88 258.94,13.57 255.15,13.57 254.71,13.13 247.19,13.13 246.19,14.13 246.19,14.36 244.85,15.7 242.5,15.7 240.41,17.79 234.99,17.79 v2(233.96,18.81)
  BOTTOM w0.102: JKB.2 222.97,6.34 223.19,6.56 223.82,6.56 223.97,6.71 223.97,8.17 224.28,8.48 230.58,8.48 232.46,10.36 232.46,16.16 231.75,16.87 231.75,17.39 232.7,18.34 233.5,18.34 v2(233.96,18.81)
NUM_LED: length 34.9
  TOP w0.102: RE637.1 273.03,37.79 273.99,36.84 273.99,34.13 276.39,31.72 v2(277.32,31.72) ; v2(288.59,31.78) 290.14,30.23 290.14,27.15 290.49,26.8 290.49,24.85 292.87,22.47 292.87,21.24 292.64,21.01 UE5.36
  IN3 w0.102: v2(288.59,31.78) 288.32,31.52 285.44,31.52 284.83,32.12 277.73,32.12 v2(277.32,31.72)
  BOTTOM w0.102: v1(277.75,32.06) 277.4,31.72 v2(277.32,31.72)
NVVDD1_EN: length 148.7
  TOP w0.102: v1(318.25,61.04) 318.07,61.04 317.76,60.73 v2(317.76,60.71)
  TOP w0.254: UE10.15 v2(317.76,60.71) ; v2(283.09,162.54) CG481.1 RG549.2 282.98,164.78 282.98,166.9 282.45,167.43 DG7.1 ; PQ8203.2 276.58,149.88 276.3,149.6 PR6036.2 v2(275.92,150.36)
  IN3 w0.254: v2(283.09,162.54) 283.09,159.95 280.23,157.09 280.23,155.81 279,154.58 277.92,154.58 275.92,152.57 v2(275.92,150.36) 275.92,149.07 279.17,145.82 281.66,145.82 285.99,141.48 285.99,109.87 285.97,109.09 285.99,107.77 286.09,106.25 286.2,105 286.32,104.08 286.89,100.87 287.09,99.89 287.59,97.86 287.87,96.81 288.41,94.98 288.9,93.48 289.18,92.55 289.8,91.19 292.24,86.16 v2(292.24,80.61) 292.72,80.13 292.72,77.31 299.78,70.24 299.78,62.35 301.3,60.83 304.97,60.83 305.58,60.22 306.32,60.22 306.94,60.84 314.26,60.84 314.91,60.19 317.24,60.19 v2(317.76,60.71)
  BOTTOM w0.254: v2(292.24,80.61) 291.63,80.61 290.48,79.46 290.37,79.46 289.74,78.83 QG508.2
