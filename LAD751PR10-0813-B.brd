# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBB_WCK23: length 46.3
  IN2 w0.089: v2(245.87,86.65) 245.69,86.47 245.42,86.47 245.14,86.19 245.14,85.66 245.33,85.47 245.33,82 245.88,81.45 246.03,81.45 258,69.49 258.53,69.49 261.92,66.1 261.92,59.79 259.67,57.54 256.23,57.54 256.13,57.44 256.11,57.44 254.35,55.67 253.78,55.67 253.41,55.3 v2(253.17,55.3)
  BOTTOM w0.102: UG9.J39 v2(245.87,86.65)
  BOTTOM w0.119: UG3.D4 v2(253.17,55.3)
FBB_WCK23#: length 46.5
  IN2 w0.089: v2(245.87,85.95) 245.87,86.19 245.78,86.28 245.5,86.28 245.32,86.1 245.32,85.73 245.51,85.54 245.51,82.08 245.95,81.63 246.11,81.63 258.07,69.67 258.61,69.67 262.1,66.18 262.1,59.71 259.74,57.36 256.31,57.36 254.39,55.44 254.39,55.3 254.3,55.21 254.06,55.21 v2(253.97,55.3)
  BOTTOM w0.102: UG9.H39 245.35,85.65 245.26,85.74 245.26,85.92 245.34,86 245.82,86 v2(245.87,85.95)
  BOTTOM w0.119: UG3.D5 v2(253.97,55.3)
FBB_WCK45: length 30.5
  IN2 w0.089: v2(272.95,79.56) 273.33,79.18 273.33,78.32 272.88,77.87 268.85,77.87 260.9,85.82 259.91,85.82 258.01,87.73 255.08,87.73 254.6,88.21 250.68,88.21 250.17,87.7 v2(250.17,87.45)
  BOTTOM w0.102: UG9.L46 v2(250.17,87.45)
  BOTTOM w0.119: UG4.D4 272.55,79.16 v2(272.95,79.56)
FBB_WCK45#: length 30.4
  IN2 w0.089: v2(272.95,78.76) 273,78.76 273.15,78.61 273.15,78.39 272.81,78.05 268.92,78.05 260.97,86 259.99,86 258.08,87.9 255.15,87.9 254.67,88.39 250.61,88.39 250.07,87.85 249.6,87.85 249.47,87.72 v2(249.47,87.45)
  BOTTOM w0.102: UG9.L45 249.59,87.75 249.47,87.63 v2(249.47,87.45)
  BOTTOM w0.119: UG4.D5 272.55,78.64 272.67,78.76 v2(272.95,78.76)
FBB_WCK67: length 44.5
  IN2 w0.089: v2(251.57,85.25) 251.57,85.67 251.72,85.82 252.97,85.82 268.91,69.87 276.12,69.87 277.9,71.66 277.9,74.64 278.68,75.42 279.54,75.42 281.34,77.22 281.34,78.38 v2(280.95,78.76)
  BOTTOM w0.102: UG9.H47 v2(251.57,85.25)
  BOTTOM w0.119: UG4.P4 v2(280.95,78.76)
FBB_WCK67#: length 44.5
  IN2 w0.089: v2(250.77,85.35) 251,85.35 251.65,86 253.04,86 268.99,70.05 276.03,70.05 277.72,71.75 277.72,74.72 278.61,75.6 279.47,75.6 281.15,77.28 281.15,77.48 281.06,77.57 280.96,77.57 280.82,77.71 280.82,77.83 v2(280.95,77.96)
  BOTTOM w0.102: UG9.H46 250.47,85.81 250.55,85.89 250.71,85.89 250.81,85.79 250.81,85.39 v2(250.77,85.35)
  BOTTOM w0.119: v2(280.95,77.96) 280.73,78.18 280.73,78.19 UG4.P5
FBC_CLK0: length 37.8
  TOP w0.119: v2(227.39,61.92) 227.58,61.73 228.13,61.73 RG124.1
  IN6 w0.107: v2(229.07,85.25) 228.85,85.03 228.85,84.61 228.7,84.46 228.7,82.18 228.95,81.93 228.95,75.56 228,74.61 228,73.76 227.89,73.66 227.17,73.66 226.95,73.44 226.95,72.95 227.17,72.73 227.89,72.73 228,72.63 228,72.31 227.89,72.2 227.16,72.2 226.94,71.98 226.94,71.5 227.16,71.27 227.89,71.27 228,71.17 228,70.76 227.89,70.65 227.22,70.65 227,70.43 227,69.95 227.22,69.73 227.89,69.73 228,69.62 228,61.64 227.89,61.53 227.78,61.53 v2(227.39,61.92) 226.98,61.51 226.98,61.2 226.78,61.01 226.78,59.98 225.72,58.91 225.17,58.91 225.04,59.05 224.67,59.05 224.56,59.15 v2(224.56,59.38)
  BOTTOM w0.089: UG9.G15 v2(229.07,85.25)
  BOTTOM w0.119: v2(224.56,59.38) 224.56,59.11 224.37,58.91 UG5.J12
FBC_CLK0#: length 37.8
  TOP w0.119: RG527.1 228.13,61.52 227.58,61.52 v2(227.39,61.33)
  IN6 w0.107: v2(229.22,84.7) 228.9,84.38 228.9,82.26 229.15,82.01 229.15,75.48 228.2,74.53 228.2,73.68 227.98,73.46 227.26,73.46 227.15,73.35 227.15,73.03 227.26,72.93 227.98,72.93 228.2,72.71 228.2,72.22 227.98,72 227.24,72 227.14,71.9 227.14,71.58 227.24,71.47 227.98,71.47 228.2,71.25 228.2,70.68 227.98,70.45 227.31,70.45 227.2,70.35 227.2,70.03 227.31,69.92 227.98,69.92 228.2,69.7 228.2,61.56 227.98,61.33 v2(227.39,61.33) 226.98,60.93 226.98,59.89 225.8,58.72 225.09,58.72 224.96,58.85 224.53,58.85 224.07,59.31 v2(223.79,59.31)
  BOTTOM w0.102: UG9.F15 v2(229.22,84.7)
  BOTTOM w0.119: UG5.J11 v2(223.79,59.31)
FBC_CLK1: length 35.5
  TOP w0.102: v2(232.64,62.26) 232.46,62.08 RG125.1
  IN1 w0.102: v2(233.27,85.95) 233.27,86.15 233.11,86.32 232.81,86.32 232.54,86.04 232.54,84.94 232.88,84.6 232.88,80.73 232.88,80.5
  IN1 w0.107: 232.88,80.5 232.01,79.64 232.01,73.46 232.01,68.75 232.01,61.91 232.29,61.63 232.51,61.63 232.64,61.75 v2(232.64,62.26) 232.94,61.96 232.94,61.45 233.37,61.02 233.37,59.72 234.19,58.9 235.03,58.9 235.28,59.15 235.43,59.15 v2(235.59,59.31)
  BOTTOM w0.102: v2(233.27,85.95) 233.22,86 232.72,86 232.64,85.92 232.64,85.74 232.73,85.65 UG9.H21
  BOTTOM w0.119: v2(235.59,59.31) 235.88,59.31 235.99,59.2 235.99,58.91 UG6.J12
FBC_CLK1#: length 35
  TOP w0.102: v2(232.64,60.96) 232.43,61.17 RG528.1
  IN1 w0.102: v2(233.27,86.65) 232.87,86.65 232.34,86.12 232.34,84.86 232.68,84.52 232.68,80.73 232.68,80.58
  IN1 w0.107: 232.68,80.58 231.82,79.72 231.82,73.46 231.81,68.75 231.81,61.83 232.21,61.43 232.53,61.43 232.61,61.35 232.61,60.99 v2(232.64,60.96) 232.82,61.14 232.97,61.14 233.18,60.94 233.18,59.64 234.11,58.71 235.11,58.71 235.3,58.9 235.97,58.9 v2(236.39,59.31)
  BOTTOM w0.102: UG9.J21 v2(233.27,86.65)
  BOTTOM w0.119: v2(236.39,59.31) 236.62,59.08 236.62,59.08 UG6.J11
FBC_CMD0: length 37.2
  BOTTOM w0.102: 216.59,57.71 UG5.G3 ; 219.46,77.94 224.35,77.94 225.42,79.01 225.42,81.1 225.62,81.3 225.62,81.8 UG9.C11
  BOTTOM w0.185: 216.59,57.71 215.17,57.71 215.02,57.56 214.65,57.56 214.39,57.82 211.64,60.57 211.64,70.13 219.46,77.94
FBC_CMD1: length 36.8
  TOP w0.102: RG51.2 218,58.58 217.54,58.13 216.97,58.13 v2(216.59,58.51)
  BOTTOM w0.102: UG5.J3 v2(216.59,58.51) ; UG9.B11 225.97,81.3 225.62,80.95 225.62,78.88 224.27,77.54 220.07,77.54
  BOTTOM w0.185: 220.07,77.54 212.18,69.65 212.18,60.86 214.59,58.46 215,58.46 215.05,58.51 v2(216.59,58.51)
FBC_CMD2: length 33.1
  TOP w0.102: v2(215.79,59.31) 216.17,59.69 217.59,59.69 217.75,59.53 RG58.1
  BOTTOM w0.102: UG9.A11 225.97,78.92 224.22,77.17 220.97,77.17 ; v2(215.79,59.31) 215.99,59.11 UG5.J2
  BOTTOM w0.185: 220.97,77.17 213.87,70.07 213.87,60.13 214.66,59.34 214.96,59.34 214.99,59.31 v2(215.79,59.31)
FBC_CMD3: length 31.7
  BOTTOM w0.102: UG9.D11 226.32,82.5 226.32,78.91 224.21,76.8 221.68,76.8
  BOTTOM w0.185: UG5.L3 216.58,60.1 215.19,60.1 215.01,60.28 214.9,60.28 214.41,60.78 214.41,69.53 221.68,76.8
FBC_CMD4: length 26.7
  BOTTOM w0.102: 222.41,76.32 224.13,76.32 226.67,78.86 UG9.A12
  BOTTOM w0.185: UG5.K5 218.95,60.08 218.95,64.26 218.95,65.57 217.42,67.1 217.42,71.34 222.41,76.32
FBC_CMD5: length 28.5
  BOTTOM w0.102: 222.75,75.84 224,75.84 227.02,78.87 227.02,80.9 226.67,81.25 UG9.B12 ; 217.79,59.71 UG5.K4
  BOTTOM w0.185: 222.75,75.84 218.13,71.22 218.13,66.84 219.24,65.73 219.24,64.38 219.24,64.38 219.24,59.82 218.77,59.34 218.16,59.34 217.79,59.71
FBC_CMD6: length 28.3
  BOTTOM w0.102: UG9.C12 226.67,82 227.02,81.65 227.02,81.25 227.22,81.05 227.22,78.72 223.77,75.26 223.07,75.26
  BOTTOM w0.185: UG5.J5 218.84,58.91 219.53,59.6 219.53,64.5 219.53,66.21 218.67,67.07 218.67,70.87 223.07,75.26
FBC_CMD7: length 29.3
  BOTTOM w0.102: UG9.C14 227.72,81.8 227.72,81.3 227.47,81.05 227.47,78.65 223.42,74.6 223.22,74.6
  BOTTOM w0.185: 223.22,74.6 219.21,70.58 219.21,67.51 219.82,66.9 219.82,64.62 219.82,59.46 218.87,58.52 218.18,58.52 UG5.J4
FBC_CMD8: length 27.7
  BOTTOM w0.102: UG9.B14 228.07,81.3 227.72,80.95 227.72,78.24 223.49,74.01 221.79,72.31
  BOTTOM w0.185: 221.79,72.31 219.78,70.3 219.78,67.74 220.1,67.42 220.1,64.74 220.1,59.28 218.93,58.11 UG5.H5
FBC_CMD9: length 28.2
  BOTTOM w0.102: UG9.A14 228.07,78.08 222.56,72.57
  BOTTOM w0.185: 222.56,72.57 222.56,71.33 220.39,69.16 220.39,64.86 220.39,58.93 219.2,57.74 218.15,57.74 UG5.H4
FBC_CMD10: length 31.5
  BOTTOM w0.102: UG9.D14 228.42,82.5 228.42,77.91 223.33,72.82
  BOTTOM w0.185: UG5.G12 223.79,57.71 221.96,57.71 221.84,57.82 221.78,57.82 221.67,57.94 221.65,57.94 220.68,58.9 220.68,64.98 220.68,67.39 223.33,70.05 223.33,72.82
FBC_CMD11: length 27
  BOTTOM w0.102: 224.1,73.18 228.77,77.85 UG9.A15
  BOTTOM w0.185: UG5.H10 221.9,58.11 221.79,58.22 221.76,58.22 220.96,59.02 220.96,65.1 220.96,66.74 224.1,69.88 224.1,73.18
FBC_CMD12: length 28.3
  BOTTOM w0.102: 224.87,73.25 229.12,77.5 229.12,80.9 228.77,81.25 UG9.B15
  BOTTOM w0.185: 224.87,73.25 224.87,69.83 221.25,66.21 221.25,65.22 221.25,65.22 221.25,59.14 221.88,58.51 222.99,58.51 UG5.H11
FBC_CMD13: length 28.5
  BOTTOM w0.102: 225.64,73.32 229.42,77.1 229.42,80.95 229.12,81.25 229.12,81.8 UG9.C15
  BOTTOM w0.185: UG5.K11 223.02,59.34 222.26,59.34 221.54,60.06 221.54,65.34 221.54,65.92 223.51,67.89 224.45,67.89 225.64,69.09 225.64,73.32
FBC_CMD14: length 27.4
  BOTTOM w0.102: 226.41,73.39 229.77,76.75 229.77,80.04 229.62,80.18 229.62,81.1 229.82,81.3 229.82,81.57 230.17,81.92 UG9.C17
  BOTTOM w0.185: UG5.K10 222.41,59.71 221.82,60.29 221.82,65.76 223.21,67.15 224.8,67.15 226.41,68.77 226.41,73.39
FBC_CMD15: length 28.4
  BOTTOM w0.102: 227.19,73.47 230.19,76.47 230.19,77.4 230.22,77.43 230.22,80.16 229.82,80.56 229.82,80.95 230.17,81.3 UG9.B17
  BOTTOM w0.185: UG5.L12 223.78,60.1 222.45,60.1 222.2,60.36 222.2,65.67 223.29,66.77 225.75,66.77 227.19,68.2 227.19,73.47
FBC_CMD16: length 33
  BOTTOM w0.102: UG9.B24 235.07,81.25 235.42,80.9 235.42,77.14
  BOTTOM w0.185: 235.42,77.14 243.51,69.06 244.75,69.06 247.23,66.57 247.23,59.21 245.59,57.56 245.13,57.56 244.99,57.71 243.59,57.71 UG6.L3
FBC_CMD17: length 31.8
  TOP w0.102: RG52.2 243.65,58.45 v2(243.59,58.51)
  BOTTOM w0.102: UG9.A24 235.07,76.97 ; v2(243.59,58.51) 243.37,58.73 243.37,58.73 UG6.J3
  BOTTOM w0.185: v2(243.59,58.51) 243.61,58.49 245.73,58.49 246.69,59.45 246.69,66.35 244.56,68.48 243.32,68.48 236.39,75.4 236.39,75.65 235.07,76.97
FBC_CMD18: length 31.9
  TOP w0.102: RG57.1 244.5,59.42 v2(244.39,59.31)
  BOTTOM w0.102: 234.72,76.31 234.72,82.5 UG9.D23 ; v2(244.39,59.31) 244.13,59.06 UG6.J2
  BOTTOM w0.185: v2(244.39,59.31) 245.19,59.31 245.29,59.41 245.7,59.41 246.15,59.87 246.15,66.12 244.87,67.41 243.63,67.41 234.72,76.31
FBC_CMD19: length 28.3
  BOTTOM w0.102: UG9.A23 234.45,80.67 234.45,75.81 ; 245.37,60.46 245.34,60.46
  BOTTOM w0.142: 245.61,61.12 245.61,60.7 245.37,60.46 ; 245.34,60.46 244.99,60.11 243.59,60.11 UG6.G3
  BOTTOM w0.185: 234.45,75.81 243.58,66.69 244.82,66.69 245.61,65.9 245.61,61.12
FBC_CMD20: length 25.5
  BOTTOM w0.102: 234.2,75.3 234.2,80.23 234.01,80.42 234.01,80.94 234.37,81.3 UG9.B23
  BOTTOM w0.185: UG6.H5 241.18,60.11 241.18,65.83 241.71,66.36 241.71,67.79 234.2,75.3
FBC_CMD21: length 27.4
  BOTTOM w0.102: UG9.C23 234.02,81.8 234.02,81.3 233.82,81.1 233.82,74.92
  BOTTOM w0.185: UG6.H4 241.99,59.31 241.44,59.31 240.89,59.85 240.89,65.95 240.94,65.99 240.94,67.8 233.82,74.92
FBC_CMD22: length 27.3
  BOTTOM w0.102: 233.5,74.2 233.5,80.23 233.56,80.3 233.56,81.01 233.32,81.25 233.32,81.65 232.97,82 UG9.C21
  BOTTOM w0.185: UG6.J5 241.19,58.91 240.61,59.49 240.61,66.07 240.64,66.1 240.64,67.33 238.91,69.06 238.64,69.06 235.7,71.99 233.5,74.2
FBC_CMD23: length 28.2
  BOTTOM w0.102: UG9.B21 232.97,81.25 233.33,80.89 233.33,80.52 233.28,80.48 233.28,80.42 233.18,80.32 233.18,73.75
  BOTTOM w0.185: UG6.J4 241.99,58.51 240.89,58.51 240.32,59.08 240.32,66.19 240.34,66.21 240.34,66.88 238.66,68.56 238.37,68.56 233.18,73.75
FBC_CMD24: length 27
  BOTTOM w0.102: UG9.A21 232.91,80.75 232.91,73.26
  BOTTOM w0.185: UG6.K5 240.79,58.11 240.03,58.86 240.03,66.31 240.04,66.31 240.04,66.48 238.42,68.1 238.31,68.1 238.24,68.17 238,68.17 232.91,73.26
FBC_CMD25: length 31.1
  BOTTOM w0.102: UG9.D20 232.62,82.5 232.62,79.51 232.41,79.3 232.41,72.99 ; 242.39,58.11 UG6.K4
  BOTTOM w0.185: 242.39,58.11 241.99,57.71 240.64,57.71 239.74,58.61 239.74,66.33 238.29,67.78 238.23,67.78 238.12,67.88 237.52,67.88 232.41,72.99
FBC_CMD26: length 30.1
  BOTTOM w0.102: UG9.A20 232.27,79.66 232.06,79.45 232.06,74.14 231.72,73.8
  BOTTOM w0.185: 231.72,73.8 231.72,72.92 237.04,67.59 238.01,67.59 239.44,66.16 239.44,58.66 238.49,57.71 236.39,57.71 UG6.L12
FBC_CMD27: length 29.2
  BOTTOM w0.102: 230.99,73.77 231.73,74.51 231.73,79.54 231.95,79.77 231.95,80.61 231.94,80.62 231.94,80.89 231.95,80.89 231.95,80.98 232.27,81.3 UG9.B20
  BOTTOM w0.185: UG6.K10 238.39,58.11 239.15,58.88 239.15,66.04 237.89,67.31 236.56,67.31 234.76,69.11 230.99,72.88 230.99,73.77
FBC_CMD28: length 30.8
  BOTTOM w0.102: UG9.C20 231.92,81.8 231.92,81.3 231.71,81.09 231.71,80.07 231.43,79.8 231.43,77.35 231.43,77.35 231.43,74.91 230.58,74.06
  BOTTOM w0.185: 230.58,74.06 230.58,72.32 235.88,67.02 237.77,67.02 238.87,65.92 238.87,59.04 238.34,58.51 237.19,58.51 UG6.K11
FBC_CMD29: length 30.3
  BOTTOM w0.102: UG9.C18 230.87,82 231.22,81.65 231.22,81.25 231.45,81.02 231.45,80.35 231.15,80.04 231.15,75.33 230.01,74.19 ; 236.79,59.71 UG6.H11
  BOTTOM w0.185: 230.01,74.19 230.01,72.13 235.4,66.73 237.65,66.73 238.58,65.8 238.58,59.7 238.29,59.41 237.89,59.41 237.79,59.31 237.19,59.31 236.79,59.71
FBC_CMD30: length 29.7
  BOTTOM w0.102: UG9.B18 230.87,81.25 231.22,80.9 231.22,80.57 230.88,80.23 230.88,75.76 228.73,73.61
  BOTTOM w0.185: UG6.H10 237.93,59.71 238.29,60.08 238.29,65.68 237.53,66.45 235.19,66.45 234.58,67.06 234.29,67.06 232.23,69.12 230.89,69.12 228.73,71.28 228.73,73.61
FBC_CMD31: length 30.6
  BOTTOM w0.102: 227.96,73.54 230.54,76.12 230.54,80.42 UG9.A18
  BOTTOM w0.185: 227.96,73.54 227.96,71.28 230.66,68.58 232,68.58 234.13,66.45 234.72,66.45 235.01,66.16 237.41,66.16 238.01,65.56 238.01,60.38 237.74,60.11 236.39,60.11 UG6.G12
FBC_D0: length 20.3
  IN6 w0.102: v2(222.81,82.44) 221.93,81.57 221.93,80.21 221.62,79.9 221.62,77.95
  IN6 w0.13: 221.62,77.95 219.32,75.64 219.32,72.59 217.09,70.36 217.09,66.26 v2(217.18,66.17)
  BOTTOM w0.102: v2(217.18,66.17) 217.18,65.92 217.52,65.58 217.52,65.58 UG5.U4 ; UG9.C6 222.76,82.44 v2(222.81,82.44)
FBC_D1: length 20.5
  IN6 w0.102: v2(221.23,79.11) 221.23,78.57
  IN6 w0.13: 221.23,78.57 218.64,75.98 218.64,72.87 216.53,70.75 216.53,66.81 215.79,66.07 v2(215.79,65.71)
  BOTTOM w0.102: v2(215.79,65.71) 216,65.5 216,65.5 UG5.U2 ; UG9.D6 222.13,82.51 222.13,80.01 v2(221.23,79.11)
FBC_D2: length 19.6
  IN6 w0.102: v2(222.81,79.93) 223.1,79.93 223.49,79.53 223.49,78.31 223.13,77.95 222.97,77.95
  IN6 w0.13: v2(217.39,64.91) 218.21,65.73 218.21,69.9 220.48,72.16 220.48,75.45 222.97,77.95
  BOTTOM w0.102: UG9.A6 222.47,80.27 v2(222.81,79.93) ; UG5.T4 217.62,64.67 v2(217.39,64.91)
FBC_D3: length 20.7
  IN6 w0.102: 222.09,77.72 222.09,79.7 222.33,79.94 222.33,80.71 v2(222.77,81.15)
  IN6 w0.13: v2(215.79,64.91) 216.19,65.31 217.17,65.31 217.65,65.79 217.65,70.13 219.88,72.35 219.88,75.5 222.09,77.72
  BOTTOM w0.102: v2(215.79,64.91) 216,64.7 UG5.T2 ; UG9.B6 v2(222.77,81.15)
FBC_D4: length 26.2
  IN6 w0.102: v2(220.77,81.15) 219.92,80.3 219.92,78.53
  IN6 w0.13: v2(217.39,61.71) 216.99,62.11 214.69,62.11 213.76,63.04 213.76,69.7 217.45,73.39 217.45,76.06 219.92,78.53
  BOTTOM w0.102: UG5.N4 217.62,61.95 v2(217.39,61.71) ; v2(220.77,81.15) UG9.B4
FBC_D5: length 22.6
  IN6 w0.102: 218.01,76.05 220.35,78.39 220.35,79.51 v2(220.44,79.6)
  IN6 w0.13: v2(215.79,62.51) 215.39,62.91 214.75,62.91 214.32,63.34 214.32,69.47 218.01,73.16 218.01,76.05
  BOTTOM w0.102: v2(215.79,62.51) UG5.N2 ; v2(220.44,79.6) 221.03,80.18 221.03,80.71 UG9.A4
FBC_D6: length 29.4
  IN6 w0.13: v2(217.39,60.91) 216.89,60.41 214.64,60.41 211.68,63.36 211.68,69.21 216.32,73.85 216.32,76.8 v2(219.12,79.6)
  BOTTOM w0.102: UG5.M4 217.61,61.13 v2(217.39,60.91) ; UG9.B3 220.02,81.1 220.02,80.5 v2(219.12,79.6)
FBC_D7: length 27.4
  IN6 w0.102: v2(220.77,81.85) 220.27,81.35 220.27,81.05 219.52,80.3 219.52,79.42
  IN6 w0.13: 219.52,79.42 219.52,79.08 216.89,76.45 216.89,73.62 212.25,68.98 212.25,63.59 214.53,61.31 215.39,61.31 v2(215.79,61.71)
  BOTTOM w0.102: UG5.M2 216.01,61.49 v2(215.79,61.71) ; UG9.C4 v2(220.77,81.85)
FBC_D8: length 18.9
  IN1 w0.13: v2(224.87,82.55) 224.47,82.15 224.47,80.97 225.19,80.25 225.19,77.41 224,76.22 224,65.92 v2(223.79,65.71)
  BOTTOM w0.102: v2(223.79,65.71) 223.56,65.48 UG5.U11 ; UG9.D9 v2(224.87,82.55)
FBC_D9: length 17.7
  IN1 w0.13: v2(225.39,65.71) 225.39,76.76 225.86,77.23 225.86,80.86 v2(224.87,81.85)
  BOTTOM w0.102: UG5.U13 225.15,65.47 225.15,65.47 v2(225.39,65.71) ; UG9.C9 v2(224.87,81.85)
FBC_D10: length 20.5
  IN1 w0.13: v2(225,83.4) 224.06,82.46 224.06,80.26 224.22,80.1 224.22,77.38 223.39,76.55 223.39,65.31 v2(223.79,64.91)
  BOTTOM w0.102: UG9.E9 224.72,83.4 v2(225,83.4) ; v2(223.79,64.91) 223.79,64.91 UG5.T11
FBC_D11: length 17.8
  IN2 w0.117: v2(225.39,64.91) 224.99,65.31 224.99,67.89 225.07,67.97 225.07,79.65 v2(224.64,80.08)
  BOTTOM w0.102: v2(224.64,80.08) 224.22,80.5 224.22,81.1 UG9.B9 ; v2(225.39,64.91) UG5.T13
FBC_D12: length 22.2
  IN1 w0.13: v2(222.5,79.07) 221.9,78.46 221.9,77.97 221.2,77.27 221.2,64.19 222.48,62.91 223.19,62.91 223.59,62.51 v2(223.79,62.51)
  BOTTOM w0.102: UG9.B8 223.51,81.08 223.51,80.04 222.53,79.07 v2(222.5,79.07) ; UG5.N11 v2(223.79,62.51)
FBC_D13: length 22.4
  IN1 w0.13: v2(223.08,78.42) 223.08,78.22 221.76,76.9 221.76,64.64 222.69,63.71 223.19,63.71 223.39,63.51 223.39,63.11 223.59,62.91 224.99,62.91 v2(225.39,62.51)
  BOTTOM w0.102: UG5.N13 225.15,62.27 v2(225.39,62.51) ; UG9.A8 223.87,79.07 223.22,78.42 v2(223.08,78.42)
FBC_D14: length 27.3
  IN1 w0.13: v2(223.79,61.71) UG5.M11 222.23,61.31 220.08,63.46 220.08,78.68 220.61,79.21 221.46,80.06 221.64,80.06 221.86,80.28 221.86,80.62 221.85,80.63 221.85,80.97 221.86,80.98 221.86,81.32 221.85,81.33 221.85,81.67 221.86,81.68 221.86,82.02 221.85,82.03 221.85,82.97 221.86,82.98 221.86,83.32 221.85,83.33 221.85,83.63 v2(222.17,83.95)
  BOTTOM w0.102: UG9.F6 v2(222.17,83.95) ; UG5.M11 v2(223.79,61.71)
FBC_D15: length 27.5
  IN1 w0.13: v2(225.39,61.71) 224.99,62.11 222.36,62.11 220.64,63.83 220.64,77.92 222.36,79.64 222.36,83.44 v2(222.77,83.85)
  BOTTOM w0.102: UG5.M13 225.18,61.5 v2(225.39,61.71) ; v2(222.77,83.85) UG9.E6
FBC_D16: length 43.2
  IN1 w0.13: v2(222.99,52.11) 223.19,51.91 223.28,51.91 223.88,51.31 223.88,51.14 224.21,50.81 227.66,50.81 231.15,54.29 231.15,73.67 231,73.82 231,79.75 232.21,80.96 232.21,83.22 232.4,83.41 232.4,84.18 232.24,84.34 231.58,84.34 v2(231.27,84.65)
  BOTTOM w0.102: UG5.A11 223.39,52.51 v2(222.99,52.11) ; UG9.F18 v2(231.27,84.65)
FBC_D17: length 38.3
  IN1 w0.13: v2(231.17,85.25) 230.73,84.81 230.73,81.21 229.42,79.9 229.42,70.62 229.94,70.1 229.94,54.68 227.19,51.93 226.39,51.93 226.21,52.11 v2(225.39,52.11)
  BOTTOM w0.102: UG9.G18 v2(231.17,85.25) ; v2(225.39,52.11) UG5.A13
FBC_D18: length 40.4
  IN1 w0.13: v2(222.99,52.91) 223.39,52.51 223.96,52.51 224.19,52.28 224.19,51.85 224.31,51.73 224.47,51.73 224.83,51.37 227.43,51.37 230.51,54.45 230.51,72.93 230.39,73.05 230.39,79.99 231.26,80.86 231.26,81.19 231.87,81.8 231.87,82.55 v2(231.17,83.25)
  BOTTOM w0.102: v2(231.17,83.25) UG9.E18 ; UG5.B11 223.2,53.13 v2(222.99,52.91)
FBC_D19: length 39.7
  IN1 w0.13: v2(231.34,86.13) 230.28,85.06 230.28,81.68 228.86,80.26 228.86,70.39 229.37,69.88 229.37,54.9 226.96,52.49 226.61,52.49 226.59,52.52 226.35,52.52 226.35,52.51 226.02,52.51 226.02,52.52 225.55,52.52 225.55,52.51 225.22,52.51 225.22,52.52 224.98,52.52 v2(224.59,52.91)
  BOTTOM w0.102: UG5.B13 224.8,53.12 v2(224.59,52.91) ; UG9.H18 v2(231.34,86.13)
FBC_D20: length 33.9
  IN1 w0.13: v2(223.79,55.31) 224.19,54.91 227.69,54.91 228.8,56.02 228.8,69.66 228.3,70.16 228.3,80.69 229.13,81.52 229.13,82.2 v2(229.31,82.38)
  BOTTOM w0.102: v2(229.31,82.38) 229.26,82.38 228.79,82.85 UG9.D15 ; v2(223.79,55.31) UG5.E11
FBC_D21: length 33.2
  IN1 w0.13: v2(229.27,83.78) 228.85,83.36 228.85,82.73 228.67,82.55 228.67,81.64 227.74,80.71 227.74,69.67 228.23,69.18 228.23,56.79 227.15,55.71 UG5.E13 v2(224.59,56.11)
  BOTTOM w0.102: v2(229.27,83.78) 229,83.78 UG9.E15 ; UG5.E13 224.81,55.89 v2(224.59,56.11)
FBC_D22: length 33.1
  IN1 w0.13: v2(229.77,84.65) 229.43,84.31 229.15,84.31 228.47,83.63 228.47,82.99 228.19,82.71 228.19,81.74 227.18,80.73 227.18,77.15 226.95,76.92 226.95,58.92 226.33,58.3 226.32,58.3 226.09,58.07 226.09,58.07 225.79,57.77 225.79,56.76 225.78,56.75 225.78,56.75 225.55,56.51 224.19,56.51 v2(223.79,56.11)
  BOTTOM w0.102: UG9.G17 230.12,84.95 229.82,84.65 v2(229.77,84.65) ; UG5.F11 v2(223.79,56.11)
FBC_D23: length 32.5
  IN1 w0.13: v2(225.39,56.91) 225.39,58.1 226.59,59.3 226.59,65.87 226.39,66.07 226.39,77.12 226.56,77.29 226.56,80.66 227.64,81.74 227.64,82.75 228.07,83.18 228.07,84.2 228.22,84.35 228.22,85.01 228.86,85.65 229.57,85.65 v2(229.87,85.95)
  BOTTOM w0.102: UG5.F13 225.16,56.68 225.16,56.69 v2(225.39,56.91) ; UG9.H17 v2(229.87,85.95)
FBC_D24: length 41
  IN6 w0.102: 227.91,76.3 227.91,80.66 228.17,80.92 228.17,82.02 228.3,82.15 228.3,85.89 229.06,86.65 v2(229.07,86.65)
  IN6 w0.13: v2(218.09,52.11) 218.1,52.1 219.59,52.1 220.61,53.12 220.61,54.2 221.62,55.21 221.62,57.76 222.52,58.66 222.52,59.23 222.43,59.32 222.43,66.11 222.95,66.63 224.8,68.48 224.8,73.19 227.91,76.3
  BOTTOM w0.102: UG5.A4 217.79,52.42 v2(218.09,52.11) ; UG9.J15 v2(229.07,86.65)
FBC_D25: length 43
  IN6 w0.089: v2(229.22,86.1) 229.21,86.1
  IN6 w0.102: 229.21,86.1 228.51,85.4 228.51,80.3 228.33,80.12 228.33,75.83
  IN6 w0.13: v2(216.59,52.11) 216.98,51.71 219.97,51.71 221.37,53.12 221.37,53.63 222.51,54.77 222.51,57.77 223.18,58.43 223.18,59.57 223.39,59.78 223.39,66.18 225.43,68.22 225.43,72.93 228.33,75.83
  BOTTOM w0.102: UG9.H15 v2(229.22,86.1) ; UG5.A2 216.38,52.32 v2(216.59,52.11)
FBC_D26: length 36.4
  IN6 w0.102: 226.83,77.34 226.83,80.97 227.59,81.73 227.59,82.49 227.9,82.8 227.9,83.55 v2(227.64,83.81)
  IN6 w0.13: v2(218.19,52.91) 218.59,53.31 219.14,53.31 219.14,53.31 219.15,53.31 219.38,53.55 219.38,53.55 219.46,53.64 219.46,55.03 220.54,56.11 220.54,59.19 221.13,59.78 221.13,66.69 223.47,69.03 223.47,73.98 226.83,77.34
  BOTTOM w0.102: UG5.B4 217.96,53.14 217.96,53.14 v2(218.19,52.91) ; v2(227.64,83.81) 227.81,83.81 UG9.E14
FBC_D27: length 39.6
  IN6 w0.102: v2(227.77,84.55) 228.11,84.21 228.11,82.71 227.86,82.47 227.86,81.37 227.47,80.98 227.47,76.78
  IN6 w0.13: 227.47,76.78 224.15,73.46 224.15,68.76 223.61,68.21 221.75,66.36 221.75,59.5 221.07,58.82 221.07,55.68 219.97,54.58 219.97,53.31 219.16,52.5 218.26,52.5 218.26,52.5 217.93,52.5 217.92,52.5 217.84,52.5 217.43,52.91 v2(216.59,52.91)
  BOTTOM w0.102: v2(216.59,52.91) 216.37,53.13 216.36,53.13 UG5.B2 ; UG9.F14 v2(227.77,84.55)
FBC_D28: length 36.7
  IN6 w0.102: 225.97,77.38 226,77.38 226.37,77.75 226.37,81.56 226.58,81.77 226.58,85.04 v2(225.67,85.95)
  IN6 w0.13: v2(217.39,56.11) 217.79,55.71 219.22,55.71 219.93,56.42 219.93,59.33 220.46,59.86 220.46,66.92 222.83,69.29 222.83,74.24 225.97,77.38
  BOTTOM w0.102: UG9.H11 v2(225.67,85.95) ; UG5.E4 v2(217.39,56.11)
FBC_D29: length 37.3
  IN6 w0.102: v2(225.12,84.9) 225.17,84.95 225.82,84.95 226.27,84.5 226.27,82.99 226.22,82.94 226.22,81.96 225.75,81.49 225.75,78.06
  IN6 w0.13: 225.75,78.06 222.19,74.5 222.19,69.55 220.04,67.4 219.93,67.29 219.93,60.22 219.53,59.82 219.53,56.74 219.3,56.51 216.19,56.51 v2(215.79,56.11)
  BOTTOM w0.102: UG5.E2 215.79,56.11 v2(215.79,56.11) ; v2(225.12,84.9) 225.17,84.95 UG9.G11
FBC_D30: length 31.4
  IN6 w0.102: v2(225.67,83.95) 225.98,83.64 225.98,83.12 225.89,83.03 225.89,82.13 225.36,81.6 225.36,80.86 225.12,80.61 225.12,78.29
  IN6 w0.13: v2(218.19,56.91) 218.67,57.39 218.67,59.72 219.33,60.38 219.33,68.86 221.63,71.16 221.63,74.8 225.12,78.29
  BOTTOM w0.102: UG9.F11 v2(225.67,83.95) ; v2(218.19,56.91) UG5.F4
FBC_D31: length 31.9
  IN6 w0.102: 224.27,78.27 224.27,82.58 224.69,83 225.27,83 v2(225.57,83.3)
  IN6 w0.13: v2(216.59,56.91) 216.99,57.31 217.61,57.31 218.01,57.71 218.01,59.96 218.77,60.72 218.77,69.32 221.05,71.6 221.05,75.06 224.27,78.27
  BOTTOM w0.102: UG5.F2 216.35,56.68 v2(216.59,56.91) ; v2(225.57,83.3) 225.72,83.3 UG9.E11
FBC_D32: length 24.5
  IN1 w0.102: 238.72,82.81 238.72,84.11 238.86,84.26 238.86,86.06 v2(238.27,86.65)
  IN1 w0.13: v2(242.79,65.71) 243.3,66.22 243.3,68.22 238.96,72.56 238.96,80.69 238.57,81.09 238.57,82.66 238.72,82.81
  BOTTOM w0.102: v2(242.79,65.71) 242.79,65.71 UG6.A4 ; UG9.J29 v2(238.27,86.65)
FBC_D33: length 21.8
  IN1 w0.102: v2(239.57,83.95) 239.19,83.57 239.19,83.09
  IN1 w0.13: v2(244.39,65.71) 244.67,66 244.67,69.66 240.04,74.29 240.04,81.06 239.27,81.83 239.27,83.01 239.19,83.09
  BOTTOM w0.102: UG6.A2 244.15,65.48 v2(244.39,65.71) ; v2(239.57,83.95) UG9.F30
FBC_D34: length 23.7
  IN1 w0.102: v2(238.27,85.35) 238.6,85.02 238.6,84.37 238.5,84.27 238.5,83.08
  IN1 w0.13: 238.5,83.08 238.25,82.83 238.25,81.92 238.13,81.8 238.13,72.6 242.32,68.4 242.32,65.37 v2(242.79,64.91)
  BOTTOM w0.102: v2(242.79,64.91) 242.79,64.91 UG6.B4 ; UG9.H29 v2(238.27,85.35)
FBC_D35: length 23.9
  IN1 w0.102: 238.96,82.61 238.96,83.94 239.2,84.18 239.2,84.88 v2(239.57,85.25)
  IN1 w0.13: v2(244.39,64.91) 243.91,65.38 243.91,69.56 239.44,74.04 239.44,80.89 238.92,81.41 238.92,82.57 238.96,82.61
  BOTTOM w0.102: v2(244.39,64.91) 244.13,64.65 UG6.B2 ; UG9.G30 v2(239.57,85.25)
FBC_D36: length 26.8
  IN1 w0.13: v2(242.79,61.71) 243.19,62.11 245.94,62.11 246.86,63.03 246.86,69.06 242.26,73.66 242.26,74.61 v2(240.62,76.25)
  BOTTOM w0.102: UG9.B30 239.27,81.25 239.6,80.92 239.6,80.62 239.54,80.56 239.54,79.62 239.58,79.57 239.58,77.65 240.16,77.08 240.16,76.71 v2(240.62,76.25) ; UG6.E4 v2(242.79,61.71)
FBC_D37: length 22.8
  IN1 w0.13: v2(244.39,62.51) 244.79,62.91 245.54,62.91 246.1,63.47 246.1,69.03 240.52,74.61 v2(240.52,75.11)
  BOTTOM w0.102: UG9.A30 239.27,77.25 239.65,76.87 239.65,76.45 240.22,75.88 240.22,75.41 v2(240.52,75.11) ; UG6.E2 244.18,62.31 v2(244.39,62.51)
FBC_D38: length 35.2
  IN1 w0.102: 240.8,83.78 240.61,83.59 240.61,80.88 ; 240.8,85.5 240.59,85.72 239.8,85.72 v2(239.57,85.95)
  IN1 w0.13: v2(242.79,60.91) 243.28,60.42 246.61,60.42 247.98,61.8 247.98,69.53 244.33,73.18 244.33,74.54 241.41,77.47 241.35,77.47 241.02,77.8 241.02,80.47 240.61,80.88 ; 240.8,83.78 240.8,85.5
  BOTTOM w0.102: UG9.H30 v2(239.57,85.95) ; UG6.F4 v2(242.79,60.91)
FBC_D39: length 27.7
  IN1 w0.13: v2(244.39,61.71) 244.79,61.31 246.66,61.31 247.42,62.07 247.42,69.29 243.21,73.5 243.21,74.39 241.06,76.54 241.06,77.16 240.82,77.4 v2(240.63,77.4)
  BOTTOM w0.102: UG6.F2 244.18,61.5 v2(244.39,61.71) ; v2(240.63,77.4) 240.62,77.4 239.91,78.11 239.91,79.65 239.81,79.75 239.81,81.06 239.62,81.25 239.62,81.6 239.27,81.95 UG9.C30
FBC_D40: length 19.2
  IN6 w0.102: 236,80.18 236.12,80.3 236.12,80.4 236.13,80.41 236.13,80.41 236.36,80.64 236.92,80.64 237.36,81.08 237.36,82.44 v2(237.47,82.55)
  IN6 w0.13: 236,80.18 236,74.34 236.29,74.05 236.29,69.69 236.69,69.29 236.69,66.01 v2(236.39,65.71)
  BOTTOM w0.102: UG6.A11 v2(236.39,65.71) ; UG9.D27 v2(237.47,82.55)
FBC_D41: length 23.4
  IN6 w0.102: v2(236.13,86.64) 236.18,86.64 236.57,86.25 236.57,82.35 235.61,81.4 235.1,81.4 234.54,80.83 234.57,80.8
  IN6 w0.13: v2(234.79,65.71) 234.61,65.89 234.61,74.05 234.61,74.05 234.57,74.09 234.57,80.8
  BOTTOM w0.102: UG9.J26 236.18,86.64 v2(236.13,86.64) ; UG6.A13 235.02,65.47 v2(234.79,65.71)
FBC_D42: length 21.9
  IN6 w0.102: v2(237.47,84.55) 237.04,84.12 237.04,81.59 236.5,81.04 236.23,81.04 235.58,80.4
  IN6 w0.13: v2(236.39,64.91) 235.99,65.3 235.99,68.75 235.73,69.01 235.73,74.05 235.58,74.2 235.58,80.4
  BOTTOM w0.102: UG6.B11 236.62,64.68 v2(236.39,64.91) ; UG9.F27 v2(237.47,84.55)
FBC_D43: length 22.5
  IN6 w0.102: 235.05,80.33 236.72,82 236.72,82.1 236.79,82.17 236.79,84.57 v2(237.47,85.25)
  IN6 w0.13: 235.05,80.33 235.05,74.17 235.17,74.05 235.17,73.82 235.17,73.82 235.17,65.89 235.18,65.87 235.18,65.55 235.17,65.53 235.17,65.29 v2(234.79,64.91)
  BOTTOM w0.102: v2(234.79,64.91) UG6.B13 ; UG9.G27 v2(237.47,85.25)
FBC_D44: length 23.3
  IN6 w0.102: v2(238.52,78.5) 237.74,77.72 237.74,77.22 237.76,77.2 237.76,74.3 238.24,73.82
  IN6 w0.13: v2(236.39,62.51) 236.79,62.91 237.81,62.91 238.95,64.05 238.95,71.19 238.83,71.32 238.24,71.9 238.24,73.82
  BOTTOM w0.102: UG9.C27 237.17,82 237.52,81.65 237.52,81.25 237.8,80.97 237.8,79.22 v2(238.52,78.5) ; v2(236.39,62.51) UG6.E11
FBC_D45: length 25.4
  IN6 w0.102: 238.83,73.82 238.12,74.53 238.12,77.5 v2(238.52,77.9)
  IN6 w0.13: 238.83,73.82 238.83,72.86 238.84,72.85 238.84,72.09 239.39,71.55 239.66,71.28 239.66,63.72 238.05,62.11 235.38,62.11 234.98,61.71 v2(234.79,61.71)
  BOTTOM w0.102: UG6.E13 235.02,61.95 235.02,61.94 v2(234.79,61.71) ; UG9.B27 237.17,81.25 237.52,80.9 237.52,78.9 v2(238.52,77.9)
FBC_D46: length 24.1
  IN6 w0.102: 239.4,73.82 238.61,74.61 238.61,76.71 v2(238.57,76.75)
  IN6 w0.13: v2(236.39,61.71) 236.4,61.71 236.8,61.31 238.2,61.31 240.22,63.33 240.22,71.05 240.22,71.51 239.95,71.78 239.4,72.33 239.4,73.82
  BOTTOM w0.102: UG9.A27 237.17,78.15 v2(238.57,76.75) ; v2(236.39,61.71) UG6.F11
FBC_D47: length 29.6
  IN6 w0.102: 237.68,73.82 237.33,74.17 237.33,78.26 237.97,78.9 237.97,80.38 238.64,81.05 238.64,83.3 v2(238.13,83.81)
  IN6 w0.13: 237.68,73.82 237.68,71.67 238.39,70.96 238.39,64.42 237.68,63.71 236.11,63.71 235.99,63.59 235.99,63.05 235.85,62.91 234.6,62.91 234.26,62.57 234.26,61.44 v2(234.79,60.91)
  BOTTOM w0.102: v2(238.13,83.81) 238.2,83.88 238.2,84.34 238.57,84.71 UG9.G29 ; UG6.F13 235.04,61.16 v2(234.79,60.91)
FBC_D48: length 43.7
  IN6 w0.102: v2(231.97,85.95) 231.82,85.95 231.57,85.7 230.82,85.7 230.27,85.15 230.27,83.01 230.09,82.83
  IN6 w0.13: v2(236.39,52.11) 236.4,52.1 236.4,51.35 235.75,50.7 233.98,50.7 228.82,55.86 228.82,73.03 230.09,74.3 230.09,82.83
  BOTTOM w0.102: v2(236.39,52.11) 236.62,52.34 UG6.U11 ; UG9.H20 v2(231.97,85.95)
FBC_D49: length 34.3
  IN6 w0.102: 231.02,82.4 v2(231.17,82.55)
  IN6 w0.13: v2(234.79,52.11) 234.39,52.51 233.84,52.51 233.83,52.51 233.82,52.51 233.59,52.75 233.59,52.75 232.05,54.29 232.04,54.29 229.95,56.38 229.95,72.53 231.02,73.61 231.02,82.4
  BOTTOM w0.102: UG6.U13 v2(234.79,52.11) ; UG9.D18 v2(231.17,82.55)
FBC_D50: length 40.7
  IN6 w0.102: v2(231.85,84.73) 231.85,84.62 231.48,84.25 231.07,84.25 230.68,83.86 230.68,82.83 230.53,82.68
  IN6 w0.13: v2(236.39,52.91) 235.99,52.51 235.99,51.86 235.85,51.72 235.75,51.72 235.74,51.71 233.82,51.71 233.82,51.72 233.78,51.72 229.38,56.12 229.38,72.79 230.53,73.94 230.53,82.68
  BOTTOM w0.102: UG9.G20 232.05,84.73 v2(231.85,84.73) ; v2(236.39,52.91) 236.6,53.13 UG6.T11
FBC_D51: length 35.3
  IN6 w0.102: 231.66,81.65 231.86,81.85 231.86,83.28 v2(231.72,83.42)
  IN6 w0.13: 231.66,81.65 231.66,73.45 230.51,72.3 230.51,56.62 233.81,53.31 235.15,53.31 235.55,52.91 v2(235.59,52.91)
  BOTTOM w0.102: v2(231.72,83.42) 231.79,83.35 232.07,83.35 UG9.E20 ; UG6.T13 235.36,53.14 235.36,53.14 v2(235.59,52.91)
FBC_D52: length 36
  IN6 w0.102: 232.31,83.53 233.06,84.28 233.54,84.28 v2(233.97,83.85)
  IN6 w0.13: 232.31,83.53 232.31,73.31 231.07,72.07 231.07,57.67 233.03,55.7 235.99,55.7 v2(236.39,55.31)
  BOTTOM w0.102: UG9.F23 v2(233.97,83.85) ; UG6.N11 v2(236.39,55.31)
FBC_D53: length 30.8
  IN6 w0.102: v2(233.27,83.25) 232.87,82.85
  IN6 w0.13: 232.87,82.85 232.87,73.07 231.63,71.83 231.63,58.23 233.82,56.04 234.72,56.04 v2(234.79,56.11)
  BOTTOM w0.102: v2(234.79,56.11) 234.79,56.11 UG6.N13 ; UG9.E21 v2(233.27,83.25)
FBC_D54: length 31.5
  IN6 w0.102: 233.48,81 233.96,81.48 233.96,82.26 233.67,82.55 v2(233.27,82.55)
  IN6 w0.13: v2(236.39,56.11) 235.99,56.51 234.12,56.51 232.19,58.44 232.19,71.6 233.48,72.89 233.48,81
  BOTTOM w0.102: UG9.D21 v2(233.27,82.55) ; UG6.M11 236.59,56.31 236.59,56.31 v2(236.39,56.11)
FBC_D55: length 28.7
  IN6 w0.102: v2(233.97,83.3) 234.34,82.93 234.34,81.02 234.05,80.73
  IN6 w0.13: v2(234.79,56.91) 233.24,58.45 233.24,71.86 234.05,72.66 234.05,80.73
  BOTTOM w0.102: v2(234.79,56.91) 234.99,56.71 234.99,56.7 UG6.M13 ; v2(233.97,83.3) 234.12,83.3 UG9.E23
FBC_D56: length 40
  IN1 w0.13: v2(235.37,85.25) 234.5,84.38 234.5,80.58 232.99,79.07 232.99,70.72 237.69,66.03 237.69,57.78 238.75,56.72 238.75,54.72 240.96,52.51 242.39,52.51 v2(242.79,52.91)
  BOTTOM w0.102: v2(242.79,52.91) 242.39,52.51 UG6.U4 ; UG9.G24 v2(235.37,85.25)
FBC_D57: length 40.9
  IN1 w0.13: v2(236.17,85.95) 237.06,85.06 237.06,82.06 237.5,81.62 237.5,72.43 241.5,68.43 241.5,60.56 242.35,59.71 244.61,59.71 244.86,59.45 244.86,57.94 245.59,57.21 245.63,57.17 245.63,52.74 245.4,52.51 244.79,52.51 v2(244.39,52.91)
  BOTTOM w0.102: UG6.U2 244.13,52.65 244.13,52.65 v2(244.39,52.91) ; UG9.H26 v2(236.17,85.95)
FBC_D58: length 37.2
  IN1 w0.13: v2(235.37,84.55) 234.95,84.13 234.95,80.3 233.59,78.94 233.59,70.92 238.64,65.87 238.64,57.73 239.5,56.86 239.5,54.71 240.91,53.31 241.59,53.31 v2(241.99,52.91)
  BOTTOM w0.102: UG9.F24 v2(235.37,84.55) ; v2(241.99,52.91) 242.39,53.31 UG6.T4
FBC_D59: length 36.6
  IN1 w0.13: v2(244.39,53.71) 244.79,54.11 244.79,57.14 244.06,57.87 244.06,58.63 243.78,58.9 242.13,58.9 242.02,59.01 241.08,59.96 241.08,68.06 236.94,72.2 236.94,81.7 236.77,81.86 236.77,84.05 v2(236.17,84.65)
  BOTTOM w0.102: UG6.T2 244.15,53.47 v2(244.39,53.71) ; v2(236.17,84.65) UG9.G26
FBC_D60: length 35.2
  IN1 w0.13: v2(242.79,56.11) 242.3,55.62 241.03,55.62 240.32,56.33 240.32,56.9 239.12,58.1 239.12,66.28 234.17,71.23 234.17,78.81 235.49,80.13 235.49,81.18 236.44,82.12 236.44,83.68 v2(236.17,83.95)
  BOTTOM w0.102: v2(242.79,56.11) 242.55,55.87 UG6.N4 ; UG9.F26 v2(236.17,83.95)
FBC_D61: length 32.9
  IN1 w0.13: v2(243.59,56.11) 243.19,56.51 241.66,56.51 241.51,56.65 241.51,57.08 239.54,59.05 239.54,66.76 234.8,71.5 234.8,76.2 234.81,76.21 234.81,77.99 v2(236.52,79.7)
  BOTTOM w0.102: v2(236.52,79.7) 236.91,80.09 236.91,80.46 236.82,80.55 236.82,82.5 UG9.D26 ; UG6.N2 v2(243.59,56.11)
FBC_D62: length 29
  IN1 w0.13: v2(242.79,56.91) 242.6,56.91 240.23,59.28 240.23,67.11 235.41,71.93 235.41,77.84 v2(236.52,78.95)
  BOTTOM w0.102: v2(242.79,56.91) 242.64,56.77 242.64,56.76 UG6.M4 ; v2(236.52,78.95) 236.12,79.35 236.12,80.88 236.47,81.23 UG9.B26
FBC_D63: length 31.3
  IN1 w0.102: v2(244.39,56.11) 243.99,56.51 243.99,57.19
  IN1 w0.13: v2(236.52,77.75) 236.1,77.33 236.1,73.85 236.07,73.82 236.07,72.18 240.65,67.6 240.65,59.55 242.1,58.11 243.07,58.11 243.99,57.19
  BOTTOM w0.102: UG6.M2 v2(244.39,56.11) ; UG9.C26 236.12,81.8 236.12,81.27 235.89,81.04 235.89,78.38 v2(236.52,77.75)
FBC_DBI0: length 23.5
  IN2 w0.117: v2(215.79,63.31) 215.39,63.71 214.46,63.71 213.92,64.25 213.92,68.78 219.59,74.45 219.59,80.01 220.13,80.55 221.37,80.55 v2(221.47,80.45)
  BOTTOM w0.102: UG9.A5 v2(221.47,80.45) ; v2(215.79,63.31) UG5.P2
FBC_DBI1: length 22.6
  IN1 w0.13: v2(223.5,81.9) 223.54,81.86 223.54,80.2 223.72,80.02 223.72,77.87 222.46,76.61 222.46,64.81 222.76,64.51 224.78,64.51 224.99,64.3 224.99,63.71 v2(225.39,63.31)
  BOTTOM w0.102: UG9.C8 223.62,81.9 v2(223.5,81.9) ; UG5.P13 v2(225.39,63.31)
FBC_DBI2: length 40
  IN2 w0.117: v2(231.17,86.65) 230.7,86.18 230.7,78.32 229.54,77.15 229.54,69.15 230.25,68.43 230.25,56.35 227.2,53.3 225.2,53.3 224.99,53.51 224.99,54.11 v2(224.59,54.51)
  BOTTOM w0.102: UG5.D13 224.8,54.72 224.8,54.72 v2(224.59,54.51) ; UG9.J18 v2(231.17,86.65)
FBC_DBI3: length 40.3
  IN2 w0.117: v2(216.59,55.31) 217,54.9 217.22,54.9 217.23,54.9 217.55,54.9 217.55,54.9 219.76,54.9 222.16,57.3 225.23,57.3 226.75,58.82 227.07,58.82 228.21,59.97 228.21,66.66 226.92,67.95 226.92,81.16 226.58,81.5 226.58,84.16 v2(226.97,84.55)
  BOTTOM w0.102: UG9.F12 v2(226.97,84.55) ; v2(216.59,55.31) UG5.D2
FBC_DBI4: length 25.4
  IN2 w0.117: v2(241.42,74.36) 242.67,73.11 242.67,70.51 246.49,66.69 246.49,64.14 246.06,63.71 244.79,63.71 v2(244.39,63.31)
  BOTTOM w0.102: UG6.D2 244.17,63.09 v2(244.39,63.31) ; v2(241.42,74.36) 240.69,74.36 239.79,75.26 239.79,75.49 239.01,76.27 239.01,76.88 238.96,76.93 238.96,80.56 238.92,80.6 238.92,82.5 UG9.D29
FBC_DBI5: length 24.3
  IN6 w0.102: 236.99,73.82 236.99,78.9 237.41,79.32 237.41,80.51 238.19,81.3 238.19,82.53 v2(237.47,83.25)
  IN6 w0.13: v2(234.79,63.31) 235.19,63.71 235.19,64.29 235.41,64.51 237.39,64.51 237.63,64.75 237.63,69.33 236.99,69.97 236.99,73.82
  BOTTOM w0.102: v2(237.47,83.25) UG9.E27 ; UG6.D13 v2(234.79,63.31)
FBC_DBI6: length 37.2
  IN2 w0.117: v2(235.56,54.54) 235.18,54.16 235.18,53.45 235.03,53.31 232.99,53.31 232.8,53.5 231.97,53.5 230.93,54.55 230.93,68.71 230.64,69 230.64,77.42 232.14,78.92 232.14,83.78 v2(231.97,83.95)
  BOTTOM w0.102: UG6.P13 235.19,54.91 v2(235.56,54.54) ; UG9.F20 v2(231.97,83.95)
FBC_DBI7: length 36.2
  IN2 w0.117: v2(244.39,55.31) 243.99,55.71 243.34,55.71 243.19,55.86 243.19,56.28 242.96,56.51 242.62,56.51 242.39,56.74 242.39,57.12 242.18,57.33 240.65,57.33 238.27,59.71 235.59,59.71 235.18,60.12 235.18,67.76 236.04,68.62 236.04,73.8 236.01,73.82 v2(236.01,82.41)
  BOTTOM w0.102: v2(244.39,55.31) 244.13,55.06 UG6.P2 ; v2(236.01,82.41) 236.12,82.52 236.12,82.97 236.47,83.32 UG9.E26
FBC_EDC0: length 24.9
  IN2 w0.117: v2(216.58,64.11) 216.19,64.51 214.84,64.51 214.83,64.52 214.83,64.52 214.6,64.75 214.6,68.25 220.35,74.01 220.35,78.84 221.07,79.55 221.13,79.55 221.93,80.35 221.93,82.69 v2(221.47,83.15)
  BOTTOM w0.102: UG9.D5 v2(221.47,83.15) ; v2(216.58,64.11) 216.58,64.11 UG5.R2
FBC_EDC1: length 32.8
  IN2 w0.117: v2(223.57,83.15) 223.54,83.12 223.54,83.12 223.28,82.85 222.62,82.85 222.36,82.59 222.36,79.61 221.33,78.58 221.33,73.82 217.66,70.15 217.66,65.98 216.99,65.31 216.99,63.09 217.18,62.9 217.22,62.9 217.23,62.9 217.55,62.9 217.55,62.9 217.61,62.9 217.75,62.76 220.88,62.76 222.63,64.51 224.19,64.51 v2(224.59,64.11)
  BOTTOM w0.102: v2(224.59,64.11) 224.99,63.71 UG5.R13 ; UG9.D8 v2(223.57,83.15)
FBC_EDC2: length 40.4
  IN2 w0.117: v2(225.39,53.71) 225.79,54.11 227.02,54.11 227.08,54.17 227.08,54.18 227.93,55.03 227.93,55.2 227.29,55.85 227.27,55.86 227.27,55.87 227.27,55.89 227.27,56.04 227.39,56.16 227.56,56.16 228.24,55.47 228.42,55.47 228.54,55.59 228.54,55.77 227.85,56.45 227.85,56.63 227.97,56.75 228.14,56.75 228.83,56.06 229,56.06 229.25,56.3 229.25,56.91 229.05,57.11 228.11,57.11 227.99,57.24 227.99,57.41 228.11,57.53 229.19,57.53 229.56,57.9 229.56,67.78 228.73,68.61 228.73,77.51 230.01,78.78 230.01,83.11 v2(229.87,83.25)
  BOTTOM w0.102: v2(229.87,83.25) UG9.E17 ; UG5.C13 v2(225.39,53.71)
FBC_EDC3: length 41.6
  IN2 w0.117: v2(215.79,54.51) 216.19,54.11 220.06,54.11 221.26,55.31 222.31,55.31 222.71,55.71 225.53,55.71 225.54,55.72 225.62,55.72 225.78,55.87 225.78,57.04 225.8,57.07 225.8,57.07 226.23,57.5 226.7,57.5 228.89,59.69 228.89,66.94 227.78,68.04 227.78,82.44 v2(226.97,83.25)
  BOTTOM w0.102: UG9.E12 v2(226.97,83.25) ; UG5.C2 216,54.29 v2(215.79,54.51)
FBC_EDC4: length 24.9
  IN2 w0.117: v2(239.57,83.25) 239.18,82.86 239.18,81.94 240.1,81.02 240.1,73.69 241.99,71.8 241.99,70.02 245.82,66.2 245.82,64.82 245.51,64.51 243.99,64.51 v2(243.59,64.11)
  BOTTOM w0.102: UG6.C2 v2(243.59,64.11) ; v2(239.57,83.25) UG9.E30
FBC_EDC5: length 21.1
  IN2 w0.117: v2(238.57,79.7) 237.91,79.04 237.91,64.14 237.48,63.71 235.99,63.71 v2(235.59,64.11)
  BOTTOM w0.102: v2(235.59,64.11) UG6.C13 ; UG9.B29 238.57,81.3 238.17,80.9 238.17,80.1 v2(238.57,79.7)
FBC_EDC6: length 35.3
  IN2 w0.117: v2(233.27,85.25) 232.82,84.8 232.82,78.64 231.6,77.42 231.6,55.54 233.04,54.11 234.39,54.11 v2(234.79,53.71)
  BOTTOM w0.102: UG6.R13 235.02,53.94 v2(234.79,53.71) ; UG9.G21 v2(233.27,85.25)
FBC_EDC7: length 36.8
  IN2 w0.117: v2(235.39,83.23) 235.03,82.86 235.03,69.03 234.32,68.33 234.32,59.09 234.5,58.91 237.48,58.91 238.09,58.3 238.35,58.3 240.98,55.67 241.78,55.67 242.54,54.91 243.19,54.91 v2(243.59,54.51)
  BOTTOM w0.102: v2(243.59,54.51) 243.81,54.29 UG6.R2 ; v2(235.39,83.23) UG9.E24
FBC_WCK01: length 26
  IN2 w0.089: v2(217.39,63.31) 217.4,63.31 217.81,63.72 218.39,63.72 218.89,64.23 218.89,67.48 224.09,72.68 224.09,84.56 223.94,84.72 223.74,84.72 v2(223.57,84.55)
  BOTTOM w0.102: UG9.F8 v2(223.57,84.55)
  BOTTOM w0.119: UG5.P4 217.39,63.3 v2(217.39,63.31)
FBC_WCK01#: length 26.1
  IN2 w0.089: v2(223.42,85.11) 223.63,84.91 224.01,84.91 224.28,84.64 224.28,72.6 219.08,67.41 219.08,64.1 218.48,63.49 218.37,63.49 v2(218.19,63.31)
  BOTTOM w0.102: UG9.G8 223.58,84.95 v2(223.42,85.11)
  BOTTOM w0.119: v2(218.19,63.31) 218.41,63.09 UG5.P5
FBC_WCK23: length 38
  IN2 w0.089: v2(226.97,85.95) 226.8,85.78 226.58,85.78 226.08,85.28 226.08,66.9 226.57,66.41 226.57,59.91 224.55,57.88 221.37,57.88 219.18,55.68 218.85,55.68 218.47,55.3 v2(218.17,55.3)
  BOTTOM w0.102: UG9.H12 v2(226.97,85.95)
  BOTTOM w0.119: v2(218.17,55.3) UG5.D4
FBC_WCK23#: length 37.9
  IN2 w0.089: v2(226.97,85.25) 227.06,85.34 227.06,85.47 226.94,85.59 226.64,85.59 226.26,85.21 226.26,66.97 226.75,66.48 226.75,59.83 224.62,57.7 221.45,57.7 219.24,55.49 219.09,55.49 219.01,55.41 v2(219.01,55.31)
  BOTTOM w0.102: UG9.G12 226.85,84.95 226.97,85.07 v2(226.97,85.25)
  BOTTOM w0.119: UG5.D5 218.52,54.97 218.52,55.1 218.56,55.14 218.56,55.18 218.78,55.39 218.93,55.39 v2(219.01,55.31)
FBC_WCK45: length 29.6
  IN2 w0.089: v2(242.79,62.51) 242.41,62.14 241.82,62.14 241.15,62.8 241.15,70.61 238.95,72.81 238.95,80.45 238.02,81.38 237.56,81.38 236.68,82.25 236.68,86.27 236.91,86.5 237.31,86.5 v2(237.47,86.65)
  BOTTOM w0.102: UG9.J27 v2(237.47,86.65)
  BOTTOM w0.119: UG6.D4 v2(242.79,62.51)
FBC_WCK45#: length 29.7
  IN2 w0.089: v2(241.99,62.51) 241.75,62.51 241.33,62.93 241.33,70.68 239.13,72.89 239.13,80.53 238.1,81.56 237.63,81.56 236.86,82.32 236.86,86.2 236.98,86.32 237.1,86.32 v2(237.47,85.95)
  BOTTOM w0.102: UG9.H27 236.94,85.65 236.84,85.75 236.84,85.91 236.94,86 237.41,86 v2(237.47,85.95)
  BOTTOM w0.119: UG6.D5 241.59,63.18 241.69,63.27 241.9,63.27 242.01,63.17 242.01,62.53 v2(241.99,62.51)
FBC_WCK67: length 39.1
  IN2 w0.089: v2(234.07,84.65) 234.34,84.38 234.34,84.36 234.5,84.2 234.5,83.01 233.94,82.46 233.94,76.36 233.18,75.59 233.18,58.78 234.55,57.4 234.6,57.4 234.61,57.4 238.05,57.4 238.54,56.91 238.54,55.92 240.35,54.12 241.59,54.12 v2(241.99,54.51)
  BOTTOM w0.102: UG9.G23 v2(234.07,84.65)
  BOTTOM w0.119: UG6.P4 v2(241.99,54.51)
FBC_WCK67#: length 39.1
  IN2 w0.089: v2(241.19,54.51) 241.02,54.34 240.98,54.3 240.48,54.3 238.77,56.02 238.77,57 238.19,57.59 234.62,57.59 233.37,58.84 233.37,75.53 234.12,76.28 234.12,82.38 234.69,82.95 234.69,84.28 234.53,84.44 234.53,84.89 v2(234.07,85.35)
  BOTTOM w0.102: v2(234.07,85.35) 234.12,85.3 234.36,85.3 234.42,85.36 234.42,85.6 UG9.H23
  BOTTOM w0.119: v2(241.19,54.51) 241.51,54.51 241.59,54.59 UG6.P5
FBCAL_GND: length 6.4
  TOP w0.1: v2(248.77,89.55) v1(249.21,89.99) 249.42,90.2 252.14,90.2 252.65,89.69 RG68.1
  BOTTOM w0.1: UG9.P44 v2(248.77,89.55)
FBCAL_TERM: length 5.5
  TOP w0.1: v2(249.47,90.85) 249.86,90.46 252.68,90.46 v1(252.78,90.35) 253.69,90.35 253.97,90.63 RG69.1
  BOTTOM w0.11: UG9.R45 v2(249.47,90.85)
FBCAL_VDDQ: length 1.7
  TOP w0.305: v2(248.77,90.85) 248.12,90.2 RG67.1
  BOTTOM w0.11: UG9.R44 v2(248.77,90.85)
FBD_CLK0: length 35.7
  IN1 w0.102: v2(224.17,93.75) 223.82,94.1 223.82,94.18 223.67,94.33 223.66,94.33 223.47,94.53 223.38,94.53
  IN1 w0.107: v2(199.43,90.85) 199.21,90.63 199.21,90.49 199.04,90.33 199.04,89.15 199.7,88.49 200.1,88.49 200.39,88.19 200.39,88.05 200.73,87.7 v2(201.23,87.7) 200.99,87.46 200.66,87.46 200.55,87.36 200.55,87.04 200.69,86.9 206.09,86.9 212.84,93.65 216.25,93.65 216.71,94.11 218.8,94.11 219.41,94.72 222.44,94.72 222.63,94.53 222.72,94.53 223.38,94.53
  BOTTOM w0.102: UG9.Y8 v2(224.17,93.75)
  BOTTOM w0.119: RG160.1 200.74,87.29 200.74,87.58 200.86,87.7 v2(201.23,87.7) ; UG7.J12 199.33,91.25 199.43,91.15 v2(199.43,90.85)
FBD_CLK0#: length 35.6
  IN1 w0.102: 223.38,94.33 223.62,94.1 223.62,93.83 v2(223.49,93.7)
  IN1 w0.107: v2(199.43,91.65) 199.01,91.24 199.01,90.83 199.01,90.57 198.85,90.41 198.85,89.07 199.62,88.29 200.02,88.29 200.2,88.11 200.2,87.97 v2(199.93,87.7) 200.36,87.28 200.36,86.96 200.61,86.71 206.17,86.71 212.92,93.45 216.33,93.45 216.79,93.91 218.72,93.91 218.88,93.91 219.49,94.53 222.36,94.53 222.55,94.33 222.8,94.33 223.38,94.33
  BOTTOM w0.102: v2(223.49,93.7) 223.49,93.73 UG9.Y7
  BOTTOM w0.119: RG531.1 200.52,87.33 200.52,87.5 200.32,87.7 v2(199.93,87.7) ; UG7.J11 199.19,91.89 v2(199.43,91.65)
FBD_CLK1: length 36
  IN6 w0.107: v2(224.29,90.97) 224.29,90.85 223.68,90.25 223.5,90.25 223.39,90.25 221.97,90.25 221.74,90.48 218.82,90.48 218.78,90.44 218.78,90.44 218.53,90.2 214.45,90.2 207.65,83.4 205.44,83.4 205.33,83.3 205.33,82.98 205.11,82.76 204.63,82.76 204.41,82.98 204.41,83.3 204.3,83.4 201.77,83.4 201.59,83.22 201.59,83.07 201.69,82.96 201.97,82.96 v2(202.13,82.8) 202.1,82.77 201.88,82.56 201.32,82.56 200.89,82.13 199.91,82.13 199.04,81.26 199.04,80.4 199.21,80.23 199.21,80.07 v2(199.43,79.85)
  BOTTOM w0.102: UG9.R8 224.07,90.55 224.29,90.78 v2(224.29,90.97)
  BOTTOM w0.119: UG8.J12 199.29,79.45 199.43,79.59 v2(199.43,79.85) ; v2(202.13,82.8) 201.68,82.8 201.56,82.92 201.56,83.25 RG164.1
FBD_CLK1#: length 36.1
  IN6 w0.107: v2(199.43,79.05) 199.43,79.31 199.01,79.73 199.01,80.15 198.85,80.32 198.85,81.35 199.83,82.33 200.81,82.33 200.96,82.48 200.96,82.67 v2(200.83,82.8) 201.29,82.8 201.39,82.91 201.39,83.3 201.69,83.6 204.38,83.6 204.6,83.38 204.6,83.06 204.71,82.96 205.03,82.96 205.14,83.06 205.14,83.38 205.36,83.6 207.57,83.6 214.37,90.4 218.45,90.4 218.69,90.64 218.7,90.64 218.74,90.68 221.82,90.68 222.05,90.44 223.39,90.44 223.6,90.44 223.83,90.67 223.83,90.82 223.71,90.94 223.56,90.94 v2(223.47,90.85)
  BOTTOM w0.102: UG9.R7 v2(223.47,90.85)
  BOTTOM w0.119: UG8.J11 199.43,79.05 v2(199.43,79.05) ; v2(200.83,82.8) 201.24,82.8 201.35,82.92 201.35,83.22 201.04,83.53 201.04,83.55 RG532.1
FBD_CMD0: length 30.5
  BOTTOM w0.102: UG9.AD2 219.52,96.85 219.18,97.19 218.81,97.19 218.69,97.07 212.76,97.07 211.69,98.14
  BOTTOM w0.185: UG7.G3 197.81,98.84 197.81,100.24 197.53,100.52 197.53,101.67 198.59,102.73 210.3,102.73 211.69,101.34 211.69,98.14
FBD_CMD1: length 28.3
  TOP w0.102: RG451.2 198.71,98.94 v2(198.63,98.85)
  BOTTOM w0.102: UG7.J3 198.86,98.62 v2(198.63,98.85) ; UG9.AD1 212.55,96.85 211.37,98.03 211.37,100.89
  BOTTOM w0.185: 211.37,100.89 210.08,102.19 199.78,102.19 198.58,100.98 198.58,100.67 198.63,100.62 v2(198.63,98.85)
FBD_CMD2: length 27.9
  TOP w0.102: RG453.1 199.51,99.74 v2(199.42,99.65)
  BOTTOM w0.102: 211.06,100.12 211.06,98.03 212.58,96.5 220.72,96.5 UG9.AD4 ; UG7.J2 v2(199.42,99.65)
  BOTTOM w0.185: 211.06,100.12 209.53,101.64 200.16,101.64 199.48,100.96 199.48,100.65 199.45,100.62 199.45,100.48 199.42,100.45 v2(199.42,99.65)
FBD_CMD3: length 24.1
  BOTTOM w0.102: UG9.AC1 212.62,96.15 210.82,97.95
  BOTTOM w0.185: 210.82,97.95 210.74,98.03 210.74,99.34 208.98,101.1 200.63,101.1 200.38,100.85 200.38,100.65 200.22,100.5 200.22,98.86 UG7.L3
FBD_CMD4: length 21.8
  BOTTOM w0.102: UG9.AC2 219.47,96.15 219.05,95.73 212.48,95.73 212.35,95.85 211.84,95.85
  BOTTOM w0.185: 211.84,95.85 209.69,98.01 207.58,98.01 206.04,96.47 204.51,96.47 204.51,96.47 204.24,96.47 200.21,96.47 UG7.K5
FBD_CMD5: length 23.7
  BOTTOM w0.102: UG9.AC3 220.14,96.15 219.79,95.8 219.47,95.8 219.21,95.54 212.25,95.54 212.18,95.6 211.2,95.6 210.82,95.98
  BOTTOM w0.185: 210.82,95.98 209.55,97.25 207.59,97.25 206.52,96.18 204.63,96.18 204.36,96.18 199.96,96.18 199.41,96.73 199.41,97.24 UG7.K4
FBD_CMD6: length 23
  BOTTOM w0.102: 210.82,95.33 212.15,95.33 212.18,95.3 219.32,95.3 219.52,95.1 220.02,95.1 UG9.AA3
  BOTTOM w0.185: UG7.J5 199.03,96.51 199.64,95.9 204.48,95.9 204.75,95.9 204.75,95.9 206.65,95.9 206.65,95.9 206.94,95.9 207.65,96.62 209.11,96.62 210.4,95.33 210.82,95.33
FBD_CMD7: length 23.5
  BOTTOM w0.102: UG9.AA2 219.52,94.75 219.18,95.09 212.28,95.09 211.75,94.56
  BOTTOM w0.185: UG7.J4 198.64,97.26 198.64,96.49 199.52,95.61 204.6,95.61 204.86,95.61 206.53,95.61 208.15,95.61 209.2,94.56 211.75,94.56
FBD_CMD8: length 22.6
  BOTTOM w0.102: 211.95,93.79 212.85,94.69 218.91,94.69 UG9.AA1
  BOTTOM w0.185: UG7.H5 198.23,96.49 199.4,95.32 204.71,95.32 204.72,95.32 204.98,95.32 204.98,95.32 206.41,95.32 206.41,95.32 207.67,95.32 209.2,93.79 211.95,93.79
FBD_CMD9: length 26.7
  BOTTOM w0.102: 211.92,93.02 213.3,94.4 220.72,94.4 UG9.AA4
  BOTTOM w0.185: 211.92,93.02 209.04,93.02 207.02,95.04 206.29,95.04 205.1,95.04 204.83,95.04 199.28,95.04 197.81,96.5 197.81,97.24 UG7.H4
FBD_CMD10: length 25.9
  BOTTOM w0.102: 211.68,92.25 213.48,94.05 UG9.Y1
  BOTTOM w0.185: UG7.G12 197.83,91.65 197.83,93.63 198.94,94.75 204.95,94.75 205.22,94.75 205.22,94.75 206.17,94.75 206.17,94.75 206.54,94.75 209.03,92.25 211.68,92.25
FBD_CMD11: length 24.9
  BOTTOM w0.102: 210.82,91.48 211.36,91.48 213.58,93.7 219.12,93.7 219.47,94.05 UG9.Y2
  BOTTOM w0.185: 210.82,91.48 209.04,91.48 206.06,94.46 205.34,94.46 205.34,94.46 205.07,94.46 199.06,94.46 198.23,93.63 UG7.H10
FBD_CMD12: length 27
  BOTTOM w0.102: UG9.Y3 220.02,93.7 219.47,93.7 219.2,93.43 213.68,93.43 210.97,90.71 210.82,90.71
  BOTTOM w0.185: UG7.H11 198.63,92.45 198.63,93.62 199.18,94.17 205.19,94.17 205.46,94.17 205.46,94.18 205.94,94.18 207.75,92.36 207.75,91.61 208.65,90.71 210.82,90.71
FBD_CMD13: length 26.7
  BOTTOM w0.102: 210.82,89.94 213.89,93.01 213.89,93.02 214.06,93.19 219.33,93.19 219.52,93 220.02,93 UG9.V3
  BOTTOM w0.185: 210.82,89.94 208.01,89.94 207.47,90.48 207.47,92.24 205.82,93.89 205.58,93.89 205.31,93.89 200.23,93.89 199.46,93.12 199.46,92.42 UG7.K11
FBD_CMD14: length 25.3
  BOTTOM w0.102: 210.82,89.17 211.22,89.56 211.22,89.91 214.31,93 219.17,93 219.52,92.65 UG9.V2
  BOTTOM w0.185: 210.82,89.17 208.01,89.17 207.18,89.99 207.18,92.12 205.7,93.6 205.43,93.6 200.35,93.6 199.83,93.08 UG7.K10
FBD_CMD15: length 26.7
  BOTTOM w0.102: 210.82,88.4 211.53,89.1 211.53,89.58 214.6,92.65 UG9.V1
  BOTTOM w0.185: 210.82,88.4 207.3,88.4 206.89,88.81 206.89,92 205.58,93.31 200.57,93.31 200.22,92.97 200.22,91.66 UG7.L12
FBD_CMD16: length 40.6
  BOTTOM w0.102: UG9.L3 220.02,87.4 219.47,87.4 219.22,87.15 216.38,87.15 215.27,86.05 215.27,74.84
  BOTTOM w0.185: 215.27,74.84 208.65,68.21 199.37,68.21 197.73,69.85 197.73,70.35 197.81,70.44 197.81,71.87 UG8.L3
FBD_CMD17: length 38.9
  TOP w0.102: RG452.2 198.62,71.86 v2(198.63,71.85)
  BOTTOM w0.102: UG8.J3 199.02,72.25 198.89,72.12 198.89,72.12 v2(198.63,71.85) ; UG9.L2 219.47,87.75 219.13,87.41 216.23,87.41 215.03,86.21 215.03,75.73
  BOTTOM w0.185: v2(198.63,71.85) 198.63,69.85 198.63,69.85 198.63,69.82 199.7,68.75 208.04,68.75 215.03,75.73
FBD_CMD18: length 35.8
  TOP w0.102: RG450.1 199.57,70.91 v2(199.43,71.05)
  BOTTOM w0.102: 214.78,77.14 214.78,86.41 216.12,87.75 UG9.L1 ; 199.46,71.02 v2(199.43,71.05) 199.43,71.05 UG8.J2 ; 212.54,74.13 212.54,74.13
  BOTTOM w0.185: 212.54,74.13 212.54,74.89 214.78,77.14 ; 199.46,71.02 199.46,70.81 199.46,70.8 199.46,70.5 199.46,70.5 199.46,70.39 199.53,70.33 199.53,69.75 199.99,69.29 207.7,69.29 212.54,74.13
