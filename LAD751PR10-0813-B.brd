# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_GC6_FB_EN_R: length 8.3
  TOP w0.089: RG563.2 212.31,24.24 v2(212.47,24.09) 212.28,23.9 212.26,23.9 211.86,23.5 v1(211.63,23.5)
  IN1 w0.089: v2(215.36,22.91) 214.68,23.59 212.96,23.59 v2(212.47,24.09)
  BOTTOM w0.089: UH1.BD32 215.49,23.83 214.87,23.83 214.7,23.67 214.7,23.43 214.83,23.3 215.21,23.3 215.36,23.15 v2(215.36,22.91)
GPU_INV_PWM: length 47.6
  TOP w0.089: v2(224.3,110.75) v1(223.66,110.75)
  TOP w0.102: v2(188.31,99.28) 188.85,99.81 UG24.5 188.85,102.43 RG150.1
  IN6 w0.102: v2(188.31,99.28) 188.89,99.28 191.21,101.59 207.44,101.59 209.93,104.08 214.56,104.08 218.51,108.04 218.51,110.2 219.4,111.09 223.08,111.09 223.43,110.75 v2(224.3,110.75)
  BOTTOM w0.089: v2(224.3,110.75) 223.27,110.75 UG9.BD7
GPU_LPC: length 17
  IN1 w0.254: v2(281.82,134.26) 281.35,133.79 279.37,133.79 278.99,134.17 278.99,134.99 277.96,136.02 277.96,139.45 275.17,142.24 v2(275.17,142.51)
  BOTTOM w0.102: v2(281.82,134.26) 281.75,134.26 v1(281.34,134.68)
  BOTTOM w0.203: v2(275.17,142.51) 275.21,142.48 PU6000.35
  BOTTOM w0.254: v2(281.82,134.26) PR6062.2 282.43,133.38 PR6052.1
GPU_MDP_N0: length 85.2
  IN6 w0.089: v2(229.58,164.59) 229.62,164.59 229.8,164.78 229.8,164.95 229.72,165.04 225.91,165.04 225.02,164.15 225.02,163.39 223.97,162.33 223.97,160.37 223.65,160.05 223.65,158.32 222.43,157.09 218,157.09 216.92,156.01 216.19,156.01 214.49,154.31 212.54,154.31 209.86,151.63 209.86,149.62 207.03,146.8 207.03,142.89 208.36,141.57 208.36,135.64 209.72,134.28 214.96,134.28 222.9,126.34 224.41,126.34 230.63,120.12 230.63,114.18 230.63,113.96 230.39,113.72 230.13,113.72 229.87,113.46 v2(229.87,113.25)
  BOTTOM w0.089: v2(229.58,164.59) 229.76,164.78 229.76,166.25 CV27.1
  BOTTOM w0.101: UG9.BG17 230.17,113.15 230.07,113.25 v2(229.87,113.25)
GPU_MDP_N1: length 104.3
  TOP w0.089: v2(242.03,165.92) 241.83,165.71 241.61,165.71 241.5,165.83 241.5,166.34 241.91,166.75 241.91,167.42 241.99,167.51 CV30.1
  IN6 w0.089: v2(242.03,165.92) 241.82,165.7 241.44,165.7 241.17,165.44 241.17,163.25 240.78,162.85 238.71,162.85 238.32,163.24 233.95,163.24 232.61,164.58 232.61,165.46 232.11,165.95 224.99,165.95 223.91,164.88 223.91,163.53 223.06,162.69 223.06,160.72 222.78,160.44 222.78,158.71 222.16,158.09 217.57,158.09 216.35,156.87 213.88,156.87 208.99,151.99 208.99,149.98 206.17,147.16 206.17,141.88 206.76,141.29 206.76,136.02 209.36,133.41 214.6,133.41 222.54,125.48 223.79,125.48 228.84,120.43 228.87,120.43 228.87,120.42 228.87,120.42 228.87,120.41 228.88,120.41 229.83,119.47 229.83,116.37 228.71,115.25 228.71,112.91 v2(229.07,112.55)
  BOTTOM w0.101: UG9.BF15 v2(229.07,112.55)
GPU_MDP_N2: length 102.7
  IN6 w0.089: v2(227.77,111.95) 227.77,111.75 227.93,111.59 228.06,111.59 228.17,111.7 228.17,116.55 226.57,118.15 226.45,118.27 226.45,119.78 226.46,119.79 226.46,119.87 226.47,119.87 226.47,120.53 226.45,120.56 226.45,121.38 223.28,124.55 222.52,124.55 214.35,132.72 214.33,132.72 214.3,132.74 208.95,132.74 206.07,135.63 206.07,140.9 205.41,141.56 205.41,147.34 208.23,150.17 208.23,152.85 212.62,157.24 212.62,157.67 213.07,158.12 214.75,158.12 215.02,158.39 216.07,158.39 216.68,158.99 220.31,158.99 220.95,159.63 221.33,159.63 222.12,160.42 222.12,160.71 222.4,160.99 222.4,162.98 223.19,163.77 223.19,165.2 224.61,166.62 227.75,166.62 229.05,167.93 230.58,167.93 231.88,166.62 232.86,166.62 233.95,165.53 233.95,164.49 234.54,163.91 237.54,163.91 239.41,165.78 v2(240.67,165.78)
  BOTTOM w0.089: CV33.1 241.05,166.68 241.25,166.48 241.25,165.78 241.04,165.57 240.88,165.57 v2(240.67,165.78)
  BOTTOM w0.101: UG9.BF14 v2(227.77,111.95)
GPU_MDP_N3: length 97.4
  IN6 w0.089: v2(227.77,113.25) 226.9,113.25 226.4,113.75 226.4,115.97 224.94,117.43 224.94,118.9 225.76,119.73 225.76,120.53 225.74,120.56 225.74,121.13 224.31,122.56 223.56,122.56 214.08,132.05 208.03,132.05 205.4,134.68 205.4,140.53 204.67,141.26 204.67,147.55 207.5,150.37 207.5,153.27 210.84,156.61 210.84,158.34 211.41,158.91 212.49,158.91 213.95,160.37 218.65,160.37 220.88,162.6 220.88,163.84 224.33,167.29 227.44,167.29 228.97,168.82 231.68,168.82 233.77,166.73 234.37,166.73 235.29,165.81 v2(235.29,164.92)
  BOTTOM w0.089: CV31.1 235.07,167.2 235.07,165.13 v2(235.29,164.92)
  BOTTOM w0.101: UG9.BG14 v2(227.77,113.25)
GPU_MDP_P0: length 85.2
  IN6 w0.089: v2(230.16,164.59) 230,164.75 230,165.03 229.8,165.23 225.83,165.23 224.82,164.23 224.82,163.47 223.77,162.41 223.77,160.45 223.45,160.14 223.45,158.4 222.34,157.29 217.92,157.29 216.84,156.21 216.11,156.21 214.41,154.51 212.46,154.51 209.66,151.71 209.66,149.7 206.84,146.88 206.84,142.81 208.16,141.48 208.16,135.56 209.64,134.08 214.88,134.08 222.82,126.14 224.33,126.14 230.06,120.41 230.09,120.41 230.45,120.05 230.45,114.11 230.45,114.04 230.31,113.9 v2(229.79,113.9)
  BOTTOM w0.089: v2(230.16,164.59) 229.94,164.81 229.94,166.34 CV26.1
  BOTTOM w0.101: v2(229.79,113.9) 230.04,113.65 UG9.BH17
GPU_MDP_P1: length 104.3
  TOP w0.089: v2(242.03,165.33) 241.83,165.53 241.54,165.53 241.32,165.75 241.32,166.41 241.73,166.82 241.73,167.26 CV28.1
  IN6 w0.089: v2(242.03,165.33) 241.86,165.5 241.52,165.5 241.37,165.36 241.37,163.16 240.86,162.66 238.63,162.66 238.24,163.04 233.87,163.04 232.41,164.49 232.41,165.37 232.03,165.76 225.07,165.76 224.11,164.8 224.11,163.45 223.26,162.6 223.26,160.64 222.98,160.35 222.98,158.63 222.25,157.89 217.65,157.89 216.43,156.68 213.96,156.68 209.19,151.9 209.19,149.9 206.37,147.07 206.37,141.96 206.96,141.37 206.96,136.1 209.44,133.61 214.69,133.61 222.62,125.67 223.87,125.67 230.01,119.54 230.01,116.3 228.89,115.18 228.89,113.81 229.05,113.65 229.24,113.65 229.47,113.42 229.47,113.08 229.32,112.94 229.16,112.94 229.07,113.02 v2(229.07,113.25)
  BOTTOM w0.101: UG9.BG15 v2(229.07,113.25)
GPU_MDP_P2: length 102.6
  IN6 w0.089: v2(227.77,111.25) 227.93,111.41 228.13,111.41 228.35,111.63 228.35,116.62 226.63,118.34 226.63,119.71 226.64,119.72 226.64,119.79 226.65,119.8 226.65,121.46 223.36,124.75 222.6,124.75 214.44,132.91 214.41,132.91 214.38,132.94 209.03,132.94 206.27,135.71 206.27,140.98 205.6,141.64 205.6,147.26 208.43,150.08 208.43,152.76 212.82,157.16 212.82,157.59 213.15,157.92 214.83,157.92 215.1,158.19 216.16,158.19 216.76,158.79 220.39,158.79 221.03,159.44 221.41,159.44 222.31,160.34 222.31,160.63 222.59,160.91 222.59,162.9 223.38,163.69 223.38,165.12 224.69,166.42 227.83,166.42 229.14,167.73 230.5,167.73 231.8,166.42 232.78,166.42 233.75,165.45 233.75,164.41 234.46,163.71 237.62,163.71 239.49,165.58 240.29,165.58 v2(240.67,165.19)
  BOTTOM w0.089: v2(240.67,165.19) 240.88,165.4 241.12,165.4 241.42,165.7 241.42,166.46 CV32.1
  BOTTOM w0.101: UG9.BE14 v2(227.77,111.25)
GPU_MDP_P3: length 97.3
  IN6 w0.089: v2(234.7,164.92) 235.09,165.3 235.09,165.72 234.28,166.53 233.69,166.53 231.59,168.62 229.05,168.62 227.52,167.09 224.41,167.09 221.08,163.76 221.08,162.52 218.73,160.17 214.04,160.17 212.57,158.71 211.5,158.71 211.04,158.25 211.04,156.53 207.69,153.18 207.69,150.29 204.87,147.47 204.87,141.34 205.6,140.61 205.6,134.77 208.12,132.25 214.16,132.25 223.64,122.76 224.4,122.76 225.94,121.22 225.94,119.66 225.12,118.83 225.12,117.5 226.58,116.04 226.58,113.82 226.97,113.43 227.19,113.43 227.28,113.52 227.28,114.04 227.36,114.13 227.59,114.13 227.68,114.04 v2(227.68,113.79)
  BOTTOM w0.089: CV29.1 234.9,167.38 234.9,165.11 v2(234.7,164.92)
  BOTTOM w0.101: v2(227.68,113.79) 227.82,113.65 UG9.BH14
GPU_OVERT#: length 544.3
  TOP w0.102: QG502.3 213.35,155.82 214.07,155.1 v2(214.07,154.91) ; v2(309.1,53.93) 309.1,55.2 309.82,55.92 309.82,56.37 310.13,56.68 310.13,57.61 309.74,58.01 RG534.2 309.74,58.8 UG23.6 ; UE6.21 v2(328.4,42.95) ; DG3.1 v2(281.58,171.69) ; v2(202.66,118.64) 203.39,118.64 v1(203.4,118.65)
  TOP w0.107: RE102.1 289.06,12.41 v2(289.19,12.54)
  IN1 w0.102: v2(214.07,154.91) 214.07,154.37 212.56,152.87 212.56,151.39 213.62,150.34 224.7,150.34 224.98,150.62 227.34,150.62 227.62,150.34 239.18,150.34 239.55,150.7 241.77,150.7 241.91,150.57 251.69,150.57 252.4,151.27 252.4,153.62 253.57,154.79 264.17,154.79 265.13,153.83 270.39,153.83 271.12,153.11 273.72,153.11 274.49,153.87 279.9,153.87 v2(282.75,156.71) 283.73,157.69 283.73,167.14 281.58,169.28 v2(281.58,171.69)
  IN2 w0.102: v2(328.4,42.95) 327.64,43.71 327.64,47.97 325.98,49.64 319.73,49.64 319.02,50.35 312.89,50.35 309.3,53.93 v2(309.1,53.93) 308.18,54.85 308.18,56.77 306.11,58.85 301.05,58.85 300.27,59.62 300.27,62.81 299.47,63.61 299.47,69.18 294.97,73.68 294.97,77.95 294.97,77.95 295.35,80.51 289.55,92.44 288.2,96.69 287.29,100.29 286.52,104.8 286.29,107.7 286.29,143.42 282.75,146.96 v2(282.75,156.71)
  IN3 w0.102: v2(328.4,42.95) 328.5,42.95 329.23,42.22 329.23,40.58 328.3,39.64 328.3,37.11 327.22,36.04 327.22,33.37 322.02,28.17 322.02,25.18 321.13,24.29 321.13,19.81 320.58,19.26 320.58,18.47 315.97,13.85 315.97,9.04 314.91,7.99 307.78,7.99 304.97,5.18 298.95,5.18 298.22,5.91 293.58,5.91 291.22,8.27 291.22,11.97 290.65,12.54 v2(289.19,12.54)
  IN4 w0.102: v2(202.66,118.64) 202.66,115.23 199.82,112.4 199.82,109.76 199.82,109.76 199.82,106.92 200.17,106.56 200.17,104.57 197.12,101.51 192.06,101.51 191.3,100.75 191.3,95.11 191.78,94.63 191.78,69.5 192.08,69.2 199.1,69.2 206.02,62.28 206.02,58.14 206.54,57.63 206.54,53.31 209.27,50.58 209.27,48.83 211.56,46.53 212.75,46.53 215.29,43.99 216.89,43.99 217.41,44.51 223.25,44.51 225.75,42.01 228.77,42.01 228.91,42.15 232.92,42.15 234.35,43.58 238.66,43.58 239.81,42.42 247.2,42.42 248.55,43.77 259.63,43.77 260.21,43.2 266.55,43.2 273.58,36.17 276.93,36.17 278.49,37.73 279.32,37.73 280.91,39.31 290.4,39.31 292.4,37.31 296.77,37.31 300.1,40.65 310.57,40.65 311.15,41.22 318.57,41.22 319.15,40.65 326.09,40.65 v2(328.4,42.95)
  BOTTOM w0.102: v2(202.66,118.64) 202.66,118.26 202.76,118.16 QG501.6
GPU_PEX_RST_HOLD#: length 24.8
  IN1 w0.081: v2(220.06,112.58) 220.06,112.86 219.95,112.97 218.31,112.97 216.73,114.56 212.13,114.56 211.36,113.79 209.59,113.79 208.97,114.41 203.78,114.41 201.7,116.5 v2(201.7,117.35)
  BOTTOM w0.109: v2(220.06,112.58) 220.37,112.89 UG9.BG3
  BOTTOM w0.114: RG14.1 200.39,117.89 DG1.3 201.58,117.47 v2(201.7,117.35)
GPU_PH1: length 28.6
  IN1 w0.508: v2(258.07,145.19) 258.52,144.75 260.8,144.75 261.66,145.61 263.88,145.61 266.58,142.91 266.58,131.05 267.09,130.54 271.14,130.54 271.65,131.05 v2(271.65,131.54)
  BOTTOM w0.508: PR6026.1 v2(271.65,131.54)
  vias: v1(258.48,144.89) v2(257.44,145.19)
GPU_PH2: length 43.2
  IN1 w0.508: v2(244.36,145.07) 244.36,146.55 244.86,147.06 251.97,147.06 252.92,146.11 256.02,146.11 256.97,147.06 264.26,147.06 267.29,144.04 268.04,144.04 268.55,143.53 268.55,139.08 269.38,138.25 269.38,134 270.84,132.55 272.09,132.55 272.6,132.04 v2(272.6,131.54)
  BOTTOM w0.508: PR6027.1 v2(272.6,131.54)
  vias: v1(244.78,144.76) v2(243.72,145.07)
GPU_PH3: length 60.2
  TOP w0.102: 229.83,144.62 229.49,144.62 v1(229.28,144.82)
  IN1 w0.508: v2(230.51,145) 230.51,146.65 231.56,147.69 237.24,147.69 238.93,146.01 242.91,146.01 244.6,147.69 252.24,147.69 253.19,146.74 255.7,146.74 256.65,147.69 264.52,147.69 267.55,144.67 268.35,144.67 269.19,143.83 269.19,139.34 270.02,138.51 270.02,134.26 270.96,133.32 272.5,133.32 273.57,132.25 v2(273.57,132.11)
  BOTTOM w0.508: PR6028.1 v2(273.57,132.11)
  vias: v2(229.88,145)
GPU_PH4: length 82.6
  IN1 w0.508: v2(274.46,132.11) 274.46,132.26 272.76,133.95 271.23,133.95 270.65,134.53 270.65,138.77 269.82,139.61 269.82,144.1 268.61,145.31 267.81,145.31 264.38,148.74 264.38,149.53 263.2,150.72 253.72,150.72 252.8,149.8 252.8,149.47 251.66,148.33 244.34,148.33 242.65,146.64 239.2,146.64 237.51,148.33 231.29,148.33 229.32,146.36 225.69,146.36 224.35,147.7 217.78,147.7 216.8,146.72 v2(216.8,145)
  BOTTOM w0.508: PR6030.1 v2(274.46,132.11) ; 213.06,142.63 211.07,140.63 PR6213.1
GPU_PROG1: length 14
  IN1 w0.254: v2(271.5,137.29) 271.55,137.29 272.37,136.47 272.37,135.6 274.33,133.64 276,133.64 277.99,131.64 279.2,131.64 v2(279.66,132.11)
  BOTTOM w0.203: v2(271.5,137.29) 271.63,137.29 272.01,137.67 PU6000.24
  BOTTOM w0.254: PR6056.2 v2(279.66,132.11) 279.66,132.11 PR6046.1
GPU_PROG2: length 16.5
  IN1 w0.254: v2(271.5,136.65) 271.64,136.65 271.99,136.31 271.99,135.45 274.18,133.26 275.84,133.26 277.83,131.26 280.02,131.26 v2(280.87,132.11)
  BOTTOM w0.102: v1(282.05,131.5) PR6050.1
  BOTTOM w0.203: PU6000.23 272.19,137.27 271.57,136.65 v2(271.5,136.65)
  BOTTOM w0.254: PR6050.1 v2(280.87,132.11) PR6057.2
GPU_PROG3: length 20
  IN1 w0.254: v2(283.94,138.59) 283.94,141.07 281.42,143.59 274.39,143.59 273.54,142.74 v2(273.54,142.42)
  BOTTOM w0.102: v2(283.94,138.59) v1(284.68,138.59)
  BOTTOM w0.203: v2(273.54,142.42) 273.54,142.32 274.41,141.46 PU6000.33
  BOTTOM w0.254: PR6047.1 282.43,137.07 PR6058.2 283.07,138.59 v2(283.94,138.59)
GPU_PROG4: length 19.3
  IN1 w0.254: v2(281.82,136.1) 281.82,135.38 281.57,135.12 280.98,135.12 280.86,135.25 279.27,135.25 278.38,136.14 278.38,142.51 277.77,143.12 275.1,143.12 274.58,142.6 274.58,142.55 v2(274.56,142.53)
  BOTTOM w0.102: v1(274.34,142.98) 274.58,142.74 274.58,142.55 v2(274.56,142.53)
  BOTTOM w0.203: PU6000.34 274.81,141.95 274.56,142.2 v2(274.56,142.53)
  BOTTOM w0.254: PR6051.1 282.43,135.22 PR6059.2 v2(281.82,136.1)
GPU_PROG5: length 13.2
  IN1 w0.254: v2(271.5,138.56) 271.55,138.56 272.77,137.34 272.77,135.74 274.49,134.02 276.15,134.02 278.04,132.13 v2(278.44,132.13)
  BOTTOM w0.203: v2(271.5,138.56) 271.59,138.47 PU6000.26
  BOTTOM w0.254: PR6060.2 v2(278.44,132.13) PR6048.1
GPU_PROG6: length 1.7
  BOTTOM w0.203: PR6031.1 278.79,139.15 278.66,139.27 PU6000.3
GPU_PSI: length 6.4
  TOP w0.102: v1(277.83,141.09) 277.49,141.44 PR6041.2
  TOP w0.254: PR6037.1 276.87,142.87 v2(276.87,142.54) 276.87,141.95 276.65,141.73 PR6041.2
  BOTTOM w0.203: PU6000.37 276.01,141.65 276.87,142.51 v2(276.87,142.54) 276.87,142.89 PR6039.1
GPU_PWM1: length 45.9
  TOP w0.254: v2(253.06,152.24) 252.6,151.78 PR6105.2
  IN2 w0.254: v2(253.06,152.24) 253.06,152.19 253.86,151.39 256.43,151.39 256.71,151.11 263.25,151.11 269.27,145.09 273.95,145.09 274.71,144.33 281.7,144.33 282.86,143.17 282.86,136.46 282,135.6 v2(281.19,135.6)
  BOTTOM w0.254: PR6043.1 v2(281.19,135.6)
  BOTTOM w0.305: v2(253.06,152.24) 253.06,151.99 253.21,151.83 PU6100.1
  BOTTOM w0.508: v2(253.06,152.24) 252.61,152.69 PR6102.1
GPU_PWM2: length 58.2
  TOP w0.102: v1(239.16,152.69) 239.16,152.68 239.15,152.67 v2(239.15,152.18)
  TOP w0.254: v2(239.15,152.18) 238.79,151.82 PR6112.2
  IN2 w0.254: v2(239.15,152.18) 239.15,152.13 239.88,151.4 240.5,151.4 240.95,150.95 255.95,150.95 256.37,150.53 263.3,150.53 269.12,144.71 273.79,144.71 274.56,143.95 281.54,143.95 282.48,143.01 282.48,137.79 v2(281.19,136.49)
  BOTTOM w0.254: PR6049.1 v2(281.19,136.49)
  BOTTOM w0.305: v2(239.15,152.18) 239.15,152.05 239.43,151.77 PU6101.1
  BOTTOM w0.508: PR6109.1 238.71,152.62 v2(239.15,152.18)
GPU_PWM3: length 70.2
  TOP w0.102: v1(224.98,152.61) 225.43,152.15 v2(225.43,152.11)
  TOP w0.254: v2(225.43,152.11) 225.09,151.77 PR6203.2
  IN2 w0.254: v2(281.19,137.38) 282.1,138.3 282.1,142.85 281.38,143.57 274.4,143.57 273.64,144.33 267.24,144.33 263.54,148.03 259,148.03 257.1,149.92 255.15,149.92 254.5,150.57 240.8,150.57 240.34,151.02 226.48,151.02 225.43,152.07 v2(225.43,152.11)
  BOTTOM w0.254: PR6054.1 v2(281.19,137.38)
  BOTTOM w0.305: v2(225.43,152.11) 225.43,151.99 225.72,151.71 PU6200.1
  BOTTOM w0.508: v2(225.43,152.11) 225.43,152.8 PR6200.1
GPU_PWM4: length 83.2
  TOP w0.102: PR6210.2 v1(212.82,151.3)
  TOP w0.254: PR6210.2 211.59,151.75 211.84,152.01 v2(211.86,152.01)
  IN2 w0.254: v2(211.86,152.01) 212.24,151.62 215.39,151.62 216.36,150.64 240.18,150.64 240.64,150.18 253.12,150.18 253.76,149.54 256.95,149.54 258.84,147.64 263.38,147.64 267.08,143.95 273.48,143.95 274.24,143.19 281.22,143.19 281.72,142.69 281.72,138.8 v2(281.19,138.27)
  BOTTOM w0.254: PR6055.1 v2(281.19,138.27)
  BOTTOM w0.305: PU6201.1 212.06,151.58 212.06,151.59 212.06,151.81 v2(211.86,152.01) 211.81,152.05 211.29,152.05 PR6207.1
GPU_PWR_EN: length 24.7
  TOP w0.102: RG551.2 277.9,144.81 UG25.2 277.9,146.72 278.08,146.89 278.85,146.89 279.29,146.45 RG552.2 v1(280.54,146.45) 281.61,146.45 281.97,146.82 281.97,150.51 281.4,151.09 277.36,151.09 277.07,151.38 UG26.1 277.07,152.87 277.58,153.38 278.52,153.38 280.29,155.15 UG28.1
GPU_SNB1: length 1.4
  TOP w0.102: PR6108.2 v1(256.5,142.4)
GPU_SNB2: length 1.4
  TOP w0.102: PR6115.2 v1(242.73,142.27)
GPU_SNB3: length 1.4
  TOP w0.102: PR6206.2 v1(228.96,142.21)
GPU_SNB4: length 1.4
  BOTTOM w0.102: PC6227.1 206.33,142.15 v1(205.95,142.53)
GPU_TX0N: length 39.1
  IN1 w0.089: v2(227.59,119.48) 227.53,119.53 227.53,120.45 224.75,123.23 216.85,123.23 216.48,123.61 212.68,123.61 212.17,124.12 209.84,124.12 209.06,124.89 204.42,124.89 204.21,125.1 202.98,125.1 202.78,125.3 201.9,125.3 v2(201.86,125.34)
  BOTTOM w0.089: CV417.2 202,127.08 202.22,126.86 202.41,126.68 202.41,125.15 202.25,124.99 202.19,124.99 201.86,125.32 v2(201.86,125.34) ; UG9.BM17 230.23,116.39 230.45,116.39 230.56,116.5 230.56,116.58 230.69,116.71 230.69,117.08 230.2,117.57 230.2,118.84 v3(229.6,119.44) 228.76,120.28 227.38,120.28 227.29,120.19 227.29,119.74 227.55,119.48 v2(227.59,119.48)
GPU_TX0N_C: length 2
  BOTTOM w0.089: CV417.1 202.22,127.92 202.22,128.15 202.03,128.34 202.03,128.73 201.92,128.84 UV21.2
GPU_TX0P: length 39
  IN1 w0.089: v2(201.86,124.75) 201.86,124.77 202.19,125.1 202.7,125.1 202.9,124.9 204.13,124.9 204.34,124.69 208.98,124.69 209.75,123.92 212.09,123.92 212.6,123.41 216.39,123.41 216.77,123.03 224.66,123.03 227.35,120.34 227.35,119.75 227.07,119.48 v2(227.04,119.48)
  BOTTOM w0.089: CV416.2 202.59,127.11 202.59,125.07 202.32,124.81 201.92,124.81 v2(201.86,124.75) ; v2(227.04,119.48) 227.11,119.55 227.11,120.26 227.3,120.45 228.83,120.45 229.45,119.84 229.51,119.84 229.99,119.35 229.99,119.3 230.37,118.92 230.37,117.65 230.87,117.15 UG9.BM18
GPU_TX0P_C: length 2
  BOTTOM w0.089: CV416.1 202.4,127.88 202.4,128.23 202.2,128.42 202.2,128.73 202.32,128.84 UV21.1
GPU_TX1N: length 38.6
  IN1 w0.089: v2(228.21,119.48) 228.21,119.38 228.3,119.29 228.42,119.29 228.61,119.48 228.61,120.32 228.51,120.41 228.48,120.41 225.2,123.7 217.05,123.7 216.65,124.1 212.85,124.1 212.29,124.66 211.43,124.66 210.57,125.52 207.68,125.52 207.44,125.76 204.54,125.76 204.35,125.57 203.32,125.57 202.57,126.32 202.21,126.32 202.1,126.21 202.1,126.02 202.01,125.93 v2(201.84,125.93)
  BOTTOM w0.089: v2(201.84,125.93) 201.7,126.08 201.11,126.08 200.86,126.33 CV419.2 ; UG9.BK17 230.17,115.23 229.8,115.6 229.8,116.08 229.66,116.22 229.66,118.21 229.1,118.77 228.68,118.77 228.21,119.25 v2(228.21,119.48)
GPU_TX1N_C: length 2
  BOTTOM w0.089: UV21.5 200.72,128.94 200.83,128.82 200.83,128.33 201.08,128.09 201.08,127.92 CV419.1
GPU_TX1P: length 38
  IN1 w0.089: v2(228.97,119.53) 228.79,119.72 228.79,120.39 225.28,123.9 217.13,123.9 216.73,124.3 212.94,124.3 212.38,124.86 211.52,124.86 210.65,125.72 207.76,125.72 207.52,125.96 204.46,125.96 204.27,125.77 203.4,125.77 202.65,126.51 201.85,126.51 v2(201.84,126.52)
  BOTTOM w0.089: CV418.2 201.43,126.87 201.34,126.78 201.15,126.78 201.04,126.68 201.04,126.41 201.19,126.26 201.58,126.26 v2(201.84,126.52) ; v2(228.97,119.53) 228.66,119.53 228.57,119.45 228.57,119.16 228.77,118.97 229.18,118.97 229.86,118.29 229.86,116.32 230.06,116.12 230.32,116.12 230.41,116.03 230.41,115.84 230.32,115.75 UG9.BL17
GPU_TX1P_C: length 2
  BOTTOM w0.089: UV21.4 201.12,128.94 201.01,128.84 201.01,128.4 201.25,128.16 201.25,127.88 CV418.1
GPU_TX2N: length 41
  IN1 w0.089: v2(199.51,125.4) 199.72,125.19 200.02,125.19 200.64,124.57 200.64,124.36 201.49,123.51 202.74,123.51 203,123.24 204.22,123.24 204.46,123.48 206.78,123.48 207.7,122.57 211.32,122.57 213.28,120.62 213.62,120.62 213.9,120.89 220.54,120.89 220.79,121.15 223.33,121.15 224.79,119.69 224.79,118.39 225.42,117.76 227.08,117.76 227.53,117.31 228.1,117.31 228.46,117.67 228.46,118.25 v2(228.42,118.29)
  BOTTOM w0.089: v2(228.42,118.29) 228.35,118.22 228.35,118.09 228.52,117.91 228.99,117.91 229.08,117.82 229.08,116.25 228.89,116.06 228.71,116.06 228.61,115.96 228.61,115.84 228.7,115.75 UG9.BL15 ; v2(199.51,125.4) 199.75,125.15 199.97,125.15 200.11,125.3 200.11,126.69 200.02,126.78 199.83,126.78 199.72,126.9 CV421.2
GPU_TX2N_C: length 2
  BOTTOM w0.089: CV421.1 199.94,127.93 199.94,128.21 200.03,128.29 200.03,128.73 199.92,128.84 UV21.7
GPU_TX2P: length 41.4
  IN1 w0.089: v2(228.97,118.29) 228.64,117.96 228.64,117.6 228.18,117.14 227.46,117.14 227.01,117.58 225.35,117.58 224.61,118.32 224.61,119.59 223.25,120.95 220.88,120.95 220.62,120.69 213.98,120.69 213.71,120.42 213.19,120.42 211.24,122.37 207.61,122.37 206.7,123.29 204.54,123.29 204.3,123.04 202.92,123.04 202.66,123.31 201.41,123.31 200.44,124.28 200.44,124.49 199.94,124.99 199.69,124.99 v2(199.51,124.81)
  BOTTOM w0.089: UG9.BK15 228.77,115.31 229.12,115.66 229.12,116.03 229.26,116.18 229.26,116.23 229.26,118 v2(228.97,118.29) ; v2(199.51,124.81) 199.67,124.97 200.04,124.97 200.29,125.22 CV420.2
GPU_TX2P_C: length 1.9
  BOTTOM w0.089: UV21.6 200.32,128.84 200.2,128.73 200.2,128.22 200.12,128.13 200.12,127.88 CV420.1
GPU_TX3N: length 37.2
  IN1 w0.089: v2(199.47,125.99) 199.63,125.99 199.77,126.13 199.77,126.26 199.86,126.35 200.05,126.35 200.53,125.86 200.53,125.34 201.11,124.77 201.11,124.55 201.68,123.98 202.4,123.98 202.47,124.04 203.95,124.04 204.02,123.98 207.19,123.98 207.72,123.45 209.28,123.45 209.48,123.25 211.81,123.25 212.67,122.39 214.11,122.39 214.23,122.27 224.35,122.27 226.19,120.44 226.2,120.44 226.32,120.32 226.32,119.22 226.69,118.85 227.33,118.85 227.52,118.67 227.52,118.59 v2(227.22,118.3)
  BOTTOM w0.089: UG9.BM14 228.22,116.6 228.22,116.77 227.5,117.48 227.5,118.06 227.26,118.3 v2(227.22,118.3) ; v2(199.47,125.99) 199.31,126.16 198.74,126.16 198.57,126.32 CV423.2
GPU_TX3N_C: length 2
  BOTTOM w0.089: CV423.1 198.77,127.9 198.77,128.44 198.85,128.51 198.85,128.82 198.72,128.95 UV21.10
GPU_TX3P: length 37.3
  IN1 w0.089: v2(199.47,126.58) 199.5,126.55 200.13,126.55 200.73,125.94 200.73,125.42 201.3,124.85 201.3,124.64 201.77,124.17 202.32,124.17 202.38,124.24 204.03,124.24 204.1,124.17 207.27,124.17 207.8,123.64 209.36,123.64 209.56,123.45 211.89,123.45 212.75,122.59 214.19,122.59 214.31,122.47 224.44,122.47 226.33,120.58 226.33,120.56 226.5,120.39 226.5,119.29 226.76,119.03 227.4,119.03 227.69,118.74 227.69,118.38 v2(227.77,118.3)
  BOTTOM w0.089: UG9.BM15 228.47,116.75 228.47,116.77 227.68,117.56 227.68,118.21 v2(227.77,118.3) ; CV422.2 199.14,126.87 199.06,126.78 198.84,126.78 198.75,126.69 198.75,126.42 198.84,126.33 199.22,126.33 v2(199.47,126.58)
GPU_TX3P_C: length 1.9
  BOTTOM w0.089: CV422.1 198.95,127.9 198.95,128.36 199.02,128.44 199.02,128.82 199.12,128.91 UV21.9
GPU_VID: length 3.1
  BOTTOM w0.203: PU6000.39 276.81,141.29 v1(277.48,141.96) 277.54,141.96 278.2,142.63 PR6044.2
GSYNC_ID: length 23.8
  BOTTOM w0.089: UH1.AK45 209.07,17.04 209.68,16.43 210.85,16.43 211.97,15.31 211.97,15.16
  BOTTOM w0.102: 211.97,15.16 211.97,13.28 210.85,12.16 207.63,12.16 v1(207.27,11.8) 206.81,11.35 202.24,11.35 201.82,11.77 198.93,11.77 198.01,12.69 198.01,13.74 198.14,13.88 RH29.1 RH30.1
H_CPUPWRGD: length 228.6
  TOP w0.089: v4(131.1,116.81) 131.1,116.33 131.2,116.24 v2(131.2,115.8) 131.2,115.27 CH194.1
  IN1 w0.081: v2(209.69,41.6) 209.69,42.25 208.29,43.65 208.29,49.83 204.52,53.59 204.08,53.59 v2(203.41,54.26)
  IN3 w0.127: v2(117.6,35.08) 116.59,35.08 116.42,35.25 116.42,37.93 115.83,38.51 113.46,38.51 109.51,42.47 109.51,57.46 111.59,59.54 111.79,59.54 114.74,62.49 115.95,62.49 128.69,75.22 128.69,94.89 132.14,98.35 132.14,102.75 132.99,103.6 133.42,103.6 136.51,106.69 136.51,113.47 135.61,114.37 132.94,114.37 131.5,115.8 v2(131.2,115.8)
  IN6 w0.081: v2(117.6,35.08) 117.67,35.01 117.67,33.18 118.04,32.82 130.7,32.82 132.26,31.26 178.27,31.26 188.9,41.88 188.9,49.89 190.27,51.27 194.16,51.27 195.49,49.94 198.89,49.94 199.56,50.61 199.56,50.97 202.85,54.26 v2(203.41,54.26)
  BOTTOM w0.089: UH1.AM3 210.02,38.45 209.79,38.69 209.79,39.49 210.02,39.72 210.02,41.27 v2(209.69,41.6)
  BOTTOM w0.107: CPU1.BT31 131.24,115.76 v2(131.2,115.8)
H_DRAMRST#: length 119.5
  TOP w0.114: RD31.2 CD69.1 RD35.2 136.54,52.54 v1(135.49,53.59) 135.06,54.02 v2(134.56,54.02)
  IN1 w0.081: 210.79,40 210.79,42.71 209.39,44.11 209.39,50.29 205.37,54.31 205.37,55.34 204.1,56.61 204.1,57.62 v2(203.63,58.08) ; v2(218.14,32.85) 217.79,32.5 215.78,32.5 215.57,32.72 212.56,32.72 210.96,34.32 210.96,35.67 210.57,36.05 210.57,38.17
  IN1 w0.089: 210.79,40 210.57,39.78 210.57,38.17
  IN6 w0.081: v2(134.56,54.02) 135.3,54.02 137.16,52.16 148.1,52.16 148.34,51.91 168.99,51.91 170.41,53.34 176.83,53.34 177.43,53.94 177.43,56.42 178.87,57.86 189.4,57.86 190.01,57.25 191.23,57.25 191.54,56.94 192.72,56.94 195.97,60.19 200.54,60.19 202.34,58.39 203.33,58.39 v2(203.63,58.08)
  BOTTOM w0.089: UH1.BC14 215.42,33.24 215.66,33.01 216.13,33.01 216.45,32.69 216.65,32.69 216.84,32.51 217.79,32.51 v2(218.14,32.85)
H_PECI: length 340.8
  TOP w0.114: RE76.2 310.5,18.62 v2(310.65,18.76)
  IN3 w0.127: v2(130.44,117.95) 130.72,117.95 132.91,115.76 132.91,115.03 133.36,114.59 135.73,114.59 136.73,113.59 136.73,106.6 133.51,103.39 133.08,103.39 132.36,102.66 132.36,98.57 132.93,98 132.93,93.75 129.55,90.37 129.55,75.36 116.04,61.84 115.36,61.84 111.83,58.3 111.83,52.87 111.09,52.14 111.09,48.14 112.48,46.76 112.48,40.79 114.12,39.15 116.09,39.15 116.93,38.31 v2(116.93,35.81) ; v2(211.08,48.48) 214.5,48.48 217.47,45.51 220.62,45.51 221.78,44.36 223.96,44.36 225.6,42.72 228.65,42.72 229.05,42.31 235.24,42.31 237,44.08 237,44.81 237.64,45.45 242.03,45.45 242.96,44.52 266.06,44.52 273.99,36.6 277.76,36.6 278.86,37.7 282.25,37.7 283.92,36.04 290.84,36.04 292.24,37.43 297.38,37.43 299.67,35.15 299.67,33.69 302.73,30.63 302.73,27.64 305.42,24.95 305.42,22.52 308.29,19.65 309.76,19.65 v2(310.65,18.76)
  IN6 w0.081: v2(211.08,48.48) 211.08,50.13 207.27,53.94 206.29,53.94 205.51,54.73 202.64,54.73 199.58,51.67 196.1,51.67 194.62,53.14 189.52,53.14 187.23,50.85 187.23,42.51 178.1,33.38 132.48,33.38 131.4,34.46 121.45,34.46 119.63,36.28 117.4,36.28 v2(116.93,35.81)
  BOTTOM w0.089: v2(130.44,117.95) 131.11,117.28 CPU1.BT34
  BOTTOM w0.114: RH73.2 v2(211.08,48.48)
H_PM_DOWN: length 219.7
  IN1 w0.081: v2(198.49,50.75) 198.49,50.74 200.81,48.41 200.81,47.12 203.42,44.51 205.78,44.51 208.26,42.03 208.26,41.52 208.41,41.37 208.41,40.99 v2(208.1,40.68)
  IN3 w0.127: v2(105.67,35.41) 105.67,35.88 103.31,38.25 103.31,53.22 104.28,54.18 104.28,58.32 105.18,59.22 106.17,59.22 107.34,60.4 107.34,62.94 116.75,72.34 116.75,90.32 117.92,91.49 117.92,92.88 121.34,96.31 121.34,98.03 123.77,100.46 123.77,111.56 125.87,113.66 125.87,114.21 126.55,114.89 126.55,116.96 v2(126.13,117.39)
  IN6 w0.081: v2(198.49,50.75) 198.03,51.2 195.91,51.2 194.45,52.66 189.95,52.66 187.69,50.4 187.69,42.32 178.25,32.88 132.32,32.88 131.22,33.98 121.1,33.98 119.27,35.81 117.64,35.81 117.24,35.41 v2(105.67,35.41)
  BOTTOM w0.089: v2(208.1,40.68) 208.1,40.56 208.29,40.37 208.52,40.13 208.52,39.69 208.48,39.64 208.48,39.28 UH1.AH2
  BOTTOM w0.114: v2(126.13,117.39) RH155.1
H_PM_SYNC_R: length 220.7
  IN1 w0.081: v2(208.68,40.49) 208.48,40.29 207.98,40.29 207.7,40.57 207.7,40.93 207.49,41.15 207.49,41.56 205.33,43.72 203.12,43.72 200.04,46.8 200.04,48.08 197.62,50.5 v2(197.62,50.75)
  IN3 w0.127: v2(131.23,117.98) 131.23,117.92 132.78,116.37 134.57,116.37 135.53,115.41 135.53,115.09 136.94,113.68 136.94,106.51 133.6,103.17 133.17,103.17 132.57,102.57 132.57,98.66 133.14,98.09 133.14,93.35 130.14,90.35 130.14,75.2 117.06,62.13 117.06,60.89 116.75,60.57 114.88,60.57 113.37,59.06 113.37,53.49 111.63,51.75 111.63,48.38 113.08,46.93 113.08,40.92 114.27,39.72 116.91,39.72 117.94,38.69 117.94,36.47 118.35,36.06 v2(118.35,35.08)
  IN6 w0.081: v2(197.62,50.75) 195.82,50.75 194.41,52.16 189.99,52.16 188.09,50.26 188.09,42.17 178.41,32.49 132.16,32.49 131.06,33.59 120.94,33.59 119.12,35.41 118.69,35.41 v2(118.35,35.08)
  BOTTOM w0.076: CPU1.BM34 134.56,117.75 133.28,117.75 133.2,117.66 132.62,117.66 132.54,117.59 132.1,117.59 132.09,117.57 131.58,117.57 131.23,117.92 v2(131.23,117.98)
  BOTTOM w0.089: v2(208.68,40.49) 208.75,40.42 208.75,39.63 208.66,39.54 208.66,38.73 208.56,38.64 208.56,38.23 UH1.AJ4
H_PROCHOT#: length 407.7
  TOP w0.114: v2(52.21,22.89) PR724.1 ; PQ8.1 74.94,8.16 75.19,8.41 75.19,13.4 v1(74.7,13.89) v2(73.53,15.06) ; v2(307.15,5.56) 307.15,6.18 307.55,6.59 RE78.2 308.7,6.59 QE2.1
  IN1 w0.081: v2(307.15,5.56) 307.15,6.41 305.33,8.22 300.11,8.22 298.71,9.62 298.71,11.08 297.93,11.87 296.69,11.87 295.51,13.05 293.14,13.05 291.09,15.1 273.24,15.1 271.81,13.67 267.83,13.67 266.24,12.08 255.6,12.08 254.83,12.86 241.86,12.86 239.92,10.92 229.47,10.92 229.16,10.61 212.7,10.61 212.38,10.29 207.57,10.29 207.31,10.03 206.16,8.88 193.19,8.88 192.57,9.5 186.57,9.5 175.08,20.99 130.25,20.99 v2(129.17,19.91)
  IN3 w0.127: v2(128.27,115.83) 128.64,115.83 129.93,114.54 129.93,104.3 128.95,103.32 128.95,102.38 125.76,99.19 125.76,98.57 119.43,92.24 119.43,71.91 110.33,62.81 110.33,61.27 107.38,58.31 107.38,56.93 105.91,55.47 105.91,41.09 107.82,39.17 107.82,31.98 103.25,27.41 103.25,26.59 101.47,24.81 101.47,23.48 98.97,20.99 v2(98.43,20.99)
  IN6 w0.081: v2(129.17,19.91) 113.97,19.91 111.47,17.41 98.73,17.41 98.44,17.7 98.44,20.98 v2(98.43,20.99) 97.1,20.99 95.96,19.84 84.27,19.84 81.14,16.71 75.18,16.71 v2(73.53,15.06) 71.87,13.39 63.78,13.39 63.38,13.79 63.38,17.69 63.13,17.94 59.76,17.94 57.92,19.78 55.95,19.78 52.83,22.89 v2(52.21,22.89)
  BOTTOM w0.114: RH165.2 v2(128.27,115.83) RH158.1
H_THERMTRIP#: length 105.6
  TOP w0.254: RH163.2 167.02,115.42 v2(167.6,116)
  IN6 w0.081: 175.71,91.1 175.71,90.06 177.95,87.82 177.95,79.68 179.2,78.42 179.2,75.82 177.7,74.32 177.7,69.52 179.2,68.02 179.2,62.08 181.57,59.72 185.17,59.72 185.31,59.86 190.15,59.86 190.45,59.56 191.65,59.56 192.43,60.33 193.83,60.33 195.39,61.89 200.59,61.89 v2(201.56,60.93)
  IN6 w0.097: 175.71,91.1 175.71,91.99 172.41,95.29 172.41,103.19 172.18,103.41 169.27,103.41 167.71,104.97 167.71,115.89 v2(167.6,116)
  BOTTOM w0.076: CPU1.J31 167.93,115.66 v2(167.6,116)
  BOTTOM w0.114: RH79.2 210.13,47.21 209.76,47.57 209.76,50.13 204.94,54.96 204.22,54.96 203.22,55.96 203.22,58.99 202.86,59.36 202.86,59.63 v2(201.56,60.93)
H_THERMTRIP#_R: length 10
  BOTTOM w0.089: 207.65,41.62 207.65,40.62 207.99,40.27 208.13,40.27 208.35,40.06 208.35,39.76 208.3,39.72 208.3,39.48 208,39.18 208,38.39 208.06,38.33 208.24,38.33 208.33,38.42 UH1.AJ3
  BOTTOM w0.114: 207.65,41.62 207.65,41.84 208.07,42.26 208.07,44.13 v1(208.5,44.56) 210.16,46.22 RH79.1
H_VCCST_PWRGD: length 237
  TOP w0.114: v2(305.74,20.21) UE5.123 ; v2(177.61,96.87) 177.11,97.38 175.84,97.38 174.82,98.39 174.82,99.75 174.71,99.86 RH164.2 RH154.1 173.8,100.73 173.55,100.48 CH193.1 ; Q7.3 319.89,44.64 319.29,44.04 319.29,40.35 318.46,39.53 318.46,38.12 318.92,37.66 318.92,35.73 v4(316.3,33.12) 316.16,32.98 316.16,27.22 v2(314.26,25.32)
  IN1 w0.081: v2(314.26,25.32) 313.11,24.17 313.11,23.8 309.53,20.21 v2(305.74,20.21)
  IN3 w0.127: v2(305.74,20.21) 304.1,21.86 304.1,23.09 302.92,24.27 302.92,25.24 302.37,25.79 301.4,25.79 299.3,27.9 299.3,29.19 298.61,29.88 293.82,29.88 288.2,35.5 283.73,35.5 282.04,37.19 279.07,37.19 277.97,36.09 274.15,36.09 274.15,36.09 273.78,36.09 265.87,44 237.65,44 235.16,41.51 228.58,41.51 227.89,42.21 225.39,42.21 223.85,43.75 218.43,43.75 214.45,47.72 211.15,47.72 210.39,48.48 210.39,51.32 212.52,53.45 212.52,59.68 209.11,63.09 v2(208.54,63.09)
  IN6 w0.081: v2(177.61,96.87) 177.61,89.98 179.23,88.36 179.23,80.18 180.47,78.95 180.47,74 178.8,72.34 178.8,69.97 180.3,68.47 180.3,65.92 183.25,62.97 190.69,62.97 191.81,61.85 193.8,61.85 196.29,64.35 198.88,64.35 200.14,63.09 v2(208.54,63.09)
HDA_SPKR: length 264
  TOP w0.114: DA1.3 41.29,26.39 41.49,26.59 41.49,30.75 41.38,30.86 41.38,32.62 41.03,32.97 40.02,32.97 39.85,32.8 39.56,32.8 39.29,33.07 39.29,33.41 39.55,33.67 39.55,36.38 36.41,39.52 36.41,50.37 v2(36.2,50.58)
  IN1 w0.081: v2(217.44,26.31) 218.51,26.31 218.7,26.51 218.7,27.72 217.73,28.69 216.44,28.69 215.74,29.38 215.74,29.79 215.02,30.51 213.37,30.51 211.65,32.23 211.02,32.23 210.45,32.8 210.45,35.1 209.66,35.88 209.66,39.7 210.07,40.11 210.07,42.41 208.67,43.81 208.67,49.99 204.4,54.26 v2(204.11,54.26)
  IN6 w0.081: v2(204.11,54.26) 203.6,53.75 202.88,53.75 199.94,50.81 199.94,50.21 199.28,49.55 195.31,49.55 193.98,50.88 190.43,50.88 189.3,49.75 189.3,41.74 178.43,30.87 132.07,30.87 130.52,32.43 110.8,32.43 108.47,34.76 105.55,34.76 105.19,35.13 105.19,40.42 97.81,47.79 97.81,48.08 96.89,49 87.8,49 87.32,49.48 81.46,49.48 81.3,49.32 67.55,49.32 67.25,49.61 47.02,49.61 45.36,51.28 36.9,51.28 v2(36.2,50.58)
  BOTTOM w0.089: UH1.BD26 216.82,26.94 v2(217.44,26.31)
HDMI_CTRLCLK: length 65.2
  IN4 w0.102: v2(223.59,120.1) 223.37,119.87 223.1,119.87 215.08,127.9 212.7,127.9 211.68,128.92 211.68,129.13 210.13,130.68 210.13,132.9 210.64,133.41 210.64,146.46 209.14,147.96 209.14,151.59 213.45,155.89 213.45,156.36 215.32,158.24 216.12,158.24 216.79,158.9 218.84,158.9 219.72,159.77 220.13,159.77 220.25,159.66 v2(220.25,159.53)
  BOTTOM w0.101: UG9.BK9 224.89,115.37 224.89,115.99 225.12,116.22 v3(225.12,119.02) 225.12,119.44 224.47,120.08 223.61,120.08 v2(223.59,120.1)
  BOTTOM w0.102: v2(220.25,159.53) 219.94,159.84 219.31,159.84 RV648.2 217.38,159.12 217.16,159.35 QV96.4
HDMI_CTRLDAT: length 71.2
  IN4 w0.102: v2(220.25,160.16) 220.09,160 219.63,160 218.75,159.12 216.69,159.12 216.03,158.46 215.22,158.46 213.22,156.46 213.22,155.99 208.91,151.68 208.91,147.86 210.41,146.36 210.41,133.5 209.9,132.99 209.9,130.58 211.45,129.03 211.45,128.82 212.61,127.67 214.98,127.67 222.26,120.39 222.31,120.39 223.02,119.68 223.47,119.68 v2(223.59,119.55)
  BOTTOM w0.101: v2(223.59,119.55) 223.59,119.58 223.89,119.87 224.39,119.87 224.91,119.35 224.91,116.31 224.67,116.07 224.44,116.07 224.25,115.88 224.25,115.6 224.32,115.53 224.47,115.53 224.57,115.63 UG9.BL9
  BOTTOM w0.102: RV652.2 214.96,161.44 215.73,161.44 QV96.1 215.86,162.3 216.14,162.58 217.75,162.58 218.17,162.16 218.77,162.16 218.86,162.07 220.62,162.07 220.91,161.78 220.91,161.22 220.82,161.13 220.82,160.74 v2(220.25,160.16)
HDMI_DOWN: length 16.9
  TOP w0.102: v2(222.21,163.38) v1(221.51,163.38)
  TOP w0.254: 219.17,160.34 219.17,160.08 218.86,159.77 v2(218.6,159.77) ; 219.17,160.34 LX4.2 216.92,160.34 LX5.2 LX6.2 214.58,160.41 LX1.2 LX2.2 LX7.2 LX8.2 ; 219.17,160.34 LX3.2
  IN2 w0.254: v2(218.6,159.77) 219.01,160.18 219.01,161.09 221.29,163.38 v2(222.21,163.38)
  BOTTOM w0.254: QX1.1 222.17,163.42 v2(222.21,163.38)
HDMI_HPD_GPU#: length 155
  TOP w0.102: QV97.6 217.88,157.33 v2(217.88,156.32) ; v1(235.88,155.43) v2(235.88,154.85)
  IN4 w0.089: 219.53,119.98 220.1,120.56
  IN4 w0.102: v2(218.07,108.12) 218.06,108.12 216.19,109.99 216.19,114.39 217.24,115.44 217.24,117.7 219.53,119.98 ; 220.1,120.56 220.35,120.81 220.95,120.81 222.26,119.5 222.26,118.97 223.44,117.79 225.4,117.79 225.91,118.3 225.91,120.16 229.67,123.92 236.02,123.92 239.15,127.06 261.9,127.06 264.65,129.81 268.59,129.81 269.55,130.78 269.55,142.97 264.07,148.45 252.89,148.45 252.6,148.16 244.69,148.16 243.11,149.74 241.15,149.74 239.94,150.95 238.01,150.95 237.6,151.37 237.6,153.35 236.11,154.85 v2(235.88,154.85)
  BOTTOM w0.1: UG9.BA4 220.82,108.75 220.5,108.43 218.39,108.43 v2(218.07,108.12)
  BOTTOM w0.102: RX7.2 213.69,156.56 213.69,156.05 214.18,155.56 215.27,155.56 216.04,156.32 v2(217.88,156.32) 218.32,155.87 218.32,155.04 219.05,154.31 231.48,154.31 232.01,154.85 v2(235.88,154.85)
HDMI_HPD_PCH: length 193
  IN2 w0.102: v2(210.39,159.35) 209.62,158.58 209.62,156.61 208.64,155.63 208.64,154.71 205.95,152.01 205.95,150.09 196.24,140.38 196.24,137.96 190.11,131.83 190.11,126.43 184.8,121.12 184.8,115.73 183.61,114.54 183.61,105.46 181.36,103.2 181.36,96.65 186.24,91.76 186.24,87.22 177.55,78.53 177.55,71.54 179.13,69.96 180.58,69.96 180.72,70.1 184.93,70.1 190.38,64.65 190.38,61.41 191.22,60.57 193.01,60.57 193.76,61.32 v2(193.76,62.45)
  IN3 w0.089: v2(213.18,20.42) 213.77,21.01 213.77,21.46 213.41,21.83 211.94,21.83 210.72,23.05 210.72,24.24 209.51,25.44 206.83,25.44 206.74,25.35 203.36,25.35 203.27,25.44 203.27,31.91 203.82,32.46 203.82,39.47 201.41,41.88 201.41,42.08
  IN3 w0.102: 201.41,42.08 201.41,42.67 199.49,44.59 199.49,47.87 196.94,50.42 196.94,51.36 193.72,54.58 193.72,57.56 194.27,58.1 194.27,61.94 v2(193.76,62.45)
  BOTTOM w0.089: v2(213.18,20.42) 212.66,19.9 UH1.AU41
  BOTTOM w0.102: v2(193.76,62.45) 194.3,62.45 v1(194.36,62.39) ; v2(210.39,159.35) 210.04,159 QX3.3 210.33,158.58 210.52,158.77 UX2.1 211.22,158.4 211.34,158.28 211.63,158.28 212.14,157.77 213.94,157.77 RX8.1
HDMI_HPLUG: length 29.3
  IN6 w0.102: v2(209.74,163.39) 210.14,162.99 210.14,162.21 211.27,161.08 218.35,161.08 220.16,162.88 220.16,165.52 221.88,167.23 221.88,173.26 221.43,173.7 221.43,173.99 JHDMI.19
  BOTTOM w0.102: v2(209.74,163.39) 209.74,163.19 210.28,162.65 v1(210.28,162.39) 210.28,161.31 CX2.1 RX6.2
HP2_D_L1_JK: length 28.4
  TOP w0.254: LA12.1 21.34,23.9 CA50.1 21.12,24.44 20.86,24.7 19.2,24.7 18.77,25.13 18.77,28.32 v1(19.66,29.21) v2(20.07,29.62)
  BOTTOM w0.254: JACK2.1 15.45,17 16.23,17.77 16.23,26.73 18.49,28.99 18.49,29.88 19.6,30.99 DA6.3 20.06,30 20.07,29.99 v2(20.07,29.62)
HP2_D_L_C:
  vias: v1(26.68,27.1) v2(26.93,26.19) v2(26.93,25.56)
HP2_D_L_R: length 6.7
  TOP w0.254: RA46.1 24.46,28.84 RA43.2 24.46,27.34 24.79,27.01 RA41.2 24.46,26.57 24.2,26.32 24.2,25.5 23.9,25.19 v1(23.72,25.19) 22.96,25.19 RA44.1 22.68,24.92 LA12.2
HP2_D_R1_JK: length 30.2
  TOP w0.254: LA11.1 21.63,22.56 CA48.1 21.18,23.07 20.57,23.68 19.35,23.68 18.71,24.32 v1(18.63,24.32) 18.36,24.59 18.36,28.8 19.82,30.26 v2(20.87,30.26)
  IN1 w0.254: JACK2.2 8.82,27.35 16.91,27.35 20.56,30.99 v2(20.99,30.99)
  BOTTOM w0.254: v2(20.99,30.99) DA6.2 21.99,30.21 21.73,29.94 21.22,29.94 20.9,30.26 v2(20.87,30.26)
HP2_D_R_C: length 0.7
  TOP w0.127: v2(25.15,23.53) v1(25.15,22.85)
  vias: v2(25.79,23.53)
HP2_D_R_R: length 8
  TOP w0.254: RA47.1 22.68,26.21 23.07,25.81 v2(23.69,25.81) ; RA45.1 23.22,22.23 22.71,22.23 LA11.2 22.68,22.56 v1(23.57,23.44) 24.35,24.22 RA42.2 24.69,24.46 24.69,25.02 RA40.2 24.79,25.93 v2(24.71,26)
  IN3 w0.254: v2(23.69,25.81) 23.88,26 v2(24.71,26)
HP_LINE1_JD: length 7.4
  TOP w0.102: v2(36.56,29.99) 34.9,29.99 v1(34.22,29.32)
  TOP w0.107: v2(36.56,29.99) 37.14,30.57 RA36.1 RA34.1
  BOTTOM w0.107: UA1.9 36.47,29.91 v2(36.56,29.99) 37.16,29.99 RA34.1 RA32.2
HP_MUTE#: length 28.9
  TOP w0.203: UA3.B1 19.12,23.2 v2(18.73,23.59) ; UA2.B1 20.19,28.73 19.25,27.78 v1(19.25,27.26) v2(19.25,25.47)
  TOP w0.254: v2(19.25,25.47) 19.33,25.39 19.85,25.39 RA13.2
  IN1 w0.254: v2(19.25,25.47) 19.25,25.39 18.73,24.87 v2(18.73,23.59)
  IN3 w0.254: v2(36.09,23.03) 34.49,21.43 31.76,21.43 30.87,22.32 21.59,22.32 20.32,23.59 v2(18.73,23.59)
  BOTTOM w0.254: v2(36.09,23.03) 36.55,22.57 DA2.1
HPOUT-L: length 14.7
  IN6 w0.254: v2(27.52,28.77) 27.66,28.77 28.41,28.02 28.41,25.33 24.9,21.81 v2(24.9,20.16)
  BOTTOM w0.203: UA1.32 27.94,29.11 27.6,28.77 v2(27.52,28.77)
  BOTTOM w0.254: RA35.1 25.47,18.33 25.47,19.02 24.9,19.59 v2(24.9,20.16)
HPOUT-R: length 22.2
  TOP w0.254: v2(19.44,19.93) 20.02,20.52 RA37.1
  IN6 w0.254: v2(27.52,29.39) 27.87,29.39 28.99,28.28 28.99,24.75 27.63,23.4 27.63,20.36 26.17,18.89 24.46,18.89 22.93,20.42 19.92,20.42 v2(19.44,19.93)
  BOTTOM w0.203: UA1.33 27.64,29.51 v2(27.52,29.39)
HPOUT_JD: length 38.8
  TOP w0.107: RA34.2 38.83,29.24 v1(39.41,29.24) v2(39.86,28.79)
  IN2 w0.254: v2(39.86,28.79) 38.17,28.79 37.16,27.78 36.62,27.78 36.43,27.96 35.44,27.96 34.43,26.96 32.19,26.96 31.53,26.3 29.38,26.3 23.77,20.68 18.67,20.68 18.2,20.21 17.26,20.21 16.51,19.46 16.51,17 15.15,15.64 12.57,15.64 10.73,13.8 JACK1.6
I2C0_SCL_EC: length 351.4
  TOP w0.114: v2(300.46,9.43) 300.34,9.32 UE5.83 ; RA56.1 39.59,16.31 39.95,16.66 39.95,16.84 40.21,17.1 41.76,17.1 42.3,16.57 42.3,13.49 42.11,13.3 42.11,12.41 v1(41.96,12.26) 41.62,11.93 v2(41.44,11.93) ; v2(326.69,15.4) 326.5,15.21 326.27,15.21 326.13,15.36 JIO.12
  IN6 w0.081: v2(36.96,28.26) 36.96,18.73 38.49,17.2 38.49,14.55 37.31,13.37 37.31,11.24 38.03,10.52 39.32,10.52 39.33,10.54 39.45,10.54 40.94,12.03 41.34,12.03 v2(41.44,11.93) 41.62,12.1 42.66,12.1 44.23,13.67 48.9,13.67 55.24,7.33 65.99,7.33 66.35,6.97 87.08,6.97 90.29,10.17 103.98,10.17 109.76,4.4 172.71,4.4 177.69,9.38 180.85,9.38 185.87,4.35 252.4,4.35 254.6,6.55 255.83,6.55 259.3,10.02 278.77,10.02 282.63,6.16 296.21,6.16 299.71,9.67 300.22,9.67 v2(300.46,9.43) 300.73,9.43 300.99,9.17 300.99,6.35 302.41,4.93 323.68,4.93 328,9.26 328,14.6 327.39,15.21 326.88,15.21 v2(326.69,15.4)
  BOTTOM w0.114: UA1.12 36.16,28.71 36.37,28.5 36.73,28.5 v2(36.96,28.26)
I2C0_SCL_EC_R: length 8.4
  TOP w0.114: UA4.8 38.25,10.01 38.35,10.12 v2(38.49,10.12) 39.24,10.12 40.08,10.95 40.08,12.8 39.57,13.31 v1(39.57,13.8) RA56.2
  BOTTOM w0.114: RA50.2 38.84,10.12 v2(38.49,10.12)
I2C0_SDA_EC: length 350.3
  TOP w0.114: UE5.84 300.74,9.11 300.9,9.26 v2(300.9,9.82) ; v2(41.41,12.53) 41.59,12.53 41.86,12.8 41.86,13.62 42.06,13.82 42.06,16.47 41.66,16.86 40.31,16.86 40.19,16.74 40.19,16.57 RA55.1 ; v2(326.69,14.81) 326.54,14.97 326.28,14.97 326.17,14.85 JIO.11
  IN6 w0.081: v2(326.69,14.81) 326.88,15 327.31,15 327.8,14.51 327.8,9.34 323.59,5.14 302.5,5.14 301.2,6.44 301.2,9.25 300.9,9.56 v2(300.9,9.82) 300.85,9.87 299.63,9.87 296.12,6.37 282.72,6.37 278.86,10.23 259.21,10.23 255.75,6.76 254.52,6.76 252.31,4.56 185.96,4.56 180.93,9.59 177.61,9.59 172.62,4.6 109.84,4.6 104.06,10.38 90.2,10.38 86.99,7.17 66.44,7.17 66.07,7.54 55.32,7.54 48.99,13.88 44.14,13.88 42.57,12.31 41.63,12.31 v2(41.41,12.53) 41.13,12.24 40.86,12.24 39.36,10.75 38.12,10.75 37.52,11.35 37.52,13.29 38.74,14.51 38.74,17.3 37.2,18.85 37.2,27.09 37.36,27.26 37.36,28.58 37.03,28.91 v2(36.54,28.91)
  BOTTOM w0.114: v2(36.54,28.91) 36.34,29.11 UA1.11
I2C0_SDA_EC_R: length 9.5
  TOP w0.114: UA4.7 38.31,9.61 38.45,9.48 v2(38.49,9.48) 39.43,9.48 v1(40.59,10.64) 40.65,10.7 40.65,12.92 40.07,13.51 40.07,15.03 40.43,15.39 RA55.2
  BOTTOM w0.114: RA53.2 39.09,9.48 v2(38.49,9.48)
I2C_CLK: length 440.6
  TOP w0.114: v2(312.3,18.84) 312.08,19.06 312.08,19.34 RE2.2 CE58.1 ; v2(314.93,12.1) 314.75,12.28 314.75,12.57 314.4,12.92 313.5,12.92 313.3,13.13 UE1.29 ; UE4.25 189.6,23.18 v2(189.49,23.3) ; v2(302.46,36.48) 302.59,36.35 302.78,36.35 302.92,36.49 302.92,37.33 303.43,37.85 303.69,37.85 303.82,37.98 UE8.25 ; UE3.25 226.33,160.36 226.13,160.56 226.13,160.75 225.88,161 225.27,161 224.91,160.64 224.91,160.47 v2(224.69,160.26)
  IN1 w0.081: v2(312.3,18.84) 312.08,19.06 312.08,19.58 311.48,20.18 310.31,20.18 309.63,19.5 300.05,19.5 299.22,18.68 280.48,18.68 279.47,17.68 272.4,17.68 271.89,17.17 269.07,17.17 267.48,15.58 265.83,15.58 264.24,13.99 260.59,13.99 258.67,15.9 255.97,15.9 255.74,15.68 248.53,15.68 247.98,15.13 246.44,15.13 246.03,15.54 240.46,15.54 237.83,12.91 228.77,12.91 228.37,12.52 211.91,12.52 211.59,12.19 206.42,12.19 205.94,11.72 205.93,11.72 205.77,11.56 204.07,11.56 203.19,12.43 201.96,12.43 200.99,11.47 193.3,11.47 191.35,13.42 190.51,13.42 v2(190.31,13.62) 190.02,13.62 189.41,14.23 187.44,14.23 182.56,19.11 182.56,24.09 182.33,24.32 182.07,24.32 v2(181.88,24.51)
  IN3 w0.127: v2(170.58,175.82) 170.7,175.7 170.7,175.24 171.02,174.91 171.52,174.91 172.73,176.12 174.66,176.12 175.54,175.23 178.99,175.23 179.47,175.71 183.63,175.71 185.64,173.7 188.26,173.7 188.5,173.94 189.96,173.94 191.83,172.07 195.34,172.07 195.8,171.61 201.47,171.61 203.3,169.79 205.2,169.79 205.97,169.03 205.97,167.47 207.66,165.79 218.71,165.79 220.49,164 224.2,164 225.32,162.88 225.32,161.49 224.93,161.1 224.93,160.49 v2(224.69,160.26) 224.86,160.09 224.86,159.2 224.06,158.4 221.24,158.4 220.51,157.66 216.91,157.66 216.59,157.35 214.07,157.35 213.34,156.62 210.79,156.62 206.35,152.18 206.35,149.28 205.13,148.07 205.13,143.65 206.73,142.05 206.73,137.46 207.14,137.05 207.14,132.65 206.45,131.96 206.45,129.81 206.96,129.3 206.96,127.03 207.44,126.55 207.44,125.66 207.44,125.18 206.05,123.79 205.9,123.79 203.21,121.1 203.21,118.27 199.14,114.2 199.14,113.75 197.79,112.39 197.79,112.12 194.08,108.42 190.56,108.42 188.72,106.58 188.72,105.67 186.07,103.02 186.07,98.43 185.88,98.24 185.88,94.04 186.22,93.7 186.22,87.8 185.22,86.79 185.22,70.43 183.59,68.8 183.59,63.55 184.01,63.13 184.01,55.01 185.63,53.39 185.63,44.88 190.64,39.87 190.64,33.69 184.32,27.37 184.32,25.65 183.03,24.36 182.03,24.36 v2(181.88,24.51) ; v2(302.46,36.48) 302.65,36.29 303.01,36.29 303.54,35.76 303.54,31.97 303.86,31.65 303.86,28.73 305.38,27.21 305.38,26.13 306.22,25.29 306.22,22.93 308.48,20.67 311.45,20.67 312.16,19.96 312.16,18.97 v2(312.3,18.84)
  BOTTOM w0.114: v2(314.93,12.1) 314.77,12.26 314.77,12.77 313.05,14.48 313.05,17.47 312.13,18.39 312.13,18.66 v2(312.3,18.84) ; v2(190.31,13.62) 190.13,13.45 189.88,13.45 188.73,14.6 188.73,21.73 189.29,22.28 189.29,23.09 v2(189.49,23.3) ; JCDRA.45 170.47,176.66 170.77,176.35 170.77,176.01 v2(170.58,175.82)
I2C_CTL_EN: length 7
  BOTTOM w0.102: RV22.1 207.65,131.85 207.65,131.26 207.47,131.07 207.39,131 206.87,131 206.8,131.07 205.46,131.07 205.03,131.5 RV21.1 205.03,131.55 204.38,132.2 204.38,132.81 204.2,132.98 UV21.53
I2C_DAT: length 439.1
  TOP w0.114: v2(225.28,160.26) 225.15,160.38 225.15,160.54 225.37,160.76 225.78,160.76 225.89,160.65 225.89,160.46 226.08,160.27 226.08,160.18 226.4,159.86 UE3.26 ; v2(302.46,35.9) 302.68,36.11 302.88,36.11 303.16,36.39 303.16,37.23 303.53,37.61 303.69,37.61 303.82,37.48 UE8.26 ; RE1.2 311.84,19.44 311.84,18.96 v2(311.72,18.84) ; UE1.30 313.3,12.33 313.65,12.68 314.3,12.68 314.48,12.5 314.48,12.24 v2(314.34,12.1) ; UE4.26 189.1,23.1 v2(188.91,23.3)
  IN1 w0.081: v2(181.88,23.93) 182.07,24.11 182.24,24.11 182.35,24.01 182.35,19.02 187.35,14.02 189.32,14.02 v2(190.31,13.04) 190.48,13.21 191.26,13.21 193.21,11.26 201.08,11.26 202.04,12.22 203.1,12.22 203.98,11.35 205.86,11.35 206.02,11.51 206.03,11.51 206.5,11.98 211.68,11.98 212,12.31 228.46,12.31 228.86,12.7 237.92,12.7 240.55,15.34 245.94,15.34 246.36,14.92 248.07,14.92 248.62,15.47 255.83,15.47 256.05,15.69 258.59,15.69 260.5,13.78 264.33,13.78 265.92,15.37 267.57,15.37 269.16,16.96 271.98,16.96 272.49,17.47 279.56,17.47 280.56,18.47 299.31,18.47 300.13,19.3 309.72,19.3 310.4,19.97 311.39,19.97 311.87,19.49 311.87,18.99 v2(311.72,18.84)
  IN3 w0.127: v2(311.72,18.84) 311.91,19.03 311.91,19.85 311.35,20.42 308.37,20.42 305.96,22.82 305.96,25.19 305.13,26.03 305.13,27.1 303.6,28.63 303.6,31.55 303.28,31.87 303.28,35.66 302.9,36.04 302.6,36.04 v2(302.46,35.9) ; v2(181.88,23.93) 182.06,24.11 183.14,24.11 184.58,25.54 184.58,27.27 190.89,33.58 190.89,39.97 185.88,44.98 185.88,53.49 184.26,55.11 184.26,63.24 183.84,63.66 183.84,68.7 185.47,70.32 185.47,86.69 186.47,87.69 186.47,93.8 186.13,94.14 186.13,98.14 186.32,98.33 186.32,102.92 188.97,105.56 188.97,106.47 190.66,108.16 194.19,108.16 198.04,112.02 198.04,112.28 199.4,113.64 199.4,114.1 203.46,118.16 203.46,121 206,123.54 206.15,123.54 207.69,125.08 207.69,125.66 207.69,126.65 207.21,127.13 207.21,129.4 206.7,129.91 206.7,131.86 207.39,132.55 207.39,137.16 206.98,137.57 206.98,142.16 205.38,143.76 205.38,147.96 206.6,149.18 206.6,152.08 210.89,156.37 213.45,156.37 214.17,157.09 216.7,157.09 217.01,157.41 220.61,157.41 221.35,158.15 224.16,158.15 225.11,159.09 225.11,160.09 v2(225.28,160.26) 225.18,160.35 225.18,160.99 225.57,161.39 225.57,162.99 224.3,164.26 220.6,164.26 218.81,166.04 207.76,166.04 206.22,167.58 206.22,169.13 205.31,170.04 203.4,170.04 201.58,171.87 195.9,171.87 195.45,172.32 191.93,172.32 190.06,174.19 188.39,174.19 188.16,173.96 185.75,173.96 183.74,175.97 179.37,175.97 178.88,175.48 175.65,175.48 174.76,176.37 172.62,176.37 171.42,175.16 171.13,175.16 170.95,175.34 170.95,175.61 v2(171.16,175.82)
  BOTTOM w0.114: v2(190.31,13.04) 190.13,13.21 189.78,13.21 188.49,14.5 188.49,21.83 189.05,22.38 189.05,23.16 v2(188.91,23.3) ; v2(314.34,12.1) 314.52,12.28 314.52,12.67 312.81,14.38 312.81,17.37 311.89,18.29 311.89,18.66 v2(311.72,18.84) ; v2(171.16,175.82) 171.01,175.97 171.01,176.4 171.27,176.66 JCDRA.46
I2CC_SCL: length 17.4
  IN1 w0.081: v2(194.3,116.89) 194.51,116.68 194.85,116.68 199.19,121.02 200.82,121.02 201.19,120.65 202.67,120.65 204.26,119.06 204.75,119.06 204.84,119.16 v2(205.81,119.16)
  BOTTOM w0.114: RG60.2 194.53,116.83 194.37,116.83 v2(194.3,116.89) 194.13,116.72 193.9,116.72 193.69,116.93 UG11.6 ; QG7.3 205.66,119.59 205.81,119.44 v2(205.81,119.16)
I2CC_SCL_R: length 35.7
  IN6 w0.081: v2(206.19,118.46) 206.45,118.71 206.45,119.32 206.53,119.4 207.2,119.4 207.4,119.61 207.4,120.43 209.52,122.55 211.05,122.55 213.45,120.16 215.24,120.16 215.85,119.55 217.93,119.55 218.79,120.41 218.84,120.41 219.95,121.52 222.91,121.52 223.87,120.56 ; 224.11,120.32 224.47,119.96 224.47,119 224.44,118.98 224.44,116.97 224.54,116.87
  IN6 w0.089: v2(224.97,113.35) 224.56,113.76 224.56,116.86 224.54,116.87 ; 224.11,120.32 223.87,120.56
  BOTTOM w0.1: UG9.BG9 v2(224.97,113.35)
  BOTTOM w0.114: RG12.2 206.82,119.08 v2(206.19,118.46) 206,118.65 204.92,118.65 203.99,119.59 QG7.4
I2CC_SDA: length 14
  IN1 w0.081: v2(194.3,116.31) 194.46,116.47 194.93,116.47 199.27,120.81 200.74,120.81 201.46,120.09 v2(202.6,120.09)
  BOTTOM w0.114: v2(202.6,120.09) 202.6,120.77 202.71,120.89 QG7.6 ; UG11.7 193.72,116.28 193.93,116.48 194.13,116.48 v2(194.3,116.31) 194.49,116.5 194.92,116.5 RG61.2
I2CC_SDA_R: length 32.1
  IN6 w0.081: 224.63,117.25 224.63,118.92 224.64,118.93 224.64,120.08 223,121.72 219.87,121.72 217.86,119.72 215.92,119.72 215.31,120.33 215.06,120.33 215.02,120.36 213.53,120.36 211.14,122.76 209.43,122.76 207.19,120.52 207.19,119.69 207.11,119.61 206.72,119.61 206.64,119.69 206.64,120.12 v2(206.21,120.56)
  IN6 w0.089: 224.63,117.25 224.63,117.04 224.74,116.93 224.74,114.16 v2(224.94,113.95)
  BOTTOM w0.1: UG9.BH9 v2(224.94,113.95)
  BOTTOM w0.114: QG7.1 205.87,120.89 v2(206.21,120.56) 206.27,120.62 RG11.2
