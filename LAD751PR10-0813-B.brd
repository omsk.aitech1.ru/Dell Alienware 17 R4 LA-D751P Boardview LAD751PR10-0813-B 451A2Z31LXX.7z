# Allegro board LAD751PR10-0813-B.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_HDMI_DDC_CLK: length 3
  TOP w0.089: UT1.Y2 176.15,161.33 175.77,161.33 175.76,161.32 175.54,161.32 174.57,160.34 174.49,160.34 174.39,160.24
  TOP w0.102: T9.1 174.3,160.15 174.39,160.24
TBT_HDMI_DDC_DATA: length 4.8
  TOP w0.089: 174.6,160.12 175.57,161.1 UT1.Y1
  TOP w0.127: 174.6,160.12 174.21,159.74 172.22,159.74 T7.1
TBT_HOLD_N: length 10.5
  BOTTOM w0.102: v1(191.45,150.4) UT2.7
  BOTTOM w0.107: UT2.7 191.45,157.13 189.23,159.35 RT51.2
TBT_I2C_SCL: length 43.8
  TOP w0.089: 174.39,163.29 174.41,163.26 ; v2(174.79,162.88) 174.79,162.88 174.97,162.7 176.16,162.7 UT1.U2
  TOP w0.114: RT27.2 174.35,163.32 174.39,163.29 ; 174.41,163.26 v2(174.79,162.88)
  IN3 w0.127: v2(174.79,162.88) 174.99,162.68 174.99,162.49 175.74,161.74 175.74,159.86 176.37,159.23 179.04,159.23 179.54,159.72 183.72,159.72 187.84,163.84 187.84,166.25 188.43,166.85 189.34,166.85 189.92,166.28 191.48,166.28 194.06,168.85 196.23,168.85 198.13,166.95 198.13,164.52 196.46,162.84 196.46,161.7 196.66,161.5 v2(196.93,161.5)
  BOTTOM w0.076: UT4.D2 198.41,161.82 198.04,161.82 197.94,161.71 197.93,161.71 197.38,161.71 197.16,161.5 v2(196.93,161.5)
TBT_I2C_SDA: length 43
  TOP w0.114: RT26.2 174.52,162.33 v2(174.6,162.33) 174.76,162.48 UT1.U1
  IN3 w0.127: v2(174.6,162.33) 174.8,162.33 175.48,161.64 175.48,159.75 176.26,158.97 179.15,158.97 179.64,159.46 183.83,159.46 188.1,163.74 188.1,166.15 188.54,166.59 189.24,166.59 189.81,166.02 191.59,166.02 194.17,168.6 196.12,168.6 197.87,166.85 197.87,164.62 196.2,162.95 196.2,161.6 196.68,161.12 v2(196.68,160.94)
  BOTTOM w0.076: v2(196.68,160.94) 196.69,160.94 196.69,160.93 196.81,161.04 197.09,161.04 197.56,161.51 198.02,161.51 198.07,161.57 UT4.D1
TBT_PCIE_WAKE#: length 283.9
  TOP w0.102: UE5.70 295.14,9.09 295.38,9.33 295.38,14.7 295.73,15.05 v2(295.73,17.43)
  TOP w0.107: RT10.2 171.97,161.5 v2(171.76,161.3)
  IN4 w0.102: v2(171.76,161.3) 172.58,160.48 175.71,160.48 177.29,158.9 178.86,158.9 179.17,158.58 183.09,158.58 185.36,156.31 188.61,156.31 190.32,154.6 190.32,152.47 191.77,151.02 191.77,149.1 195.25,145.61 195.25,137.87 195.77,137.36 195.77,136.16 194.83,135.23 194.83,129.87 194.21,129.25 194.21,128.12 193.53,127.44 193.53,123.74 188.41,118.63 188.41,115.36 187.23,114.18 187.23,111.46 185.93,110.16 185.93,98.93 185.73,98.74 185.73,94.54 187.54,92.73 187.54,81.89 186.48,80.83 186.48,72.81 187.06,72.22 187.06,68.03 187.58,67.51 187.58,66.79 189.32,65.05 189.32,56.51 203.66,42.16 204.36,42.16 205.8,43.6 209.87,43.6 210.88,42.59 210.88,41.51 211.67,40.72 218.65,40.72 218.81,40.87 222.23,40.87 224.69,38.41 229.93,38.41 230.95,39.43 232.31,39.43 233.56,38.17 239.75,38.17 241.78,36.14 241.78,34.62 242.14,34.26 242.78,34.26 243.06,33.98 243.06,31.92 242.36,31.22 242.36,30.14 243.79,28.72 243.79,26.45 244.28,25.95 251.34,25.95 252.29,26.91 256.42,26.91 257.81,25.52 260.13,25.52 260.73,24.93 264.85,24.93 268.85,28.92 274.8,28.92 276.17,30.3 280.74,30.3 281.51,29.53 291.82,29.53 292.74,30.45 v2(295.86,30.45)
  BOTTOM w0.102: v2(295.73,17.43) 294.59,18.57 294.59,27.72 295.86,28.99 v2(295.86,30.45)
TBT_PCIE_WAKE_N: length 5.7
  TOP w0.089: UT1.W1 175.53,161.56 174.5,160.53 174.39,160.53
  TOP w0.102: RT28.2 172.31,160.91 RT10.1 171.95,160.91 171.93,160.89 171.4,160.89 v1(171.07,161.22) ; 174.39,160.53 174.35,160.53
  TOP w0.127: 174.35,160.53 173.14,160.53 172.88,160.79 RT28.2
TBT_RBIAS: length 1.2
  TOP w0.089: v2(178.71,167.05) 178.7,167.05 UT1.H6
  BOTTOM w0.127: RT25.1 179.22,167.05 v2(178.71,167.05)
TBT_RESET_N: length 48.7
  TOP w0.089: v2(177.4,167.69) 177.38,167.69 177.08,167.39 UT1.F4
  TOP w0.107: v2(170.51,164.27) 170.33,164.09 RT23.1
  IN1 w0.102: v2(177.4,167.69) 176.87,167.69 176.22,167.04 173.28,167.04 v2(170.51,164.27)
  IN3 w0.102: v2(206.74,163.27) 206.74,164.76 204.14,167.35 201.81,167.35 200.03,169.13 198.82,169.13 197.72,170.24 192.96,170.24 192.71,170.49 191.02,170.49 190.74,170.21 187.96,170.21 186.57,171.6 181.5,171.6 180.83,172.27 179.05,172.27 178.69,171.92 178.69,170.07 177.81,169.19 177.81,168.09 v2(177.4,167.69)
  BOTTOM w0.102: v2(177.4,167.69) 177.38,167.66 RT80.1 ; RT102.2 206.71,163.29 v2(206.74,163.27)
TBT_RESET_N_EC: length 278.1
  TOP w0.102: v2(297.07,28.99) v1(297.47,28.59) 297.77,28.29 299.16,28.29 299.61,27.83 299.61,25.8 300.02,25.39 300.02,25.05 299.94,24.97 UE5.15
  TOP w0.107: v2(168.65,164.22) 168.78,164.09 RT23.2
  IN4 w0.102: v2(297.07,28.99) 296.7,28.61 282.87,28.61 281.83,27.57 277.47,27.57 277.03,28.01 269.23,28.01 265.23,24.01 261.24,24.01 259.94,22.71 258.15,22.71 257.57,23.3 257.57,24.33 256.64,25.25 252.52,25.25 252.31,25.04 243.56,25.04 242.87,25.72 242.87,28.34 241.45,29.76 241.45,33.66 240.86,34.24 240.86,35.76 239.37,37.26 224.55,37.26 221.85,39.96 218.98,39.96 218.41,39.4 213.85,39.4 213.68,39.22 212.03,39.22 210.05,41.2 210.05,41.8 209.4,42.45 206.27,42.45 205.21,41.4 202.49,41.4 195.94,47.94 194.19,47.94 187.8,54.33 187.8,55.32 187.31,55.81 187.31,56.57 185.43,58.45 185.43,66.09 185.1,66.42 185.1,69.51 185.36,69.76 185.36,71.98 185.11,72.24 185.11,81.4 186.17,82.46 186.17,92.16 184.36,93.97 184.36,99.31 184.55,99.5 184.55,110.73 185.86,112.03 185.86,114.75 187.04,115.93 187.04,119.2 192.16,124.31 192.16,128.01 192.84,128.69 192.84,129.82 193.46,130.44 193.46,136.98 193.88,137.4 193.88,145.04 190.39,148.53 190.39,149.37 185.89,153.88 182.19,153.88 180.54,155.53 180.15,155.53 178.44,157.24 176.02,157.24 175.55,156.78 172.5,156.78 172.16,157.12 168.2,157.12 167.12,158.21 167.12,161.51 167.39,161.78 167.39,163.93 167.68,164.22 v2(168.65,164.22)
TBT_RSENSE: length 1.2
  TOP w0.102: UT1.J6 v2(178.71,166.41)
  BOTTOM w0.127: RT25.2 179.21,166.41 v2(178.71,166.41)
TBT_RST#_R: length 2.5
  TOP w0.089: UT1.L4 v2(177.4,165.76)
  BOTTOM w0.114: v2(177.4,165.76) 177.03,165.39 RT1.2 176.64,165.94 v1(176.27,166.31)
TBT_SRC_CFG1: length 4
  TOP w0.089: 174.45,159.61 174.45,159.7 175.39,160.64 UT1.AA1
  TOP w0.127: 174.45,159.61 174.23,159.39 174.22,159.39 174.13,159.3 174.13,159.2 173.82,158.9 v1(173.78,158.9) 173.36,158.9 173,159.26 RT11.1
TBT_SRC_HPD: length 3.5
  TOP w0.102: UT1.G1 175.69,167.08 175.32,166.71 175.32,166.51 174.69,165.87 174.69,165.05 174.1,164.46 RT4.1
TBT_SVR_IND:
  vias: v1(169.74,169.13) v2(170.44,169.51) v2(170.51,168.62)
TBT_TCK: length 25.2
  TOP w0.102: UT1.T4 v2(177.4,163.16)
  TOP w0.114: v2(171.14,156.33) 171.14,156.8 v1(171.67,157.33)
  IN3 w0.127: v2(177.4,163.16) 177.4,163.21 175.55,165.07 174.89,165.07 174.58,164.76 173.56,164.76 171.14,162.34 v2(171.14,156.33)
  BOTTOM w0.114: RT7.2 175.65,160.82 175.98,160.49 175.98,158.22 174.89,157.13 171.94,157.13 v2(171.14,156.33)
TBT_TDI: length 10
  TOP w0.089: UT1.Y4 v2(177.4,161.2)
  BOTTOM w0.107: RT9.2 173.79,154.68 v1(174.99,155.88) 177.3,158.19 177.3,161.1 v2(177.4,161.2)
TBT_TDO: length 8.3
  TOP w0.102: v2(177.41,161.84) 177.39,161.84 UT1.W4
  BOTTOM w0.107: RT6.2 174.84,156.22 v1(176.4,157.77) 176.98,158.36 176.98,161.43 177.39,161.84 v2(177.41,161.84)
TBT_TEST_EN: length 4.8
  TOP w0.089: UT1.E1 175.47,168
  TOP w0.102: 175.47,168 175.3,168 174.9,167.6 v1(173.68,167.6) 173.53,167.6 172.34,166.4 RT17.1
TBT_TEST_PWG: length 2.7
  TOP w0.102: UT1.AB5 177.99,159.95 177.99,159.89 177.99,159.43 177.29,158.73 177.29,158.48 RT18.1
TBT_TMS: length 2.7
  TOP w0.102: UT1.V4 177.08,162.18 177.39,162.49 v2(177.4,162.49)
  BOTTOM w0.102: v2(177.4,162.49) 177.4,162.44 176.91,161.95 176.7,161.95 RT8.2 v1(176.48,160.73)
TBT_TMU_CLK_OUT: length 3.3
  TOP w0.089: UT1.V2 176.16,162.24 175.46,162.24 175.06,161.84 174.39,161.84 174.39,161.85
  TOP w0.102: 174.39,161.85 T2.1 174.13,162.11 RT34.1
TBT_XTAL_25_IN: length 11.1
  TOP w0.089: UT1.D22 185.81,168.69 186.22,168.69 186.97,169.45 187.33,169.45
  TOP w0.114: YT1.1 194.14,168.91 v1(193.7,169.34) 193.41,169.64 191.08,169.64 190.84,169.88 CT37.1 190.27,169.77 187.88,169.77 187.55,169.45 187.33,169.45
TBT_XTAL_25_OUT: length 10.7
  TOP w0.089: UT1.D23 186.34,168.46 186.82,168.94 187.33,168.94
  TOP w0.114: 187.33,168.94 187.75,168.94 188.08,169.28 188.35,169.28 v1(188.57,169.28) 190.06,169.28 CT38.1 190.84,169.13 192.54,169.13 193.02,168.66 193.02,167.36 YT1.3
TBTA_CC1: length 32.9
  TOP w0.127: v1(190.31,174.23) 190.76,173.77 DT11.1
  TOP w0.203: 191.65,174.53 191.27,174.15 DT11.1
  TOP w0.381: CT112.1 203.22,166.05 v2(203.22,166.77) ; 191.65,174.53 192.29,175.17 v2(192.29,176.63)
  IN6 w0.381: v2(203.22,166.77) 203.22,167.24 203.7,167.72 203.7,169.01 206.31,171.62 206.31,172.96 205.81,173.45 202.87,173.45 201.7,174.62 198.42,174.62 198.29,174.75 197.09,174.75 194.24,177.6 193.26,177.6 v2(192.29,176.63)
  BOTTOM w0.203: UT4.L9 202.16,165.37 202.44,165.66 202.44,165.72 203.22,166.5 v2(203.22,166.77)
  BOTTOM w0.279: JUSBC1.A5 192.1,177.51 192.29,177.32 v2(192.29,176.63)
TBTA_CC2: length 30.9
  TOP w0.127: v1(204.56,167.44) 204.33,167.22 v2(204.33,166.38)
  TOP w0.254: v2(197.45,175.29) 196.9,175.84 DT12.1
  TOP w0.381: CT113.1 203.79,166.38 v2(204.33,166.38)
  IN6 w0.381: v2(204.33,166.38) 204.22,166.48 204.22,168.81 206.82,171.41 206.82,174.83 205.85,175.8 198.65,175.8 198.14,175.29 v2(197.45,175.29) 194.64,178.11 193.9,178.11 193.52,178.49 v2(193.52,178.81)
  BOTTOM w0.203: UT4.L10 202.66,165.24 202.89,165.47 202.89,165.53 203.32,165.97 203.53,165.97 203.72,166.15 203.78,166.15
  BOTTOM w0.279: v2(193.52,178.81) 193.52,178.97 193.35,179.15 JUSBC1.B5
  BOTTOM w0.381: v2(204.33,166.38) 204.1,166.15 203.78,166.15
TBTA_DEBUG1: length 2.5
  BOTTOM w0.102: UT4.L2 198.66,165.17 198.65,165.18 198.65,165.75 198.36,166.05 v1(198.36,166.43) 198.36,166.7
  BOTTOM w0.107: 198.36,166.95 198.36,166.7
  BOTTOM w0.127: 198.36,166.95 198.45,167.04 RT71.1
TBTA_DEBUG2: length 3.2
  BOTTOM w0.076: 198.07,166.66 198.07,166.06 198.41,165.72 198.41,165.07 198.41,164.88 198.66,164.63 UT4.K2
  BOTTOM w0.107: 198.07,166.66 198.07,167.08
  BOTTOM w0.127: 198.07,167.08 198.07,167.19 RT72.1
TBTA_DIG_AUD_N: length 3.2
  BOTTOM w0.076: UT4.K3 199.16,164.64 198.91,164.89 198.91,164.96 198.91,165.17 198.83,165.25 198.83,165.97 198.79,166.01 198.79,166.43 198.99,166.63 198.99,166.65 199,166.66
  BOTTOM w0.089: RT69.1 199.08,166.74 199,166.66
TBTA_DIG_AUD_P: length 2.8
  BOTTOM w0.076: UT4.L3 199.16,165.15 198.99,165.32 198.99,166.04 198.95,166.08 198.95,166.36 199.11,166.51 199.12,166.51 199.13,166.53 199.13,166.53
  BOTTOM w0.089: RT68.1 199.49,167.22 199.49,166.88 199.28,166.67 199.28,166.65 199.22,166.6 199.2,166.6 199.13,166.53
TBTA_HPD: length 64.3
  TOP w0.102: v2(177.4,165.11) UT1.M4 ; v2(202.21,159.4) v1(202.21,158.6)
  TOP w0.107: v2(168.65,163.58) 168.78,163.45 RT41.1
  IN1 w0.102: v2(168.65,163.58) 168.65,163.57 168.25,163.16 168.25,162.69 168.63,162.31 171.24,162.31 173.71,164.78 174.54,164.78 174.75,164.99 176.14,164.99 176.26,165.11 v2(177.4,165.11)
  IN3 w0.102: v2(177.4,165.11) 176.28,166.23 176.28,167.99 178.46,170.17 178.46,172.01 178.95,172.5 180.92,172.5 181.59,171.82 186.67,171.82 188.05,170.44 190.64,170.44 191.01,170.81 192.72,170.81 193.06,170.47 197.81,170.47 198.92,169.36 200.13,169.36 201.91,167.58 204.24,167.58 207.21,164.61 207.21,162.97 207.08,162.85 206.45,162.85 204.35,160.75 203.54,160.75 202.21,159.42 v2(202.21,159.4)
  BOTTOM w0.076: UT4.C10 202.66,160.97 202.41,160.72 202.41,159.78 202.21,159.58 v2(202.21,159.4)
TBTA_I2C_INT: length 54.5
  TOP w0.102: v2(177.4,166.41) UT1.J4
  TOP w0.114: RT32.2 168.78,164.72 v2(168.65,164.85)
  IN1 w0.081: v2(177.4,166.41) 177.87,166.87 177.87,168.5 177.61,168.76 176.81,168.76 175.9,167.85 170.71,167.85 169.51,166.66 168.68,166.66 168.26,166.24 168.26,165.25 v2(168.65,164.85)
  IN3 w0.127: v2(196.13,159) 196.13,159.45 198.29,161.61 198.29,163.96 198.83,164.5 198.83,167.51 197.81,168.53 197.81,169.47 197.29,170 193.29,170 192.58,169.28 191.73,169.28 191.1,169.91 179.41,169.91 178.13,168.62 178.13,167.13 v2(177.4,166.41)
  BOTTOM w0.107: 196.54,159.42 196.99,159.86 196.99,160.45 197.6,161.07 UT4.C1
  BOTTOM w0.114: 196.54,159.42 v2(196.13,159)
TBTA_I2C_SCL1_R: length 12.4
  IN6 w0.081: v2(200.4,158.62) 200.61,158.42 202.03,158.42 205.26,155.18 205.26,153.71 v2(205.46,153.51)
  BOTTOM w0.076: UT4.B5 200.12,160.57 199.91,160.36 199.91,159.59
  BOTTOM w0.114: RT57.2 205.56,154.08 205.31,153.83 205.31,153.66 v2(205.46,153.51) 205.29,153.35 205.29,153.1 205.54,152.85 RT60.2 ; v2(200.4,158.62) 200.4,159.13 199.91,159.59
TBTA_I2C_SDA1_R: length 12.2
  IN6 w0.081: v2(204.86,153.51) 205.05,153.71 205.05,155.1 201.94,158.21 200.58,158.21 v2(200.41,158.03)
  BOTTOM w0.114: UT4.A5 200.16,159.67 200.81,159.02 200.81,158.44 v2(200.41,158.03) ; RT59.2 204.83,152.85 205.05,153.07 205.05,153.32 v2(204.86,153.51) 205.06,153.72 205.06,153.88 204.86,154.08 RT58.2
TBTA_LDO_BMC: length 4.2
  BOTTOM w0.089: 196.22,162 196.49,162.27 v1(196.49,162.69)
  BOTTOM w0.102: 196.22,162 195.97,161.75 CT98.1
  BOTTOM w0.203: CT98.1 196.06,161.26 196.76,161.96 197.12,161.96 197.14,161.94 197.83,161.94 197.96,162.07 UT4.E1
TBTA_LSRX: length 31.8
  TOP w0.089: UT1.A4 177.3,169.96 177.05,170.21 177.05,170.58 v2(176.91,170.72)
  IN1 w0.089: v2(199.34,166.2) 199.34,165.96 199.25,165.88 198.68,165.88 195.77,168.78 189.79,168.78 187.38,171.19 184.92,171.19 184.48,171.64 181.85,171.64 181.22,172.26 178.4,172.26 178.06,171.93 177.17,171.93 176.91,171.66 v2(176.91,170.72)
  BOTTOM w0.076: v2(199.34,166.2) 199.23,166.1 199.23,165.47 199.41,165.3 199.41,164.82 UT4.K4
  BOTTOM w0.089: RT42.1 177.71,172.24 176.91,171.44 v1(176.91,171.34) v2(176.91,170.72)
TBTA_LSTX: length 28.2
  TOP w0.089: UT1.A5 177.76,170.69 v2(178.02,170.95) 178.13,171.06 178.13,171.82 RT40.1
  IN1 w0.089: v2(178.02,170.95) 178.93,171.86 v2(180.26,171.86) 181.26,171.86 181.68,171.44 184.39,171.44 184.84,170.99 187.3,170.99 189.71,168.58 195.69,168.58 198.59,165.68 v2(199.66,165.68)
  BOTTOM w0.089: RT21.2 v2(180.26,171.86)
  BOTTOM w0.102: UT4.L4 v2(199.66,165.68)
TBTA_MRESET: length 2.4
  BOTTOM w0.076: UT4.E11 203.76,162.07 203.77,162.06
  BOTTOM w0.107: 203.77,162.06 205.1,162.06 205.42,162.38 RT63.1
TBTA_ROSC: length 4.5
  BOTTOM w0.076: UT4.G2 198.4,163.32 198.26,163.32 198.26,163.32 198.05,163.32 198.05,163.32 197.77,163.32 197.67,163.41 197.67,163.41 197.54,163.54 196.92,163.54
  BOTTOM w0.102: v1(195.18,164.69) 195.6,164.27 RT75.1
  BOTTOM w0.127: 196.92,163.54 195.73,163.54 RT75.1
TBTA_SBU1: length 28.9
  TOP w0.089: v2(194.95,175.36) 194.83,175.48 194.83,175.83 DT13.1 194.69,175.86 194.51,175.67 v2(194.51,174.72)
  IN6 w0.089: v2(202.07,166.5) 202.07,166.49 201.93,166.36 201.81,166.36 201.67,166.5 201.67,167.88 202.95,169.17 202.95,170.43 201.46,171.93 199.38,171.93 197.79,173.51 192.38,173.51 192.1,173.8 192.1,174.66 192.23,174.79 194.44,174.79 v2(194.51,174.72)
  BOTTOM w0.076: v2(202.07,166.5) 202.19,166.37 202.19,165.74 201.91,165.45 201.91,164.77 201.7,164.57 UT4.K8
  BOTTOM w0.089: JUSBC1.A8 193.6,177.43 193.24,177.07 193.24,176.11 193.49,175.86 194.57,175.86 194.95,175.48 v2(194.95,175.36)
TBTA_SBU2: length 28.9
  TOP w0.089: v2(189.65,176.44) 188.81,176.44 188.54,176.17 DT14.1 188.54,175.84 189.07,175.31 189.27,175.31 v2(189.3,175.28)
  IN4 w0.109: v2(189.65,176.44) 190.06,176.44 191.75,178.12 v2(191.75,178.85)
  IN6 w0.089: v2(189.3,175.28) 189.38,175.37 190.99,175.37 191.9,174.46 191.9,173.71 192.3,173.32 197.71,173.32 199.3,171.73 201.38,171.73 202.76,170.35 202.76,169.25 201.47,167.96 201.47,166.41 201.8,166.08 v2(201.8,165.9)
  BOTTOM w0.076: v2(201.8,165.9) 201.66,165.76 UT4.L8
  BOTTOM w0.089: JUSBC1.B8 191.85,178.95 v2(191.75,178.85)
TBTB_I2C_INT: length 5.6
  TOP w0.089: UT1.E2 176.14,167.76 175.68,167.76 175.65,167.73
  TOP w0.114: RT33.2 172.24,165.64 v1(172.84,166.24) 173.45,166.85 174.48,166.85 175.37,167.73 175.65,167.73
TMDS_C_TX0N: length 4.7
  TOP w0.089: v2(213.51,164.84) 213.36,164.69 213.36,163.63 214.11,162.88 214.11,162.63 RX31.1
  BOTTOM w0.089: CV1060.1 213.32,164.43 213.32,164.65 v2(213.51,164.84) 213.31,165.04 213.31,165.21 213.42,165.32 LV4.1 213.58,165.82 RV643.1
TMDS_C_TX0P: length 4.7
  TOP w0.089: v2(212.92,164.84) 213.11,164.65 v3(213.11,164.28) 213.11,163.53 213.86,162.78 213.86,162.63 RX32.1
  BOTTOM w0.089: CV1059.1 213.08,164.43 213.08,164.69 v2(212.92,164.84) 213.06,164.98 213.06,165.18 212.92,165.33 LV4.4 212.75,165.82 RV646.1
TMDS_C_TX1N: length 4.7
  TOP w0.089: RX35.1 216.4,162.65 216.4,162.94 215.68,163.66 215.68,164.66 v2(215.85,164.83)
  BOTTOM w0.089: RV642.1 216,165.82 LV5.1 215.83,165.28 215.71,165.16 215.71,164.97 v2(215.85,164.83) 215.72,164.7 215.72,164.42 CV1062.1
TMDS_C_TX1P: length 4.7
  TOP w0.089: RX36.1 216.16,162.65 216.16,162.84 215.44,163.56 v3(215.44,164.09) 215.44,164.65 v2(215.26,164.83)
  BOTTOM w0.089: RV639.1 215.16,165.82 LV5.4 215.33,165.29 215.45,165.17 215.45,165.02 v2(215.26,164.83) 215.48,164.61 215.48,164.38 CV1061.1
TMDS_C_TX2N: length 4.4
  TOP w0.089: v2(211.06,164.84) 210.88,164.66 210.88,163.23 211.06,163.05 211.06,162.68 RX37.1
  BOTTOM w0.089: RV645.1 211.2,165.82 LV6.1 211.03,165.29 210.9,165.16 210.9,165 v2(211.06,164.84) 210.91,164.68 210.91,164.48 CV1064.1
TMDS_C_TX2P: length 4.4
  TOP w0.089: RX38.1 210.82,162.63 210.82,162.95 210.64,163.13 v3(210.64,164.18) 210.64,164.67 v2(210.47,164.84)
  BOTTOM w0.089: CV1063.1 210.66,164.42 210.66,164.65 v2(210.47,164.84) 210.66,165.02 210.66,165.16 210.53,165.29 LV6.4 210.36,165.82 RV638.1
TMDS_C_TXCN: length 4.6
  TOP w0.089: RX33.1 218.66,162.63 218.66,163.09 218.66,163.36 218.12,163.9 218.12,164.65 v2(218.28,164.81)
  BOTTOM w0.089: RV641.1 218.38,165.82 LV3.1 218.22,165.28 218.09,165.16 218.09,164.99 v2(218.28,164.81) 218.14,164.68 218.14,164.56 218.14,164.38 CV1057.1
TMDS_C_TXCP: length 4.7
  TOP w0.089: RX34.1 218.42,162.63 218.42,163.09 218.42,163.26 v3(218.22,163.46) 217.88,163.8 217.88,164.62 v2(217.69,164.81)
  BOTTOM w0.089: CV1058.1 217.9,164.39 217.9,164.56 217.9,164.6 v2(217.69,164.81) 217.85,164.97 217.85,165.13 217.72,165.27 LV3.4 217.55,165.82 RV640.1
TMDS_CTRLCLK_R: length 16.1
  IN1 w0.076: v2(220.46,161.33) 220.66,161.54 220.66,164.4 220.35,164.7 220.35,170.28 221.2,171.12 221.2,172.99 220.86,173.33 220.09,173.33 JHDMI.15
  BOTTOM w0.089: RV651.1 v2(220.46,161.33)
TMDS_CTRLDAT_R: length 16.1
  IN1 w0.076: v2(220.23,160.75) 219.97,161.01 219.97,161.59 220.2,161.82 220.2,164.21 219.9,164.51 219.9,171.01 219.97,171.09 220.52,171.09 220.6,171.17 220.6,171.32 220.52,171.4 219.97,171.4 219.9,171.47 219.9,171.62 219.97,171.7 220.53,171.7 220.61,171.78 220.61,171.93 220.53,172.01 219.97,172.01 219.9,172.08 219.9,172.47 JHDMI.16
  BOTTOM w0.089: v2(220.23,160.75) 219.98,160.75 219.69,160.46 RV650.1
TMDS_L_TX0N: length 2.2
  BOTTOM w0.102: RV27.1 213.61,168.73 RV501.2 213.42,167.7 LV4.2 213.44,166.9 RV643.2
TMDS_L_TX0P: length 2.2
  BOTTOM w0.102: RV28.1 212.7,168.75 RV501.1 212.92,167.68 LV4.3 212.89,166.9 RV646.2
TMDS_L_TX1N: length 2.2
  BOTTOM w0.102: RV29.1 215.96,168.79 RV502.2 215.83,167.77 LV5.2 215.86,166.9 RV642.2
TMDS_L_TX1P: length 2.3
  BOTTOM w0.102: RV639.2 215.31,166.9 LV5.3 215.33,167.62 RV502.1 215.05,168.76 RV30.1
TMDS_L_TX2N: length 2.2
  BOTTOM w0.102: RV645.2 211.2,166.73 LV6.2 211.03,167.64 RV503.2 RV33.1
TMDS_L_TX2P: length 2.2
  BOTTOM w0.102: RV638.2 210.36,166.73 LV6.3 210.53,167.74 RV503.1 210.37,168.74 RV34.1
TMDS_L_TXCN: length 2.2
  BOTTOM w0.102: RV673.1 218.4,167.91 RV500.2 218.22,167.7 LV3.2 218.24,166.9 RV641.2
TMDS_L_TXCP: length 2.2
  BOTTOM w0.102: RV674.1 217.5,168.75 RV500.1 217.72,167.68 LV3.3 217.7,166.9 RV640.2
TMDS_R_TX0N: length 9.9
  IN6 w0.076: v2(213.43,170.35) 213.24,170.53 213.24,171.16 212.92,171.48 212.48,171.48 211.53,172.43 211.53,172.94 211.91,173.32 215.49,173.32 215.72,173.55 215.72,173.9 JHDMI.9
  BOTTOM w0.089: v2(213.43,170.35) 213.28,170.2 213.28,169.97 RV27.2
TMDS_R_TX0P: length 9.9
  IN6 w0.076: JHDMI.7 215.49,173.92 215.49,173.64 215.4,173.55 211.82,173.55 211.3,173.04 211.3,172.34 212.39,171.26 212.83,171.26 213.02,171.07 213.02,170.53 v2(212.84,170.35)
  BOTTOM w0.089: v2(212.84,170.35) 213.04,170.15 213.04,170.01 RV28.2
TMDS_R_TX1N: length 3.9
  BOTTOM w0.089: RV29.2 215.63,170.03 215.63,170.64 214.24,172.03 214.24,172.37 JHDMI.6
TMDS_R_TX1P: length 3.9
  BOTTOM w0.089: RV30.2 215.39,170.02 215.39,170.54 213.98,171.95 213.98,172.39 JHDMI.4
TMDS_R_TX2N: length 6
  BOTTOM w0.089: RV33.2 210.96,170.01 210.96,172.43 211.84,173.32 212.38,173.32 212.67,173.61 212.67,173.85 JHDMI.3
TMDS_R_TX2P: length 5.9
  BOTTOM w0.089: RV34.2 210.71,170 210.71,172.53 211.74,173.56 212.28,173.56 212.43,173.71 212.43,173.99 JHDMI.1
TMDS_R_TXCN: length 3.7
  BOTTOM w0.089: RV673.2 218.07,170 218.07,170.67 217.24,171.51 217.24,172.37 JHDMI.12
TMDS_R_TXCP: length 3.7
  BOTTOM w0.089: JHDMI.10 216.99,172.38 216.99,171.42 217.83,170.57 217.83,170 RV674.2
TMDS_SCLF: length 4.1
  BOTTOM w0.114: RV649.1 216.54,160.79 217.16,161.4 QV96.3 218.05,161.56 RV651.2
TMDS_SDAF: length 4.3
  BOTTOM w0.114: RV653.1 214.95,159.66 QV96.6 215.86,160.3 216.01,160.46 RV650.2
TMDS_TX0N: length 82.1
  IN1 w0.076: v2(231.17,112.55) 231.17,112.66 230.81,113.02 230.81,113.53 230.72,113.63 230.72,116.61 230.05,117.27 230.05,120.74 225.75,125.04 217.65,125.04 216.65,126.03 211.96,126.03 210.07,127.92 208.23,127.92 207.94,128.21 207.94,129.22 208.81,130.09 208.81,141.43 207.77,142.47 206.5,142.47 205.68,143.29 205.68,146.23 209.24,149.79 209.24,154.25 209.55,154.55 209.55,158.21 209.09,158.66 209.09,163.65 209.77,164.33 213.49,164.33 213.96,163.86 214.35,163.86 214.45,163.95 v2(214.45,164.13)
  BOTTOM w0.089: CV1060.2 213.29,163.49 213.29,163.36 213.33,163.32 213.94,163.32 214.05,163.42 214.05,163.56 214.45,163.96 v2(214.45,164.13)
  BOTTOM w0.101: UG9.BF18 v2(231.17,112.55)
TMDS_TX0P: length 82
  IN1 w0.076: v2(231.17,113.25) 231.17,113.01 231.25,112.94 231.49,112.94 231.56,113.01 231.56,113.36 231.28,113.64 231.02,113.64 230.94,113.72 230.94,116.7 230.27,117.37 230.27,120.84 225.85,125.27 217.74,125.27 216.75,126.26 212.05,126.26 210.17,128.14 208.32,128.14 208.16,128.3 208.16,129.13 209.03,130 209.03,141.52 207.86,142.69 206.6,142.69 205.91,143.38 205.91,146.14 209.46,149.7 209.46,154.16 209.77,154.46 209.77,158.3 209.32,158.76 209.32,163.56 209.86,164.1 213.39,164.1 213.86,163.63 214.25,163.63 214.45,163.43 v2(214.45,163.39)
  BOTTOM w0.089: v2(214.45,163.39) 214.36,163.39 214.04,163.08 213.23,163.08 213.12,163.19 213.11,163.19 212.99,163.32 212.99,163.61 CV1059.2
  BOTTOM w0.101: UG9.BG18 v2(231.17,113.25)
TMDS_TX1N: length 81.3
  IN1 w0.076: v2(231.97,113.25) 231.97,113.3 231.54,113.73 231.54,114.09 231.78,114.33 231.78,114.59 231.97,114.78 231.97,117.47 230.73,118.71 230.73,121.03 226.04,125.72 218.23,125.72 216.8,127.16 212.46,127.16 209.89,129.73 209.89,141.81 208.55,143.15 206.84,143.15 206.36,143.63 206.36,145.95 209.93,149.52 209.93,153.74 210.25,154.06 210.25,155.83 210.69,156.27 210.69,158.05 209.77,158.97 209.77,161.7 210.13,162.06 210.13,163.3 210.47,163.64 213.16,163.64 213.84,162.96 214.74,162.96 215.4,163.62 216.77,163.62 216.85,163.7 v2(216.85,163.8)
  BOTTOM w0.089: v2(216.85,163.8) 216.85,163.54 216.76,163.45 216.67,163.45 216.51,163.29 215.83,163.29 215.74,163.38 215.74,163.51 CV1062.2
  BOTTOM w0.101: UG9.BG20 232.27,113.07 232.09,113.25 v2(231.97,113.25)
TMDS_TX1P: length 81.4
  IN1 w0.076: v2(216.84,163.05) 216.91,163.12 216.91,163.32 216.83,163.4 215.5,163.4 214.83,162.74 213.75,162.74 213.07,163.42 210.56,163.42 210.35,163.21 210.35,161.97 210,161.61 210,159.06 210.92,158.15 210.92,156.18 210.47,155.73 210.47,153.97 210.16,153.65 210.16,149.43 206.59,145.86 206.59,143.72 206.93,143.37 208.65,143.37 210.11,141.91 210.11,129.82 212.55,127.38 216.89,127.38 218.33,125.95 226.13,125.95 230.95,121.12 230.95,118.8 232.2,117.56 232.2,114.69 232,114.49 232,114.39 232.29,114.1 232.29,113.69 232.21,113.61 231.98,113.61 231.9,113.69 v2(231.9,113.93)
  BOTTOM w0.089: v2(216.84,163.05) 215.73,163.05 215.5,163.28 215.5,163.5 CV1061.2
  BOTTOM w0.101: v2(231.9,113.93) 231.94,113.89 232.03,113.89 UG9.BH20
TMDS_TX2N: length 74.9
  IN1 w0.076: v2(212.12,162.92) 212.12,162.71 211.99,162.58 211.71,162.58 211.51,162.37 211.51,161.66 211.71,161.46 212.62,161.46 212.7,161.38 212.7,160.02 213.03,159.7 213.03,158.69 212.61,158.28 212.61,154.6 210.92,152.91 210.92,151.7 211.24,151.39 211.24,149.1 209.36,147.21 209.36,143.49 210.57,142.28 210.57,130.01 212.59,127.98 217.24,127.98 218.82,126.4 226.32,126.4 231.76,120.96 231.76,118.99 232.58,118.18 232.58,111.83 232.48,111.73 232.19,111.73 v2(231.97,111.95)
  BOTTOM w0.089: CV1064.2 210.87,163.48 210.87,163.23 211.68,162.42 211.93,162.42 212.15,162.64 212.15,162.9 v2(212.12,162.92)
  BOTTOM w0.101: UG9.BF20 v2(231.97,111.95)
TMDS_TX2P: length 74.9
  IN1 w0.076: v2(212.12,162.07) 212.12,162.28 212.05,162.35 211.81,162.35 211.73,162.28 211.73,161.76 211.81,161.68 212.72,161.68 212.92,161.47 212.92,160.11 213.25,159.79 213.25,158.6 212.84,158.19 212.84,154.5 211.15,152.81 211.15,151.8 211.46,151.48 211.46,149 209.58,147.12 209.58,143.58 210.79,142.37 210.79,130.1 212.69,128.21 217.34,128.21 218.92,126.63 226.41,126.63 231.98,121.06 231.98,119.09 232.8,118.27 232.8,111.73 232.57,111.5 232.22,111.5 v2(231.97,111.25)
  BOTTOM w0.089: v2(212.12,162.07) 212.01,162.18 211.58,162.18 210.63,163.13 210.63,163.59 CV1063.2
  BOTTOM w0.101: UG9.BE20 v2(231.97,111.25)
TMDS_TXCN: length 91
  IN1 w0.076: v2(219.49,163.58) 219.41,163.5 218.17,163.5 216.22,165.46 209.27,165.46 208.19,164.38 208.19,163.5 208.41,163.28 208.41,158.3 208.87,157.85 208.87,154.99 208.56,154.68 208.56,150.07 205,146.52 205,142.96 206.17,141.79 207.49,141.79 208.13,141.15 208.13,130.37 207.26,129.5 207.26,127.82 207.84,127.24 209.32,127.24 210.38,126.18 210.84,126.18 211.71,125.32 212.57,125.32 213.1,124.78 216.9,124.78 217.32,124.36 225.47,124.36 229.37,120.46 229.37,115.67 230.33,114.71 230.33,111.83 230.21,111.71 229.99,111.71 229.87,111.84 v2(229.87,111.95)
  BOTTOM w0.089: v2(219.49,163.58) 219.49,163.52 219.38,163.41 219.2,163.41 218.87,163.09 218.18,163.09 218.09,163.18 218.09,163.43 218.29,163.64 CV1057.2
  BOTTOM w0.101: UG9.BF17 v2(229.87,111.95)
TMDS_TXCP: length 91
  IN1 w0.076: v2(219.36,163.01) 219.36,163.07 219.16,163.28 218.08,163.28 216.12,165.23 209.36,165.23 208.42,164.29 208.42,163.6 208.64,163.37 208.64,158.4 209.09,157.94 209.09,154.9 208.78,154.59 208.78,149.98 205.23,146.42 205.23,143.05 206.26,142.01 207.58,142.01 208.35,141.24 208.35,130.28 207.48,129.41 207.48,127.92 207.94,127.46 209.42,127.46 210.47,126.41 210.94,126.41 211.8,125.54 212.66,125.54 213.2,125.01 216.99,125.01 217.42,124.58 225.56,124.58 229.59,120.55 229.59,115.76 230.55,114.8 230.55,111.74 230.31,111.49 229.97,111.49 229.87,111.39 v2(229.87,111.25)
  BOTTOM w0.089: CV1058.2 217.85,163.54 217.85,163.08 218.08,162.85 v3(218.63,162.85) 218.97,162.85 219.14,163.01 v2(219.36,163.01)
  BOTTOM w0.101: UG9.BE17 v2(229.87,111.25)
TOBII_INT: length 308.7
  TOP w0.102: RE651.2 316.72,20.76 316.72,22.46 316.52,22.66 314.69,22.66 v1(311.97,25.38) v2(311.39,25.38) ; JTOBII.6 158.56,164.89 v2(158.23,164.56) RE300.1
  IN2 w0.102: v2(286.2,25.37) 286.69,24.89 289.14,24.89 293.32,20.71 297.4,20.71 297.77,21.08 298.11,21.08 298.57,20.63 301.58,20.63 303.49,22.53 306.49,22.53 307.73,23.77 308.23,23.77 308.87,24.41 308.87,25.12 309.5,25.74 311.03,25.74 v2(311.39,25.38)
  IN4 w0.102: v2(286.2,25.37) 286.2,25.03 284.74,23.57 280.58,23.57 279.53,22.51 271.08,22.51 270.18,21.61 266.3,21.61 265.22,20.53 257.32,20.53 256.28,21.57 254,21.57 252.85,22.73 241.82,22.73 238.38,26.17 238.38,30.3 237.84,30.83 237.84,33.43 236.42,34.86 232.53,34.86 232.38,35.01 225.22,35.01 223.52,33.31 218.77,33.31 218.75,33.34 216.96,33.34 215.53,34.77 212.57,34.77 211.72,35.62 211.72,37.39 210.24,38.87 203.78,38.87 203.16,39.48 201.71,39.48 201.43,39.76 201.43,41.16 200.57,42.02 199.62,42.02 198.35,43.29 191.75,43.29 189.43,45.61 189.43,51.41 184.06,56.78 184.06,65.52 183.11,66.47 183.11,68.77 183.35,69 183.35,69.71 183.99,70.35 183.99,71.41 183.73,71.67 183.73,81.97 184.79,83.03 184.79,91.59 182.15,94.24 182.15,106.46 183.18,107.49 183.18,114.98 184.51,116.31 184.51,118.61 190.78,124.88 190.78,140.27 191.45,140.94 191.45,145.39 184.33,152.51 181.62,152.51 180.97,153.16 172.25,153.16 171.59,153.82 169.34,153.82 168.38,154.78 168.38,155 165.71,157.68 165.71,159.84 160.98,164.56 v2(158.23,164.56)
TOBII_PWR_EN#: length 366.8
  TOP w0.102: v2(329.87,46.2) 330.54,45.52 UE6.17 ; CE79.1 144.8,166.15 144.45,165.8 RE652.2 144.51,165.45 UE12.4 146.44,165.45 146.82,165.07 v1(146.82,161.61) 146.82,161.07 v2(146.41,160.66)
  IN3 w0.102: v2(329.87,46.2) 329.46,45.79 329.46,40.48 328.53,39.55 328.53,37.02 327.45,35.94 327.45,33.28 323.41,29.24 323.41,25.87 322.97,25.43 322.95,25.43 321.61,24.09 321.61,19.61 321.06,19.06 321.06,18.27 317.06,14.27 v2(317.06,13.91)
  IN4 w0.102: v2(146.41,160.66) 147.01,161.26 156.89,161.26 158.69,159.46 161.96,159.46 161.99,159.43 163.11,159.43 164.11,158.43 164.11,154.9 165.41,153.6 167.31,153.6 168.68,152.22 170.92,152.22 172.65,150.5 184.08,150.5 189.18,145.39 189.18,125.54 181.58,117.94 181.58,108.15 180.55,107.12 180.55,95.69 177.1,92.24 177.1,81.64 179.51,79.23 179.51,73.51 181.1,71.92 181.1,69.05 180.92,68.87 180.92,64.43 181.71,63.65 181.71,59.43 182.46,58.68 182.46,56.12 187.79,50.78 187.79,44.98 191.91,40.86 197.75,40.86 198.33,40.28 198.33,39.74 198.96,39.12 200.19,39.12 200.59,38.71 200.59,37.48 201.44,36.64 201.44,32.37 201.82,31.99 202.24,31.99 203.03,31.19 203.03,31.12 203.43,30.73 207.25,30.73 207.83,30.14 208.5,30.14 208.52,30.16 218.37,30.16 219.04,29.49 226.09,29.49 227.69,31.1 227.69,32.06 228.46,32.82 229.39,32.82 230.94,31.27 232.57,31.27 234.62,29.22 235.11,29.22 235.35,28.98 235.35,26.16 240.01,21.5 240.01,19.22 242.85,16.38 245.13,16.38 246.6,14.92 247.31,14.92 248.2,14.03 254.41,14.03 254.67,14.28 258.68,14.28 262.86,18.46 266.07,18.46 266.54,17.99 267.65,17.99 268.64,17 278.75,17 280.29,18.54 289.96,18.54 291.96,16.54 295.12,16.54 295.69,15.97 300.11,15.97 301.28,14.8 304.9,14.8 305.13,14.57 306.37,14.57 307.45,13.49 312.26,13.49 312.68,13.91 v2(317.06,13.91)
TON_1.2V: length 1.9
  BOTTOM w0.203: PR206.2 94.89,43.6 PU201.9
TP_CLK: length 125.9
  TOP w0.102: UE5.87 301.94,7.3 302.06,7.18 302.06,6.78 v2(301.94,6.66) 302.1,6.49 302.1,5.99 RE100.2
  IN1 w0.102: v2(301.94,6.66) 302.27,6.33 302.27,5.45 302.01,5.19 299.79,5.19 295.98,8.99 295.98,11.07 295.07,11.98 292.6,11.98 291.4,13.19 273.47,13.19 271.29,11.02 255.16,11.02 254.39,11.79 242.55,11.79 240.61,9.85 230.56,9.85 229.92,9.21 208,9.21 206.57,7.78 192.08,7.78 191.93,7.92 191.93,8.07 v2(192.27,8.4)
  BOTTOM w0.107: JTP.12 191.32,10.3 191.19,10.17 191.19,9.82 192.08,8.93 192.08,8.58 v2(192.27,8.4)
TP_DATA: length 126.4
  TOP w0.102: RE101.2 302.33,6.02 302.33,6.47 v2(302.52,6.66) 302.34,6.84 UE5.88
  IN1 w0.102: v2(302.52,6.66) 302.5,6.63 302.5,5.35 302.1,4.96 299.69,4.96 295.75,8.9 295.75,10.97 294.97,11.75 292.51,11.75 291.3,12.96 273.56,12.96 271.39,10.79 255.06,10.79 254.29,11.56 242.64,11.56 240.7,9.62 230.65,9.62 230.02,8.99 208.1,8.99 206.66,7.55 191.98,7.55 191.7,7.83 191.7,8.38 v2(191.68,8.4)
  BOTTOM w0.107: JTP.13 190.82,10.3 190.95,10.17 190.95,9.72 191.85,8.83 191.85,8.57 v2(191.68,8.4)
TP_LED_B#: length 234.3
  TOP w0.127: v1(113.13,25.94) 113.13,25.33 v2(112.98,25.18)
  TOP w0.254: UE3.14 v2(232.8,159.36)
  TOP w0.432: v2(112.98,25.18) 113.18,25.18 113.53,24.82 Q28.5
  TOP w0.508: v2(112.98,25.18) 112.25,25.18 111.82,24.75 R146.2
  IN2 w0.508: v2(182.79,97.19) 182.53,97.19 182.02,97.7 182.02,102.91 184.27,105.16 184.27,112.87 186.42,115.02 186.42,121.68 190.77,126.04 190.77,127.68 193.99,130.91 193.99,133.77 194.72,134.5 196.01,134.5 197.48,135.97 197.48,140.42 207.68,150.62 207.68,152.81 209.3,154.43 209.3,155.3 210.23,156.23 210.7,156.23 211.11,156.64 212.4,156.64 212.68,156.92 212.68,157.44 213.08,157.83 214.14,157.83 215.04,156.93 216.73,156.93 217.36,157.56 218.07,157.56 218.46,157.96 222.53,157.96 223.22,158.66 225.19,158.66 225.89,159.36 v2(232.8,159.36)
  IN3 w0.508: v2(112.98,25.18) 115.96,28.16 167.66,28.16 170.73,31.23 170.73,38.01 171.17,38.45 172.15,38.45 174.13,40.43 174.13,51.47 173.85,51.75 173.85,72.66 176.73,75.54 176.73,92.63 181.28,97.19 v2(182.79,97.19)
TP_LED_B#_DRV: length 5.1
  TOP w0.102: Q28.3 114.18,22.79 113.95,23.02 113.67,23.02 113.53,22.88 Q28.2 113.53,22.03 113.42,21.91 112.47,21.91 R144.2 111.4,22.56 v1(110.93,23.03)
TP_LED_B#_DRV#: length 98.3
  TOP w0.102: Q28.6 112.88,23.82 112.99,23.72 114.47,23.72 116.44,25.69 v1(121.1,25.69) 123.83,25.69 v2(124.2,26.06)
  IN1 w0.508: v2(195.91,12.64) 196.12,12.64 196.63,13.15 196.63,14.09 192.1,18.62 192.1,19.34 191.48,19.95 189.98,19.95 185.17,24.76 185.17,27.16 182.97,29.36 127.51,29.36 v2(124.2,26.06)
  BOTTOM w0.305: v2(195.91,12.64) 195.82,12.56 JTP.3
TP_LED_EN: length 152.6
  TOP w0.127: UE5.25 295.94,20.05 v2(295.66,19.78) ; v2(195.84,18.84) 196.11,18.58 Q2410.2
  IN2 w0.127: v2(195.84,18.84) 195.78,18.84 191.89,14.95 186.36,14.95 v2(186.06,14.66) ; v2(216.86,9.62) 217.47,10.23 232.55,10.23 233.16,10.84 241.06,10.84 242.53,9.37 254.07,9.37 255.82,11.12 259.49,11.12 260.1,11.73 266.93,11.73 267.22,11.44 276.41,11.44 279.69,8.16 279.69,5.07 280.22,4.54 v2(288.05,4.54)
  IN3 w0.127: v2(288.05,4.54) 288.78,5.27 288.78,9.16 288.17,9.77 288.17,17.81 289.19,18.83 295.1,18.83 295.66,19.39 v2(295.66,19.78)
  IN4 w0.127: v2(186.06,14.66) 186.06,12.16 189.05,9.18 193.75,9.18 194.89,8.03 206.45,8.03 207.37,8.95 216.19,8.95 v2(216.86,9.62)
TP_LED_G#: length 226.6
  TOP w0.127: v1(233.28,158.22) 232.76,157.7 v2(232.67,157.7)
  TOP w0.254: v2(232.67,157.7) 232.52,157.86 UE3.11
  TOP w0.508: R154.2 117.09,24.75 117.52,25.18 v2(118.06,25.18) 118.36,25.18 118.87,24.67 Q29.5
  IN2 w0.508: v2(182.79,96.55) 183.05,96.55 184.45,97.95 184.45,102.15 185.54,103.24 185.54,112.35 187.69,114.49 187.69,121.16 192.04,125.51 192.04,127.16 194.47,129.59 194.98,129.59 196.03,130.65 196.03,132.73 198.75,135.45 198.75,139.9 208.95,150.09 208.95,151.85 211.21,154.11 214.13,154.11 214.98,154.96 223.24,154.96 225.52,157.25 226.76,157.25 227.5,156.5 231.02,156.5 232.23,157.7 v2(232.67,157.7)
  IN3 w0.508: v2(118.06,25.18) 120.4,27.53 167.92,27.53 172.28,31.89 172.28,37.69 175.97,41.37 175.97,45.81 176.39,46.23 176.39,52.48 175.59,53.29 175.59,56.29 174.48,57.4 174.48,72.4 177.36,75.28 177.36,92.37 181.55,96.55 v2(182.79,96.55)
TP_LED_G#_DRV: length 6
  TOP w0.102: R150.2 116.15,22.13 v1(116.53,21.75) 118.69,21.75 118.87,21.93 Q29.2 118.87,22.82 119.01,22.96 119.39,22.96 119.52,22.83 Q29.3
TP_LED_G#_DRV#: length 90.7
  TOP w0.381: Q29.6 118.22,24.04 118.6,23.65 v1(121.64,23.65) 122.7,23.65 v2(125.1,26.06)
  IN1 w0.508: v2(195.27,12.68) 195.27,13.03 190.47,17.84 189.1,17.84 184.54,22.4 184.54,26.9 182.7,28.73 127.77,28.73 v2(125.1,26.06)
  BOTTOM w0.305: v2(195.27,12.68) 195.32,12.63 JTP.4
TP_LED_R#: length 236.2
  TOP w0.127: v2(111.29,25.11) v1(111.29,25.9)
  TOP w0.254: v2(233.5,157.7) 232.97,157.18 232.44,157.18 232.26,157.36 UE3.10
  TOP w0.432: R147.2 108.76,23.55 108.39,23.92 Q34.5
  TOP w0.508: R147.2 110.52,23.55 110.94,23.97 110.94,24.77 v2(111.29,25.11)
  IN2 w0.508: v2(233.5,157.7) 233.5,157.83 232.86,158.46 230.7,158.46 230.12,157.88 223.35,157.88 222.79,157.32 219.06,157.32 218.66,156.93 217.62,156.93 216.99,156.29 215.72,156.29 215.02,155.59 213.17,155.59 212.81,155.95 211.32,155.95 210.97,155.59 210.52,155.59 209.94,155.01 209.94,154.17 208.31,152.54 208.31,150.36 198.12,140.16 198.12,135.71 196.27,133.86 194.99,133.86 194.63,133.51 194.63,130.64 191.41,127.42 191.41,125.77 187.05,121.42 187.05,114.76 184.91,112.61 184.91,103.5 183.82,102.41 183.82,99.04 v2(182.79,98.01)
  IN3 w0.508: v2(182.79,98.01) 181.21,98.01 176.09,92.9 176.09,75.81 173.21,72.92 173.21,62.81 172.28,61.88 172.28,59.91 171.59,59.21 171.59,51.66 170.09,50.16 170.09,31.49 167.39,28.8 114.97,28.8 v2(111.29,25.11)
TP_LED_R#_DRV: length 4.1
  TOP w0.102: Q34.2 108.39,21.66 108.55,21.5 v1(108.66,21.5) 108.84,21.5 109.04,21.7 Q34.3 109.04,22.96 109.17,23.08 109.52,23.08 R145.2
TP_LED_R#_DRV#: length 103.7
  TOP w0.102: v2(126,26.06) v1(121.47,21.53) 120.99,21.05 108.53,21.05 107.26,22.32 107.26,22.89 107.74,23.37 Q34.6
  IN1 w0.508: v2(126,26.06) 128.04,28.09 182.44,28.09 183.9,26.63 183.9,22.14 189.18,16.86 190.39,16.86 v2(194.64,12.61)
  BOTTOM w0.305: v2(194.64,12.61) 194.82,12.43 JTP.5
TRIP_+1VALWP: length 4.1
  TOP w0.102: v1(241.6,20.44) 241.54,20.38 241.54,20.38 241.09,19.93 241.09,18.9 241.56,18.43 PR303.2
  TOP w0.254: PR303.2 242.57,18.43 242.63,18.49 PU300.2
TRONL_LED_B_DRV#: length 314.9
  TOP w0.102: v2(36.2,51.75) 35.89,52.06 v1(35.33,52.06) ; v2(307.35,29.29) 306.71,29.93 306.71,31.56 307.22,32.06 UE8.5
  IN2 w0.102: v2(307.35,29.29) 306.5,28.44 305.27,28.44 303.54,26.71 297.66,26.71 296.18,28.2 293.39,28.2 290.67,30.92 287.78,30.92 287.33,31.36 285.87,31.36 283.48,33.75 277.07,33.75 275.83,34.99 275.72,34.99 273.54,37.17 273.54,38.97 268.26,44.25 255.92,44.25 251.38,48.8 241.6,48.8 241.48,48.69 236.61,48.69 230.63,42.7 225.8,42.7 224.32,44.19 224.32,45.15 223.54,45.92 223.54,47.94 222.79,48.69 211.58,48.69 207.21,53.05 202.23,53.05 201.04,51.87 185.62,51.87 182.71,48.95 180.17,48.95 178.88,47.66 175.03,47.66 174.57,48.12 173.14,48.12 172.21,49.05 172.21,50.71 171.92,50.99 109.91,50.99 107.89,48.98 97.8,48.98 97.53,49.25 93.64,49.25 93.31,48.92 86.24,48.92 85.8,49.37 83.64,49.37 81.64,47.36 68.03,47.36 66.27,49.13 58.27,49.13 57.8,48.66 46.29,48.66 44.91,50.04 37.91,50.04 v2(36.2,51.75)
  BOTTOM w0.102: JTRONL.5 40.27,48.14 40.1,47.98 36.46,47.98 36.27,48.16 JTRONL.10
  BOTTOM w0.107: JTRONL.10 36.27,50.07 36.62,50.42 36.62,51.33 v2(36.2,51.75)
TRONL_LED_G_DRV#: length 304.1
  TOP w0.102: UE8.4 306.72,32.17 305.76,31.21 305.76,30.56 v1(306.2,30.12) 306.76,29.55 v2(306.76,29.29)
  IN2 w0.102: v2(306.76,29.29) 306.36,29.7 305.4,29.7 303.56,27.86 297.17,27.86 296.37,28.65 293.58,28.65 290.86,31.38 287.97,31.38 287.52,31.82 286.06,31.82 283.67,34.21 277.26,34.21 276.02,35.45 275.91,35.45 274,37.36 274,39.16 268.45,44.71 256.11,44.71 251.57,49.26 241.41,49.26 241.3,49.14 234.57,49.14 233.09,47.67 233.09,46.41 231.59,44.91 225.19,44.91 224,46.11 224,48.15 223.01,49.14 211.77,49.14 207.4,53.51 202.04,53.51 200.85,52.32 184.37,52.32 181.71,49.66 180.24,49.66 178.69,48.12 175.22,48.12 174.01,49.33 173.09,49.33 172.67,49.76 172.67,50.9 172.11,51.45 109.72,51.45 107.7,49.44 97.99,49.44 97.48,49.94 93.06,49.94 92.49,49.38 86.58,49.38 86.09,49.87 83.49,49.87 82.49,48.86 67.18,48.86 66.46,49.58 58.08,49.58 57.62,49.11 47.22,49.11 45.81,50.53 42.62,50.53 42.04,51.11 41.46,51.11 v2(41.07,50.73)
  BOTTOM w0.102: 41.07,50.13 v2(41.07,50.73)
  BOTTOM w0.107: JTRONL.9 37.07,50.68 37.73,51.34 40.46,51.34 v2(41.07,50.73) ; JTRONL.4 41.07,50.13
TRONL_LED_R_DRV#: length 302.7
  TOP w0.102: v2(306.18,29.29) 306.18,29.65 305.44,30.39 305.44,31.4 306.22,32.17 v1(306.22,32.26) UE8.3
  IN2 w0.102: v2(306.18,29.29) 305.56,28.67 305.18,28.67 303.45,26.94 297.76,26.94 296.27,28.43 293.48,28.43 290.76,31.15 287.87,31.15 287.43,31.59 285.96,31.59 283.58,33.98 277.17,33.98 275.93,35.22 275.82,35.22 273.77,37.27 273.77,39.07 268.35,44.48 256.02,44.48 251.47,49.03 241.5,49.03 241.39,48.91 234.66,48.91 233.32,47.57 233.32,46.32 231.69,44.69 225.1,44.69 223.77,46.02 223.77,48.03 222.89,48.91 211.67,48.91 207.31,53.28 202.14,53.28 200.95,52.09 184.47,52.09 181.81,49.44 180.33,49.44 178.79,47.89 175.13,47.89 173.92,49.1 173,49.1 172.44,49.66 172.44,50.8 172.02,51.22 109.81,51.22 107.8,49.21 97.89,49.21 97.39,49.71 93.15,49.71 92.59,49.15 86.48,49.15 86,49.64 83.59,49.64 82.58,48.63 67.09,48.63 66.37,49.35 58.18,49.35 57.71,48.89 46.39,48.89 44.98,50.3 42.28,50.3 v2(41.87,50.71) 41.74,50.71 41.36,50.32 40.59,50.32 39.82,51.09 38.25,51.09 v2(37.87,50.71)
  BOTTOM w0.107: JTRONL.8 v2(37.87,50.71) ; JTRONL.3 v2(41.87,50.71)
TRONR_LED_B_DRV#: length 45.6
  TOP w0.102: v2(309.09,30.93) 310.08,30.93 310.4,31.25 310.4,34.16 310.08,34.48 UE8.9
  TOP w0.107: v2(279.58,28.23) v1(279.58,29.13) 279.58,29.87 279.48,29.98 278.81,29.98 v2(278.27,29.43)
  IN1 w0.102: v2(309.09,30.93) 308.48,30.32 305.89,30.32 304.95,31.26 298.85,31.26 298.62,31.48 292.48,31.48 289.75,28.75 280.1,28.75 v2(279.58,28.23)
  BOTTOM w0.107: JTRONR.5 277.97,29.73 v2(278.27,29.43) ; JTRONR.10 281.97,29.29 281.86,29.18 280.54,29.18 v2(279.58,28.23)
TRONR_LED_G_DRV#: length 41.3
  TOP w0.102: v2(308.05,30.93) 308.72,31.6 v1(308.72,31.86) UE8.8
  IN1 w0.102: v2(279,28.23) 279.76,28.99 289.38,28.99 292.1,31.71 298.72,31.71 298.94,31.49 307.48,31.49 v2(308.05,30.93)
  BOTTOM w0.102: 281.17,30.39 281.17,29.58 281,29.41 280.18,29.41
  BOTTOM w0.107: JTRONR.9 281.17,30.39 ; 280.18,29.41 v2(279,28.23) 278.3,28.92 277.27,28.92 277.17,29.03 JTRONR.4
TRONR_LED_R_DRV#: length 48.6
  TOP w0.102: v2(295.82,36.48) 297.35,34.95 297.35,32.7 299.89,30.16 301.67,30.16 303.6,28.23 v1(305.76,28.23) 307.29,28.23 307.76,28.7 307.76,29.53 306.94,30.35 306.94,31.46 307.72,32.24 UE8.6
  IN1 w0.102: v2(279.15,31.72) 279.45,31.43 287.52,31.43 290.95,34.86 290.95,35.66 291.96,36.66 295.64,36.66 v2(295.82,36.48)
  BOTTOM w0.107: JTRONR.3 276.37,31.47 277.39,32.49 278.38,32.49 v2(279.15,31.72) 280.11,31.72 280.37,31.46 JTRONR.8
TS_EN: length 342.5
  TOP w0.102: v2(168.79,171.61) 169.02,171.84 169.02,172.51 167.93,173.61 167.93,177.67 168.12,177.86 JEDP.34 ; v1(331.67,46.96) v2(331.67,46.2) 332.04,45.83 UE6.14
  IN4 w0.102: v2(331.67,46.2) 330.97,46.9 329.37,46.9 328.81,46.34 328.81,42.51 331.26,40.06 331.26,39.55 332.9,37.91 332.9,34.75 331.59,33.43 326.47,33.43 324.16,31.12 311.77,31.12 311.17,30.52 299.23,30.52 298.2,29.5 296.49,29.5 295.83,28.84 277.67,28.84 277.07,28.24 269.14,28.24 265.14,24.24 261.14,24.24 259.84,22.94 258.25,22.94 257.79,23.4 257.79,24.57 256.14,26.22 252.57,26.22 251.62,25.27 243.8,25.27 243.1,25.97 243.1,28.44 241.68,29.86 241.68,33.75 241.09,34.34 241.09,35.86 239.47,37.48 224.65,37.48 221.94,40.19 218.94,40.19 218.33,39.59 213.77,39.59 213.6,39.41 212.16,39.41 211.16,40.42 210.24,41.33 210.24,41.93 209.49,42.68 206.17,42.68 205.08,41.59 202.62,41.59 196.03,48.17 194.28,48.17 188.03,54.42 188.03,55.41 187.54,55.91 187.54,56.67 185.66,58.54 185.66,66.19 185.33,66.52 185.33,69.41 185.59,69.67 185.59,72.08 185.33,72.33 185.33,81.3 186.39,82.36 186.39,92.26 184.59,94.06 184.59,99.21 184.78,99.41 184.78,110.63 186.09,111.94 186.09,114.65 187.27,115.83 187.27,119.1 192.39,124.22 192.39,127.91 193.07,128.6 193.07,129.72 193.69,130.34 193.69,136.89 194.11,137.31 194.11,145.14 190.62,148.62 190.62,149.47 185.99,154.11 182.28,154.11 180.63,155.76 180.24,155.76 178.49,157.51 175.97,157.51 175.46,157 172.6,157 172.25,157.35 169.39,157.35 168.88,157.86 168.88,159.34 169.59,160.05 169.59,167.89 168.41,169.07 168.41,171.23 v2(168.79,171.61)
TYPEC_DET#: length 24.6
  TOP w0.102: QU1.1 296.79,62.52 RU26.2 297.99,62.52 v2(298.12,62.38) 298.12,63.38 v1(298.67,63.93) ; v2(315.71,60.67) 316.26,60.12 UE10.18
  IN6 w0.102: v2(298.12,62.38) 298.82,62.38 300.54,60.66 305.06,60.66 305.43,60.29 306.96,60.29 307.23,60.57 313.64,60.57 313.94,60.27 315.3,60.27 v2(315.71,60.67)
UART_2_CCTS_DRTS: length 9.7
  BOTTOM w0.089: UH1.AN44 210.73,17.93 210.51,17.72 210.51,17.17 210.68,17.01 211.36,17.01 212.71,15.66
  BOTTOM w0.107: 212.71,15.66 212.85,15.52 212.85,13.22 213.77,12.29 v1(214.17,12.29) 214.47,12.29 215.1,12.92 RC65.1
UART_2_CRXD_DTXD: length 18.2
  TOP w0.107: JWDB.3 203.89,11.36 203.23,12.02 203.23,13.15 203.93,13.85 208.12,13.85 208.54,14.27 208.54,14.73 209.21,15.4 209.88,15.4 210.88,16.4 v1(210.88,16.69) v2(210.88,17.37)
  BOTTOM w0.089: v2(210.88,17.37) 210.88,17.62 211.04,17.79 UH1.AR45
  BOTTOM w0.107: RC62.1 213.31,15.34 211.31,17.33 210.91,17.33 v2(210.88,17.37)
UART_2_CTXD_DRXD: length 26.8
  TOP w0.107: JWDB.2 204.69,10.9 203.46,12.12 203.46,13.05 204.02,13.61 208.22,13.61 208.78,14.17 208.78,14.64 209.3,15.16 209.95,15.16 211.3,16.5 211.3,18.28 v1(211.53,18.52) 211.72,18.7 211.72,20.44 v2(212.2,20.92) 212.07,21.05 210.96,21.05 210.77,20.87 210.77,18.36 210.46,18.04 210.46,17.31 210,16.86 209.43,16.86 208.49,15.92 RC63.1
  BOTTOM w0.107: UH1.AR39 211.72,20.44 v2(212.2,20.92)
UG_3V: length 15.9
  TOP w0.102: v2(53.48,29.43) 54.12,29.43 v1(54.35,29.66)
  IN4 w1.016: 52.9,30.7 52.9,35.4 58.16,40.65 58.16,42.09 57.16,43.09
  vias: v2(53.18,28.92) v2(55.95,44.42) v2(56.4,43.98)
UG_5V: length 7.7
  IN4 w1.016: 50.62,43.02 50.61,43.02 46.61,39.02 46.61,37.94
  BOTTOM w0.102: v1(51.38,42.34) 51.51,42.46 v2(51.51,43.21)
  vias: v2(47.06,36.93) v2(47.06,36.29) v2(51.76,43.81)
UG_+1VALWP: length 5.8
  TOP w0.102: v2(253.34,19.02) 253.26,19.02 v1(252.93,18.69)
  IN1 w1.016: 253.01,18.22 252.66,17.88 248.98,17.88 248.18,18.68
  vias: v2(247.32,19.12) v2(247.32,18.49) v2(253.25,19.6)
USB2_COMP: length 4.9
  BOTTOM w0.102: 206.86,40.97 207.28,40.55 207.28,40.35 207.43,40.2 207.43,39.21 207.48,39.17 207.48,38.7 207.75,38.42 UH1.AG3
  BOTTOM w0.114: 206.86,40.97 206.86,41.88 206.28,42.46 RH109.1
USB3_A_TRX_DTX_N0: length 22.4
  TOP w0.089: v2(186.72,172.5) 186.51,172.28 arc(186.48,172.23) 186.48,172.16 arc(186.49,172.13) 186.51,172.1 186.7,171.91 186.71,171.9 arc(186.73,171.88) 186.76,171.85 arc(186.97,171.74) 187.21,171.71 187.41,171.71 arc(187.67,171.59) 187.77,171.33 187.77,171.02 arc(187.66,170.76) 187.39,170.66 186.74,170.66 arc(186.64,170.69) 186.55,170.75 186.35,170.94 186.34,170.96 arc(186.31,171) 186.27,171.03 arc(186.11,171.1) 185.94,171.12 arc(185.75,171.08) 185.59,170.96 185.59,170.95 185.5,170.73 arc(185.49,170.71) 185.49,170.7 arc(185.46,170.5) 185.38,170.32 arc(185.38,170.31) 185.37,170.3 185.35,170.28 185.35,169.66 185.31,169.62 185.22,169.62 185.12,169.72 UT1.A21
  BOTTOM w0.089: JUSBC1.B10 190.85,179.34 arc(190.83,179.24) 190.77,179.15 arc(190.69,179.13) 190.64,179.06 190.61,178.95 arc(190.58,178.89) 190.54,178.83 190.51,178.79 arc(190.46,178.75) 190.41,178.72 arc(190.35,178.7) 190.29,178.69 189.98,178.69 arc(189.85,178.67) 189.73,178.59 189.64,178.5 arc(189.57,178.4) 189.55,178.28 189.55,177.71 arc(189.5,177.46) 189.36,177.25 189.14,177.04 arc(188.95,176.92) 188.73,176.88 188.6,176.88 arc(188.44,176.85) 188.3,176.75 187.83,176.29 arc(187.43,176.02) 186.96,175.93 184.88,175.93 arc(184.77,175.88) 184.73,175.77 184.73,175.52 arc(184.76,175.45) 184.83,175.42 187.21,175.42 arc(187.43,175.38) 187.61,175.25 arc(187.68,175.15) 187.7,175.04 187.7,175.03 arc(187.76,174.76) DT5.1 187.81,174.43 arc(187.68,174.24) 187.64,174.02 187.64,173.67 arc(187.56,173.48) 187.37,173.4 186.65,173.4 arc(186.5,173.34) 186.43,173.18 arc(186.5,172.82) 186.71,172.51 v2(186.72,172.5)
USB3_A_TRX_DTX_N1: length 31.2
  TOP w0.089: UT1.B15 182.5,169.52 arc(182.56,169.62) 182.59,169.74 182.59,169.94 arc(182.57,170.02) 182.52,170.09 182.22,170.4 arc(182.2,170.43) 182.19,170.46 182.19,170.82 arc(182.12,171.19) 181.91,171.51 181.45,171.97 181.45,171.98 arc(181.43,172) 181.41,172.03 181.39,172.06 arc(181.37,172.1) 181.35,172.13 arc(181.31,172.24) 181.3,172.35 181.3,173.58 arc(181.32,173.68) v2(181.38,173.77)
  BOTTOM w0.089: v2(181.38,173.77) 181.38,173.41 arc(181.35,173.35) 181.29,173.32 181.14,173.32 arc(181.07,173.3) 181.05,173.23 181.05,173.17 arc(181.08,172.98) 181.19,172.83 181.19,172.83 arc(181.63,172.59) 182.13,172.5 183.96,172.5 arc(184.24,172.45) 184.48,172.29 185.09,171.68 arc(185.24,171.58) 185.41,171.54 186.16,171.54 arc(186.44,171.49) 186.67,171.33 188.21,169.79 arc(188.38,169.68) 188.58,169.64 190.07,169.64 arc(190.36,169.58) 190.6,169.42 190.8,169.22 arc(190.83,169.2) 190.86,169.2 194.57,169.2 arc(194.85,169.28) 195.08,169.45 195.69,170.06 arc(195.99,170.51) 196.1,171.05 196.1,173.56 arc(196.07,173.66) 195.99,173.74 arc(195.95,173.74) 195.9,173.74 195.78,173.74 arc(195.77,173.74) 195.76,173.75 arc(195.64,173.84) 195.59,173.99 195.59,174.11 DT9.1 195.75,174.26 arc(195.82,174.37) 195.84,174.49 195.84,175.68 arc(195.81,175.87) 195.7,176.03 194.88,176.85 arc(194.79,176.97) 194.77,177.12 194.77,177.15 arc(194.77,177.16) 194.77,177.17 arc(194.76,177.23) 194.73,177.3 arc(194.73,177.3) 194.73,177.31 arc(194.73,177.32) 194.72,177.32 arc(194.7,177.37) 194.66,177.41 arc(194.61,177.48) 194.6,177.56 JUSBC1.A10
USB3_A_TRX_DTX_P0: length 22.4
  TOP w0.089: v2(186.14,172.5) 186.2,172.44 arc(186.27,172.34) 186.29,172.21 arc(186.29,172.2) 186.29,172.18 arc(186.29,172.18) 186.29,172.18 arc(186.32,172.08) 186.38,171.98 186.4,171.96 arc(186.4,171.96) 186.4,171.95 186.56,171.79 186.56,171.8 186.57,171.79 arc(186.61,171.75) 186.65,171.71 arc(186.91,171.58) 187.21,171.53 187.41,171.53 arc(187.54,171.46) 187.59,171.33 187.59,171.02 arc(187.53,170.89) 187.4,170.84 187.4,170.84 186.74,170.84 arc(186.71,170.85) 186.68,170.87 186.5,171.05 arc(186.44,171.13) 186.36,171.19 arc(186.15,171.27) 185.94,171.3 arc(185.65,171.23) 185.43,171.04 185.39,170.97 185.4,170.95 185.33,170.8 arc(185.32,170.75) 185.31,170.7 arc(185.29,170.55) 185.23,170.41 184.95,170.13 arc(184.91,170.07) 184.9,170 184.9,169.72 arc(184.91,169.65) 184.95,169.58 185.09,169.44 arc(185.11,169.41) UT1.B21
  BOTTOM w0.089: JUSBC1.B11 190.35,179.28 arc(190.36,179.2) 190.41,179.13 arc(190.43,179.1) 190.44,179.06 arc(190.44,179.03) 190.44,179 arc(190.43,178.97) 190.41,178.95 190.38,178.91 arc(190.36,178.9) 190.34,178.88 arc(190.31,178.88) 190.29,178.87 189.98,178.87 arc(189.78,178.83) 189.61,178.72 189.51,178.62 arc(189.41,178.46) 189.37,178.28 189.37,177.71 arc(189.33,177.53) 189.23,177.38 189.01,177.17 arc(188.88,177.09) 188.73,177.06 188.6,177.06 arc(188.37,177.01) 188.17,176.88 187.71,176.41 arc(187.37,176.19) 186.96,176.1 184.88,176.1 arc(184.65,176.01) 184.55,175.77 184.55,175.52 arc(184.63,175.32) 184.83,175.24 187.21,175.24 arc(187.36,175.21) 187.49,175.13 arc(187.51,175.08) 187.52,175.03 187.52,175.03 arc(187.52,175) 187.53,174.97 arc(187.51,174.86) 187.46,174.77 DT4.1 187.28,174.46 arc(187.41,174.26) 187.46,174.02 187.46,173.67 arc(187.43,173.6) 187.37,173.58 186.65,173.58 arc(186.37,173.46) 186.25,173.18 arc(186.27,173) 186.32,172.81 arc(186.32,172.72) 186.28,172.63 v2(186.14,172.5)
USB3_A_TRX_DTX_P1: length 31.2
  TOP w0.089: UT1.A15 182.37,169.83 182.37,169.79 arc(182.33,169.69) 182.23,169.65 arc(182.16,169.69) 182.13,169.76 182.13,170.19 arc(182.12,170.22) 182.1,170.25 182.04,170.31 arc(182.01,170.35) 182,170.4 182,170.46 182,170.46 arc(182,170.46) 182,170.46 182,170.82 arc(181.95,171.12) 181.77,171.38 181.37,171.79 arc(181.36,171.79) 181.35,171.8 arc(181.26,171.92) 181.19,172.05 arc(181.14,172.2) 181.12,172.35 181.12,173.35 arc(181,173.6) v2(180.78,173.77)
  BOTTOM w0.089: JUSBC1.A11 195.1,177.48 arc(195.07,177.36) 195,177.26 arc(194.96,177.2) 194.94,177.12 arc(194.96,177.04) 195,176.97 195.82,176.15 arc(195.97,175.94) 196.02,175.68 196.02,174.82 arc(196.1,174.44) DT8.1 arc(196.28,174.09) 196.28,174.05 196.28,171.05 arc(196.16,170.44) 195.81,169.93 195.21,169.32 arc(194.92,169.12) 194.59,169.02 190.86,169.02 arc(190.76,169.04) 190.67,169.1 190.48,169.3 arc(190.29,169.42) 190.07,169.46 188.58,169.46 arc(188.31,169.52) 188.08,169.67 186.55,171.2 arc(186.37,171.32) 186.16,171.37 185.41,171.37 arc(185.17,171.41) 184.96,171.55 184.35,172.16 arc(184.17,172.28) 183.96,172.33 182.13,172.33 arc(181.57,172.42) 181.07,172.69 181.06,172.7 arc(181.05,172.71) 181.04,172.72 arc(181.03,172.74) 181.01,172.75 arc(180.84,173.01) 180.78,173.31 v2(180.78,173.77)
